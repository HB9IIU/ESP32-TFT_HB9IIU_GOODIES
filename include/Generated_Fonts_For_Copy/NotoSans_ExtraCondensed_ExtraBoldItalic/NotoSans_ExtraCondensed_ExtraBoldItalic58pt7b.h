#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x8F,
  0xF3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xC0, 0x3F, 0x9C, 0x70,
  0x07, 0xF3, 0x82, 0x01, 0xFE, 0x60, 0x00, 0x3F, 0xCC, 0x00, 0x07, 0xFB,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x19, 0xFC, 0x00, 0x07, 0x3F,
  0x81, 0x00, 0xE7, 0xF0, 0x38, 0x1D, 0xFE, 0x07, 0x83, 0x3F, 0xC1, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xC0,
  0x07, 0xE7, 0xF0, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC1, 0xFC, 0x00, 0x7E, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF1, 0xFC, 0x00, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0xCF, 0xE0,
  0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x7F, 0x0F, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7F, 0xE7, 0xE3, 0xF3, 0xF9, 0xFF, 0xEF, 0xFF, 0xC7, 0xE7,
  0xFF, 0xDF, 0xFF, 0x9F, 0x8F, 0xFF, 0x9F, 0xFE, 0x3F, 0x3F, 0xBF, 0xBF,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0xE3, 0xF9, 0xF8, 0x7E, 0x1F, 0x07, 0xE3,
  0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE1, 0xFC,
  0x00, 0xFE, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x07, 0xF0,
  0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xFC,
  0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0xFF, 0x03, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xF3,
  0xFE, 0x1F, 0xFF, 0xFB, 0xFC, 0x3F, 0xEF, 0xFB, 0xFC, 0x3F, 0xCF, 0xFF,
  0xF8, 0x7F, 0xC7, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0x83, 0xFF,
  0xF0, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF1, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC0,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x02, 0x0F, 0xE0, 0x0F, 0x1F, 0xC0,
  0x1F, 0x3F, 0x82, 0x3F, 0xFE, 0x3C, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFE,
  0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF1, 0xFE, 0x03, 0xC1, 0xF8, 0x03, 0x83,
  0xE0, 0x02, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x00, 0x1F, 0x8F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F,
  0xF3, 0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFB, 0xFC, 0x1F,
  0x9F, 0xE0, 0xF9, 0xFF, 0x03, 0x8F, 0xF0, 0x08, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0x07, 0x81, 0xFF,
  0x00, 0x70, 0x1F, 0xF0, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x70, 0x3F, 0xF0,
  0x04, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x80, 0x03, 0xFE, 0x0C,
  0x00, 0x7F, 0xE0, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0x7F, 0x80, 0x03, 0xE7, 0xF8, 0x00, 0x7E, 0xFF, 0x00, 0x0F,
  0xCF, 0xF0, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0x8F, 0xF0, 0x03, 0xF1, 0xFF,
  0x00, 0x3F, 0x1F, 0xE0, 0x07, 0xE1, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x0F,
  0xC1, 0xFE, 0x01, 0xF8, 0x3F, 0xE0, 0x3F, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x38, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x40, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC2, 0x00, 0x3F, 0xE0, 0x80, 0x1F,
  0xF8, 0x3C, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x0E, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x3F,
  0xCF, 0xF8, 0x0F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0x7F, 0xE3, 0xFF, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF9, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF1,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF,
  0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xBF,
  0xC0, 0x3F, 0xDF, 0xF0, 0x03, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x08, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xF1, 0xFF, 0x0C, 0x07, 0xF8,
  0x40, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x0F,
  0xFC, 0x3F, 0x07, 0xE0, 0x7F, 0xFC, 0xFC, 0x1F, 0x83, 0xFF, 0xE1, 0xF0,
  0xFC, 0x1F, 0xFF, 0x87, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0x1F, 0x87, 0xE1,
  0xF8, 0x7C, 0x7E, 0x1F, 0x87, 0xE3, 0xF1, 0xF0, 0xFC, 0x3F, 0x0F, 0xCF,
  0xC3, 0xE0, 0xFC, 0x3F, 0x3E, 0x1F, 0x83, 0xF0, 0xF8, 0xF8, 0x7E, 0x0F,
  0xC3, 0xE7, 0xE1, 0xF0, 0x7E, 0x0F, 0x9F, 0x8F, 0xC1, 0xF8, 0x7E, 0x7C,
  0x3F, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0xFC,
  0x3F, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0xFC, 0x3F, 0x1F, 0xC3, 0xE3, 0xF0,
  0xFC, 0x7F, 0x1F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFC, 0x3F, 0xFB, 0xFF, 0x03, 0xF0, 0x7F, 0xCF, 0xF8, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x10, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0x03, 0x80, 0x7F, 0xE0, 0x10, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x01, 0x00, 0x7F, 0xE0, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x01, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF0, 0x7F, 0xF0, 0x3F, 0xC3, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x70, 0x0F, 0xFE, 0x00, 0x40, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x87, 0xFC, 0x1F,
  0xFF, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF,
  0xF0, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x10, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xEF,
  0xF0, 0x07, 0xF7, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x1F, 0xDF, 0xE0,
  0x0F, 0xF7, 0xF1, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x3F, 0x9F, 0xE0, 0x0F,
  0xF7, 0xF3, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x3F, 0xBF, 0xE0, 0x1F, 0xE7,
  0xF7, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xFF,
  0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xFF, 0xC7,
  0xFC, 0x03, 0xFC, 0x7F, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xFF, 0x87, 0xF8,
  0x03, 0xFC, 0x7F, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFF, 0x8F, 0xF8, 0x07,
  0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xC0, 0x3F, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF,
  0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0x07, 0xF8, 0x07,
  0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF,
  0x00, 0x7F, 0x3F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8, 0xFF, 0x00, 0xFF, 0x3F,
  0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF3, 0xFD, 0xFE, 0x00, 0xFE, 0x1F, 0xDF, 0xE0, 0x1F, 0xE1, 0xFD, 0xFE,
  0x01, 0xFE, 0x1F, 0xDF, 0xC0, 0x1F, 0xE1, 0xFF, 0xFC, 0x01, 0xFE, 0x1F,
  0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF8,
  0x07, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01,
  0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x7F,
  0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE,
  0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x81, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x07,
  0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF,
  0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00,
  0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0x01, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x3F,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0x18, 0x03, 0xFE, 0x00, 0x80, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x3F, 0xE0,
  0x60, 0x03, 0xFE, 0x07, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F,
  0x87, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0xFF, 0x80,
  0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xEF,
  0xF0, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFC, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x07, 0xF8,
  0x7F, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF,
  0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0x8F,
  0xF0, 0x0F, 0xF3, 0xFF, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0xFE, 0x7F, 0xC0,
  0x3F, 0xCF, 0xFF, 0xCF, 0xF0, 0x07, 0xF3, 0xFB, 0xF9, 0xFE, 0x00, 0xFE,
  0x7F, 0x7F, 0x7F, 0xC0, 0x3F, 0xDF, 0xCF, 0xEF, 0xF0, 0x07, 0xFB, 0xF9,
  0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC7, 0xEF,
  0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x0F,
  0xF9, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC,
  0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFC, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x3F, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x3F, 0xF3, 0xFC, 0x0F, 0xFF, 0x7F, 0x81, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xEF,
  0xF0, 0x0F, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0xBF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xF7, 0xFF, 0x80, 0x7F, 0x3F, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC,
  0x18, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x40, 0xFF,
  0x81, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xFD, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xEF, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC1, 0xFE, 0x7F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x20, 0xFF, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFF,
  0xBF, 0xC0, 0x1F, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x61, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x03, 0x00, 0x1F, 0xF0,
  0x0F, 0x81, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE7, 0xF0, 0x03, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x9F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0xFF, 0xC7,
  0xFE, 0x01, 0xF9, 0xFF, 0xCF, 0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xF9, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0xF8, 0x07, 0xE7, 0xFF, 0x00, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB,
  0xFE, 0x07, 0xFD, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x07,
  0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x07,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x1F, 0xF1, 0xFC, 0x07, 0xFF, 0x7F, 0x81, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xEF,
  0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x03,
  0xF9, 0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x9F, 0x07,
  0xFC, 0x0C, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x20, 0x0F, 0xF8, 0xE0, 0x7F,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x05, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0x20, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0xF7, 0xF0, 0x0F, 0xFC, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xF0, 0x3F, 0xDF, 0xC1, 0xFF, 0x83, 0xFC, 0xFE, 0x0F, 0xFC,
  0x1F, 0xE7, 0xF0, 0x7F, 0xE0, 0xFF, 0x3F, 0x87, 0xFF, 0x0F, 0xF1, 0xFC,
  0x3F, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xFF, 0x8F, 0xE1, 0xFE, 0x7E,
  0xFC, 0xFF, 0x0F, 0xF3, 0xF7, 0xE7, 0xF0, 0x7F, 0xBF, 0xFF, 0x7F, 0x83,
  0xFD, 0xFB, 0xFB, 0xFC, 0x1F, 0xEF, 0xDF, 0xDF, 0xC0, 0xFF, 0xFE, 0xFF,
  0xFE, 0x07, 0xFF, 0xE7, 0xEF, 0xE0, 0x3F, 0xBF, 0x3F, 0x7F, 0x01, 0xFF,
  0xF9, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x67,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x9F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x40, 0x03, 0xFF, 0x20, 0x00, 0x0C,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 17, 42, 15, 0, -41 },
  { 91, 22, 15, 24, 5, -41 },
  { 133, 31, 41, 29, 0, -41 },
  { 292, 27, 47, 26, 0, -44 },
  { 451, 39, 43, 43, 3, -42 },
  { 661, 32, 43, 32, 0, -42 },
  { 833, 10, 15, 14, 6, -41 },
  { 852, 20, 51, 16, 1, -42 },
  { 980, 20, 51, 16, -5, -42 },
  { 1108, 23, 26, 25, 4, -45 },
  { 1183, 25, 28, 28, 2, -35 },
  { 1271, 13, 16, 14, -3, -8 },
  { 1297, 15, 7, 17, 1, -19 },
  { 1311, 10, 10, 14, 0, -9 },
  { 1324, 30, 43, 22, -3, -42 },
  { 1486, 25, 43, 26, 1, -42 },
  { 1621, 21, 41, 26, 5, -41 },
  { 1729, 28, 42, 26, -2, -42 },
  { 1876, 28, 43, 26, -1, -42 },
  { 2027, 28, 42, 26, -1, -42 },
  { 2174, 26, 42, 26, 1, -41 },
  { 2311, 26, 43, 26, 2, -42 },
  { 2451, 27, 41, 26, 2, -41 },
  { 2590, 27, 43, 26, 0, -42 },
  { 2736, 26, 43, 26, 0, -42 },
  { 2876, 15, 33, 15, 0, -32 },
  { 2938, 18, 40, 15, -3, -32 },
  { 3028, 25, 28, 28, 2, -35 },
  { 3116, 25, 19, 28, 2, -30 },
  { 3176, 25, 28, 28, 2, -35 },
  { 3264, 21, 43, 20, 2, -42 },
  { 3377, 38, 47, 39, 1, -42 },
  { 3601, 28, 42, 29, -3, -42 },
  { 3748, 29, 41, 29, 0, -41 },
  { 3897, 28, 43, 26, 2, -42 },
  { 4048, 30, 41, 31, 0, -41 },
  { 4202, 27, 41, 24, 0, -41 },
  { 4341, 27, 41, 23, 0, -41 },
  { 4480, 31, 43, 31, 2, -42 },
  { 4647, 34, 41, 32, 0, -41 },
  { 4822, 26, 41, 20, -2, -41 },
  { 4956, 26, 54, 15, -9, -41 },
  { 5132, 34, 41, 28, 0, -41 },
  { 5307, 20, 41, 23, 0, -41 },
  { 5410, 44, 41, 42, 0, -41 },
  { 5636, 36, 41, 34, 0, -41 },
  { 5821, 30, 43, 32, 2, -42 },
  { 5983, 29, 41, 27, 0, -41 },
  { 6132, 30, 52, 32, 2, -42 },
  { 6327, 29, 41, 28, 0, -41 },
  { 6476, 28, 43, 24, -1, -42 },
  { 6627, 24, 41, 24, 4, -41 },
  { 6750, 31, 42, 31, 2, -41 },
  { 6913, 29, 41, 28, 5, -41 },
  { 7062, 43, 41, 42, 4, -41 },
  { 7283, 34, 41, 27, -3, -41 },
  { 7458, 27, 41, 26, 5, -41 },
  { 7597, 30, 41, 24, -2, -41 },
  { 7751, 24, 51, 17, -3, -42 },
  { 7904, 13, 43, 22, 6, -42 },
  { 7974, 23, 51, 17, -4, -42 },
  { 8121, 27, 26, 26, -1, -41 },
  { 8209, 22, 6, 20, -6, 4 },
  { 8226, 12, 9, 18, 8, -44 },
  { 8240, 27, 33, 27, 1, -32 },
  { 8352, 28, 45, 27, -1, -44 },
  { 8510, 23, 33, 22, 1, -32 },
  { 8605, 30, 45, 27, 1, -44 },
  { 8774, 24, 33, 26, 1, -32 },
  { 8873, 31, 58, 17, -7, -44 },
  { 9098, 30, 46, 27, -2, -32 },
  { 9271, 27, 44, 27, -1, -44 },
  { 9420, 18, 45, 14, -1, -45 },
  { 9522, 24, 59, 14, -7, -45 },
  { 9699, 30, 44, 26, -1, -44 },
  { 9864, 18, 44, 14, -1, -44 },
  { 9963, 40, 32, 40, -1, -32 },
  { 10123, 27, 32, 27, -1, -32 },
  { 10231, 25, 33, 27, 1, -32 },
  { 10335, 30, 46, 27, -3, -32 },
  { 10508, 27, 46, 27, 1, -32 },
  { 10664, 23, 32, 19, -1, -32 },
  { 10756, 22, 33, 22, 0, -32 },
  { 10847, 18, 39, 18, 2, -38 },
  { 10935, 27, 33, 27, 1, -32 },
  { 11047, 24, 32, 25, 4, -32 },
  { 11143, 37, 32, 37, 3, -32 },
  { 11291, 31, 32, 25, -3, -32 },
  { 11415, 32, 46, 25, -4, -32 },
  { 11599, 25, 32, 21, -2, -32 },
  { 11699, 24, 50, 20, 0, -41 },
  { 11849, 7, 58, 22, 7, -45 },
  { 11900, 22, 50, 20, -3, -41 },
  { 12038, 25, 11, 28, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC58PT7B_H_
