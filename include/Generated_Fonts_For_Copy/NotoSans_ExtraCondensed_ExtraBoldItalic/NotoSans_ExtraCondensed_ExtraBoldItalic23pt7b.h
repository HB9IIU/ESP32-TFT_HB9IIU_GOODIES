#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE0, 0x00, 0x06,
  0x1E, 0x3C, 0x70, 0x77, 0xBB, 0x9D, 0xDC, 0xEE, 0x77, 0x30, 0x07, 0x70,
  0x66, 0x06, 0x60, 0xEE, 0x3F, 0xF3, 0xFF, 0x1D, 0xC1, 0x98, 0x19, 0x8F,
  0xFE, 0xFF, 0xC3, 0x30, 0x77, 0x07, 0x60, 0x66, 0x0E, 0xE0, 0x01, 0x00,
  0xF0, 0x7F, 0x8F, 0xE3, 0xAC, 0x74, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xC4, 0xB9, 0xFF, 0x3F, 0xC3, 0xF0, 0x10, 0x02, 0x00, 0x0C,
  0x04, 0x3E, 0x18, 0x3E, 0x38, 0x66, 0x30, 0x66, 0x60, 0xE6, 0xE0, 0xEE,
  0xC0, 0xED, 0xDE, 0xFD, 0xBE, 0x7B, 0xB7, 0x33, 0x77, 0x07, 0x66, 0x06,
  0x66, 0x0E, 0x66, 0x1C, 0x6E, 0x18, 0x7C, 0x38, 0x78, 0x03, 0x00, 0x7E,
  0x03, 0xF8, 0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x79,
  0xFB, 0x9D, 0xDD, 0xEF, 0xCE, 0x3E, 0x71, 0xE3, 0xFF, 0x1F, 0xFC, 0x7D,
  0xE0, 0x77, 0x7E, 0xEE, 0x07, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70,
  0x70, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x18, 0x0E,
  0x27, 0x1F, 0xAF, 0xF9, 0xFC, 0xF1, 0xFC, 0x6F, 0x13, 0x00, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0, 0x6F, 0xFE, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x0F, 0xCF, 0xE7, 0x77, 0xBB, 0x9D, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xEE, 0x77, 0x7B, 0xF9, 0xF8, 0x78, 0x00, 0x0F, 0x1F, 0x3F, 0x7E, 0xFE,
  0x6E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x01,
  0x81, 0xFC, 0x7F, 0x8E, 0x70, 0x8E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1F, 0xE3, 0xFC, 0xFF, 0x80, 0x07,
  0x03, 0xF8, 0x7F, 0x0C, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0xFC, 0x1E, 0x03,
  0xF0, 0x1E, 0x01, 0xC0, 0x39, 0x0F, 0x3F, 0xC7, 0xF8, 0xFC, 0x00, 0x01,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xFC, 0x3F, 0x06, 0xE1, 0x9C, 0x73, 0x8C,
  0xF3, 0xFF, 0x7F, 0xEF, 0xF8, 0x1E, 0x03, 0x80, 0x70, 0x0F, 0xE3, 0xF8,
  0x7F, 0x0E, 0x03, 0xC0, 0x74, 0x0F, 0xE1, 0xFC, 0x27, 0x80, 0x70, 0x0E,
  0x01, 0xC8, 0x79, 0xFE, 0x3F, 0xC7, 0xE0, 0x03, 0xC3, 0xF1, 0xFC, 0xF0,
  0x38, 0x1C, 0x07, 0x63, 0xFC, 0xFF, 0xBD, 0xEE, 0x7B, 0x9E, 0xE7, 0x39,
  0xCF, 0xF3, 0xF8, 0x7C, 0x00, 0x3F, 0xEF, 0xF9, 0xFF, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9E, 0xF3, 0x9E, 0x73, 0x8F,
  0xF0, 0xFC, 0x1F, 0x07, 0xF1, 0xEE, 0x79, 0xCE, 0x39, 0xC7, 0x3D, 0xE3,
  0xF8, 0x7E, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0xF7, 0x39, 0xCE, 0x77, 0x9D,
  0xEF, 0x7F, 0xCF, 0xF3, 0xF8, 0x0E, 0x07, 0x81, 0xCF, 0xF3, 0xF8, 0xF8,
  0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x3C, 0xE0, 0x0C,
  0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x0E, 0x38,
  0x70, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7E, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0xFC, 0xFC, 0xFC,
  0x3C, 0x0C, 0x00, 0x0C, 0x7F, 0x7F, 0x67, 0x07, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0x70, 0x70, 0x00, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0xC0, 0x0F, 0xF0,
  0x3C, 0xE0, 0xE0, 0x63, 0x80, 0xCE, 0x7D, 0x99, 0xFB, 0xF7, 0x76, 0xCC,
  0xCD, 0x99, 0x9B, 0x73, 0x36, 0xEE, 0xCD, 0xFF, 0x99, 0xDE, 0x30, 0x00,
  0x60, 0x00, 0xF0, 0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x6E, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF7, 0x8E, 0xE1, 0xFC, 0x3F, 0x07, 0x1F, 0xE1, 0xFE, 0x1C, 0xF1, 0xCF,
  0x3C, 0xE3, 0x9E, 0x3F, 0xC3, 0xF8, 0x7F, 0xC7, 0x9C, 0x71, 0xC7, 0x1C,
  0x73, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0x03, 0x81, 0xFC, 0x7F, 0x1F, 0x63,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xE2, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xCF,
  0x3C, 0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x78, 0xF7, 0x8E, 0x71, 0xE7, 0x1E,
  0x73, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xFE, 0x3F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xFC, 0x7F, 0x0F, 0xE1, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0x01, 0xC0, 0xFF, 0x1F, 0xE3, 0xE6, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF3, 0xEF, 0x7E, 0xE7, 0xCE, 0x1C, 0xE1, 0xCF, 0x3C, 0xFF,
  0x87, 0xF8, 0x3F, 0x00, 0x1E, 0x38, 0xE1, 0xC7, 0x1E, 0x38, 0xF3, 0xC7,
  0x1E, 0x38, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xC7, 0x1C, 0x38, 0xE3, 0xC7,
  0x1E, 0x78, 0xE3, 0xC7, 0x1C, 0x78, 0x1F, 0xE1, 0xF8, 0x1C, 0x03, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x3F, 0x87, 0xF0, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x1E, 0x78, 0xE7,
  0x87, 0x38, 0x3B, 0xC3, 0xFC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xFC, 0x1D, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0xCF, 0x1C, 0x78, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xE3,
  0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xDC, 0x7E, 0xFE, 0x3F, 0x7E, 0x3B, 0xF7,
  0x1D, 0xFB, 0x8E, 0xF9, 0xC7, 0x7D, 0xE7, 0xBC, 0xE3, 0x9E, 0x71, 0xCE,
  0x38, 0x1E, 0x1C, 0x78, 0x71, 0xF3, 0xC7, 0xCE, 0x3F, 0x38, 0xFC, 0xE3,
  0xF3, 0x8E, 0xDE, 0x3B, 0xF1, 0xCF, 0xC7, 0x3F, 0x1C, 0xFC, 0x73, 0xE3,
  0xC7, 0x8E, 0x1E, 0x38, 0x78, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0xCF, 0x38,
  0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xE1, 0xEE, 0x1E, 0xE1,
  0xCF, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1,
  0xCF, 0x3C, 0xF3, 0xCE, 0x39, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xE3,
  0xCF, 0x38, 0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xE1, 0xEE,
  0x1E, 0xE1, 0xCF, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x1F, 0xC3, 0xFC, 0x77, 0x8E, 0x73, 0xCE, 0x71, 0xCE,
  0x79, 0xFE, 0x3F, 0x8F, 0xE1, 0xDE, 0x3B, 0xC7, 0x39, 0xE7, 0x3C, 0xF7,
  0x1E, 0x03, 0x81, 0xFC, 0x7F, 0x1F, 0xE3, 0xC4, 0x70, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x79, 0x0F, 0x3F, 0xC7, 0xF0, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0x3C, 0xF3, 0x8F, 0x38, 0xE7,
  0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xE7, 0x1C, 0xF1, 0xCF, 0x1C, 0xE3, 0xCE,
  0x3C, 0xE3, 0x8F, 0xF8, 0xFF, 0x07, 0xE0, 0xF1, 0xFC, 0x3B, 0x87, 0x71,
  0xEE, 0x39, 0xCF, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xE1, 0xC7, 0xF1, 0xE3, 0xB8, 0xF3, 0xDC,
  0xF9, 0xCE, 0x7D, 0xE7, 0x3E, 0xE3, 0xBE, 0x71, 0xDF, 0x78, 0xFD, 0xB8,
  0x7E, 0xDC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xC3, 0xC0, 0x1E, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xFC, 0x07,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xBC,
  0x3D, 0xE1, 0xC7, 0x1C, 0x38, 0xF1, 0xFE, 0x73, 0xCE, 0x3B, 0x87, 0x70,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0xF8,
  0xFF, 0x8F, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3F,
  0x1F, 0x0F, 0x80, 0xE7, 0x18, 0xE7, 0x39, 0xCE, 0x73, 0x8C, 0x73, 0x9C,
  0xE7, 0x38, 0x07, 0xC3, 0xE0, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x03, 0x01, 0xC0, 0xF8, 0x3E, 0x1F, 0x8E,
  0x63, 0x9D, 0xC7, 0x71, 0xF8, 0x70, 0xFF, 0xFF, 0xF3, 0x9E, 0x70, 0x0E,
  0xE3, 0xDC, 0xFF, 0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0x73, 0x9E, 0xF3, 0x9E,
  0x73, 0xFE, 0x3F, 0xC7, 0xB8, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xD8,
  0x7F, 0x8F, 0xF1, 0xCF, 0x39, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x3C, 0xE7,
  0x3F, 0xE7, 0xF8, 0xEE, 0x00, 0x07, 0x8F, 0xCF, 0xE7, 0x17, 0x83, 0x81,
  0xC0, 0xE0, 0xF0, 0x78, 0x9F, 0x8F, 0xC3, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x0E, 0xE1, 0xFE, 0x3F, 0xE3, 0x9C, 0x79, 0xC7, 0x1C, 0x71,
  0xC7, 0x3C, 0xF3, 0x8F, 0x38, 0xFF, 0x87, 0xF8, 0x7B, 0x80, 0x07, 0x07,
  0xE3, 0xFC, 0xE7, 0x71, 0xDF, 0xE7, 0xF1, 0xF0, 0xF0, 0x3C, 0x07, 0x31,
  0xFC, 0x3F, 0x00, 0x00, 0x60, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0x80, 0x3E,
  0x0F, 0xE0, 0xFC, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xBC, 0x0F, 0x80,
  0xF8, 0x02, 0x00, 0x07, 0x70, 0xFF, 0x1F, 0xF1, 0xCE, 0x3C, 0xE3, 0x8E,
  0x38, 0xE3, 0x9E, 0x79, 0xC7, 0x9C, 0x7F, 0xC3, 0xFC, 0x3F, 0xC0, 0x38,
  0x03, 0x8C, 0x78, 0xFF, 0x0F, 0xE0, 0x10, 0x00, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3F, 0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xDE, 0x77, 0x1D, 0xCF, 0x73,
  0x9C, 0xEF, 0x3B, 0x8E, 0xE7, 0x80, 0x0C, 0x3C, 0x70, 0xE0, 0x07, 0x8E,
  0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0xE1, 0xC0, 0x01, 0x80,
  0xF0, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0xB8,
  0x3E, 0x0F, 0x01, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0xF3,
  0x9E, 0x39, 0xC3, 0xB8, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0xE7, 0x8E, 0x78, 0xE3, 0x80, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E,
  0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE0, 0x3B, 0x8E, 0x3F,
  0xFE, 0x3F, 0xFF, 0x39, 0xEF, 0x39, 0xCE, 0x79, 0xCE, 0x73, 0xCE, 0x73,
  0x8E, 0x73, 0x9E, 0x73, 0x9C, 0xF3, 0x9C, 0xE7, 0x9C, 0xE7, 0x3C, 0x39,
  0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xDE, 0x77, 0x1D, 0xCF, 0x73, 0x9C, 0xEF,
  0x3B, 0x8E, 0xE7, 0x80, 0x07, 0x07, 0xE3, 0xFC, 0xE7, 0x79, 0xDC, 0x77,
  0x1D, 0xC7, 0xF3, 0xFC, 0xE7, 0xF9, 0xFC, 0x3E, 0x00, 0x1C, 0xC1, 0xFE,
  0x1F, 0xE1, 0xCF, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x39, 0xE3, 0x9C,
  0x7F, 0xC7, 0xF8, 0x77, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0xE3, 0xFC, 0xFF, 0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0x73,
  0x9E, 0xF3, 0x9E, 0x73, 0xFE, 0x3F, 0xC7, 0xF8, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x00, 0x3B, 0x9F, 0xCF, 0xC7, 0xE3, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x00, 0x1F, 0x1F, 0xCF, 0xCF,
  0x27, 0x83, 0xE0, 0xF8, 0x3C, 0x0E, 0x47, 0x3F, 0x9F, 0xCF, 0xC0, 0x1C,
  0x30, 0xFF, 0xFF, 0xEE, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0F, 0x9F, 0x3E,
  0x00, 0x3C, 0xE7, 0x1C, 0xE7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9C, 0x73, 0x9E,
  0x73, 0x8E, 0x73, 0xFE, 0x3F, 0xC7, 0xB0, 0xF1, 0xFC, 0xFF, 0x39, 0xDE,
  0x77, 0x1D, 0xC7, 0xE1, 0xB8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x00,
  0xF3, 0xCF, 0xEF, 0x3F, 0x9E, 0x77, 0x3C, 0xEE, 0xFB, 0x9D, 0xB7, 0x3B,
  0x6E, 0x7E, 0xF8, 0xF9, 0xF1, 0xF7, 0xC3, 0xEF, 0x87, 0x9F, 0x0F, 0x3C,
  0x00, 0x1C, 0xF1, 0xCE, 0x1D, 0xE1, 0xDC, 0x0F, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x03, 0xF8, 0x7B, 0x87, 0x38, 0xF3, 0x80, 0x1E, 0x38, 0x73,
  0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x0B, 0x80, 0x7C,
  0x03, 0xC0, 0x28, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0xF3, 0xFC, 0xFF, 0x00, 0x07, 0xC3, 0xE0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x7C, 0x3C, 0x0F, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x83, 0x87, 0xC3, 0xC3, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x7C, 0x3C, 0x18, 0x00, 0xF8, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 12, 16, 12, 0, -16 },
  { 46, 11, 18, 10, 0, -17 },
  { 71, 16, 17, 17, 1, -17 },
  { 105, 13, 17, 13, 0, -17 },
  { 133, 4, 6, 6, 2, -16 },
  { 136, 8, 21, 6, 0, -17 },
  { 157, 8, 21, 6, -2, -17 },
  { 178, 9, 10, 10, 2, -18 },
  { 190, 10, 11, 11, 1, -14 },
  { 204, 5, 6, 6, -1, -3 },
  { 208, 7, 3, 7, 0, -8 },
  { 211, 4, 4, 6, 0, -4 },
  { 213, 12, 17, 9, -1, -17 },
  { 239, 9, 17, 10, 1, -17 },
  { 259, 8, 16, 10, 2, -16 },
  { 275, 11, 17, 10, -1, -17 },
  { 299, 11, 17, 10, 0, -17 },
  { 323, 11, 16, 10, 0, -16 },
  { 345, 11, 16, 10, 0, -16 },
  { 367, 10, 17, 10, 1, -17 },
  { 389, 11, 16, 10, 1, -16 },
  { 411, 11, 17, 10, 0, -17 },
  { 435, 10, 17, 10, 0, -17 },
  { 457, 6, 13, 6, 0, -13 },
  { 467, 7, 16, 6, -1, -13 },
  { 481, 10, 11, 11, 1, -14 },
  { 495, 10, 8, 11, 1, -12 },
  { 505, 10, 11, 11, 1, -14 },
  { 519, 8, 17, 8, 1, -17 },
  { 536, 15, 19, 16, 1, -17 },
  { 572, 11, 16, 11, -1, -16 },
  { 594, 12, 16, 11, 0, -16 },
  { 618, 11, 17, 10, 1, -17 },
  { 642, 12, 16, 12, 0, -16 },
  { 666, 11, 16, 9, 0, -16 },
  { 688, 11, 16, 9, 0, -16 },
  { 710, 12, 17, 12, 1, -17 },
  { 736, 13, 16, 13, 0, -16 },
  { 762, 11, 16, 8, -1, -16 },
  { 784, 11, 21, 6, -4, -16 },
  { 813, 13, 16, 11, 0, -16 },
  { 839, 8, 16, 9, 0, -16 },
  { 855, 17, 16, 16, 0, -16 },
  { 889, 14, 16, 13, 0, -16 },
  { 917, 12, 17, 13, 1, -17 },
  { 943, 12, 16, 11, 0, -16 },
  { 967, 12, 21, 13, 1, -17 },
  { 999, 11, 16, 11, 0, -16 },
  { 1021, 11, 17, 10, 0, -17 },
  { 1045, 9, 16, 9, 2, -16 },
  { 1063, 12, 16, 12, 1, -16 },
  { 1087, 11, 16, 11, 2, -16 },
  { 1109, 17, 16, 17, 2, -16 },
  { 1143, 13, 16, 11, -1, -16 },
  { 1169, 11, 16, 10, 2, -16 },
  { 1191, 12, 16, 9, -1, -16 },
  { 1215, 9, 21, 7, -1, -17 },
  { 1239, 5, 17, 9, 2, -17 },
  { 1250, 10, 21, 7, -2, -17 },
  { 1277, 10, 10, 10, 0, -16 },
  { 1290, 8, 2, 8, -2, 2 },
  { 1292, 5, 4, 7, 3, -18 },
  { 1295, 11, 13, 11, 0, -13 },
  { 1313, 11, 17, 11, 0, -17 },
  { 1337, 9, 13, 9, 0, -13 },
  { 1352, 12, 17, 11, 0, -17 },
  { 1378, 10, 13, 10, 0, -13 },
  { 1395, 12, 24, 7, -3, -18 },
  { 1431, 12, 19, 11, -1, -13 },
  { 1460, 10, 17, 11, 0, -17 },
  { 1482, 7, 18, 6, 0, -18 },
  { 1498, 10, 24, 6, -3, -18 },
  { 1528, 12, 17, 10, 0, -17 },
  { 1554, 7, 17, 5, 0, -17 },
  { 1569, 16, 13, 16, 0, -13 },
  { 1595, 10, 13, 11, 0, -13 },
  { 1612, 10, 13, 11, 0, -13 },
  { 1629, 12, 19, 11, -1, -13 },
  { 1658, 11, 19, 11, 0, -13 },
  { 1685, 9, 13, 8, 0, -13 },
  { 1700, 9, 13, 9, 0, -13 },
  { 1715, 7, 15, 7, 1, -15 },
  { 1729, 11, 13, 11, 0, -13 },
  { 1747, 10, 13, 10, 1, -13 },
  { 1764, 15, 13, 15, 1, -13 },
  { 1789, 12, 13, 10, -1, -13 },
  { 1809, 13, 19, 10, -2, -13 },
  { 1840, 10, 13, 8, -1, -13 },
  { 1857, 10, 20, 8, 0, -16 },
  { 1882, 3, 23, 9, 3, -18 },
  { 1891, 9, 20, 8, -1, -16 },
  { 1914, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC23PT7B_H_
