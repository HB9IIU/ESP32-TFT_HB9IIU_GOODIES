#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7B, 0xEF, 0x7B, 0xCF, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x3C,
  0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xE7, 0x0F,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x1C, 0xE0, 0x39, 0xC0, 0xE7, 0x07, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFE, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xCE, 0x03,
  0x9C, 0x0F, 0x78, 0x00, 0x00, 0x40, 0x01, 0x00, 0x3F, 0x01, 0xFF, 0x0F,
  0xF8, 0x7F, 0xE1, 0xF9, 0x07, 0x60, 0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x2F, 0x10, 0xBC, 0x66, 0xE1, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x1E, 0x07,
  0x07, 0xE0, 0xE1, 0xFC, 0x38, 0x3B, 0x87, 0x0E, 0x71, 0xC1, 0xCE, 0x78,
  0x39, 0xCE, 0x07, 0x3B, 0xC0, 0xEF, 0x73, 0x9D, 0xDC, 0xFB, 0xFB, 0xBF,
  0xFE, 0xEF, 0x77, 0x9D, 0xCE, 0x07, 0x39, 0xC1, 0xEF, 0x38, 0x39, 0xCE,
  0x0F, 0x39, 0xC1, 0xC7, 0x38, 0x70, 0xFE, 0x0E, 0x0F, 0xC3, 0x81, 0xF0,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xCF, 0x3F, 0xDE,
  0x7F, 0xDE, 0x7B, 0xFC, 0xF1, 0xFC, 0xF1, 0xF8, 0xF0, 0xF8, 0xFB, 0xF8,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x7C, 0x7B, 0xDF, 0xEF, 0x7B, 0x9C, 0x03,
  0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x47, 0x07, 0x72, 0xFF,
  0xEF, 0xFE, 0x0F, 0xF1, 0xF0, 0x3F, 0x87, 0xBC, 0x33, 0xC1, 0x10, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1E, 0x3C, 0xF1, 0xE3,
  0xCF, 0x1E, 0x78, 0x7F, 0x7F, 0x7F, 0xFF, 0x33, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x3C,
  0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0x78, 0xFF, 0x8F, 0xF1, 0xFF, 0x1E, 0xF1,
  0xEF, 0x1E, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0xF8, 0xFF, 0x8F, 0xF0, 0x7E,
  0x00, 0x03, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0x9F, 0xEF, 0xF9, 0xBC, 0x4F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0E,
  0x3C, 0x10, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF0,
  0x87, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x83, 0xE7, 0x7F, 0x3F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0xC1, 0xDE, 0x0E, 0xF0, 0xEF, 0x0E, 0x78, 0x73, 0xC7,
  0x1E, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x04, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x83, 0xE3, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xE1, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x30, 0x7B, 0xC3, 0xFF, 0x3F, 0xF9, 0xF3, 0xCF,
  0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xF0, 0xFF,
  0x03, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xDE, 0x1E,
  0x7C, 0x79, 0xE1, 0xE7, 0x87, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0xFC, 0x0F,
  0xF8, 0x3D, 0xE1, 0xE7, 0xCF, 0x8F, 0x3C, 0x3C, 0xF1, 0xF3, 0xE7, 0x8F,
  0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x3F, 0xF1,
  0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xE7, 0xCF, 0xFE, 0x7F,
  0xE3, 0xFF, 0x0E, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC4, 0x7E, 0x3F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x00, 0x0E, 0x3C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x87, 0x9F, 0x3E, 0x78, 0x03, 0x83, 0xC3, 0xE1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0xF0, 0x78,
  0x38, 0x3C, 0x1E, 0x1E, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFF, 0x3F,
  0xCF, 0xE0, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0x1F, 0xF2, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x61, 0x8E, 0x3F, 0x3B,
  0x8F, 0xE7, 0x73, 0x9C, 0xCE, 0xE3, 0x9B, 0x9C, 0xE7, 0x73, 0x9C, 0xEE,
  0x63, 0x9D, 0xDC, 0x73, 0x33, 0x9C, 0xE6, 0x7F, 0xF8, 0xC7, 0xFE, 0x1C,
  0x63, 0x83, 0x80, 0x00, 0x78, 0x00, 0x07, 0x83, 0x00, 0x7F, 0xE0, 0x07,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x78,
  0xF0, 0xF1, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x3E, 0x3E, 0x78, 0x7D,
  0xF0, 0xFB, 0xC1, 0xFF, 0x83, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0xF8, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xCF, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C,
  0x78, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0x10, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x43, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x1E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xF3, 0xC3, 0xCF,
  0x8F, 0x9F, 0x1F, 0x3C, 0x7C, 0x79, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xF0, 0x47, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF1, 0xFB, 0xE7, 0xF7, 0xCF, 0xEF,
  0x9F, 0x9F, 0x0F, 0x3E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xC1,
  0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F,
  0x0F, 0x80, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x17, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0x0F, 0x87, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC1, 0xF7, 0xC0,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xF0, 0x3C, 0xF8, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x80, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1D,
  0xCF, 0xF0, 0xF7, 0x3F, 0xC3, 0xDC, 0xEF, 0x0F, 0x77, 0xF8, 0x3D, 0xDD,
  0xE1, 0xE7, 0xF7, 0x87, 0x9F, 0x9E, 0x1E, 0x7E, 0x78, 0x79, 0xF3, 0xC1,
  0xE7, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE7, 0xC0, 0x0F,
  0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x78, 0x3F, 0x1E, 0x1F, 0xC7, 0x87, 0xF1,
  0xE1, 0xFC, 0x78, 0x7F, 0x3C, 0x1D, 0xCF, 0x0F, 0x7B, 0xC3, 0xDE, 0xF0,
  0xF7, 0xBC, 0x3D, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78,
  0xFC, 0x1E, 0x3F, 0x0F, 0x0F, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x07,
  0xBE, 0x0F, 0x7C, 0x3E, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xDF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0x83, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE1, 0xF3,
  0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C, 0xF8, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x3E,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x7C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x1F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C,
  0xFB, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFF, 0x87, 0x9E, 0x1E, 0x78,
  0x79, 0xE1, 0xE7, 0xCF, 0x9F, 0x3C, 0x3C, 0xF0, 0xF0, 0x01, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x61, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8,
  0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C, 0xF0, 0xF3,
  0xC7, 0xCF, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x3D, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x3E, 0x3E,
  0xF1, 0xF1, 0xEF, 0x8F, 0x8F, 0x78, 0xFC, 0xF3, 0xC7, 0xE7, 0x9E, 0x7F,
  0x3C, 0xF3, 0xFB, 0xC7, 0x9F, 0x9E, 0x3D, 0xFD, 0xF1, 0xEE, 0xEF, 0x0F,
  0xF7, 0x78, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x00,
  0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x7C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0,
  0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0x7C, 0x00,
  0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0xDE, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF3, 0xCF, 0x3C, 0xF1, 0xC7, 0x1C,
  0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8F, 0x3C, 0xF3, 0xCF, 0x3C, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x00, 0xC0, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0xC3, 0xDE, 0x1C, 0xF1, 0xE3, 0x9E, 0x1C, 0xF0, 0xFF, 0x07, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0xF9, 0xE3, 0xCF, 0x07, 0xBC, 0x7E, 0xF1, 0xFF,
  0xCF, 0xBE, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0xCF, 0x8F, 0x3E, 0x7C, 0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0x78, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x7B, 0xC3, 0xFF,
  0x1F, 0xF9, 0xFF, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x3D, 0xE1, 0xEF,
  0x1F, 0x78, 0xF3, 0xC7, 0xBF, 0x79, 0xFF, 0xCF, 0xFC, 0x73, 0xC0, 0x0F,
  0xC3, 0xFC, 0xFF, 0x3F, 0x67, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x4F, 0x31, 0xFE, 0x3F, 0xC3, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x81, 0xEF, 0x07, 0xFE,
  0x1F, 0xFC, 0x7D, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xF3, 0xE3, 0xEF, 0x83, 0xFF, 0x07, 0xFE,
  0x07, 0xBC, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7, 0xCF, 0x78, 0xEF, 0x9E,
  0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x8F, 0xF8,
  0x7F, 0x83, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xA0, 0x1E,
  0x00, 0x3C, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xDE,
  0x0F, 0xFC, 0x3F, 0xF8, 0xFB, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1F, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xE3, 0xE7, 0xC7, 0xDF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0x78, 0x01, 0xF0, 0x03, 0xC2, 0x07, 0x87, 0xBF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x7B, 0xC3, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF, 0x9E,
  0x78, 0xF3, 0xC7, 0x9E, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0xBE,
  0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF0, 0x07, 0x0F, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x8F, 0x8F, 0x3E, 0x1E, 0xF8, 0x79, 0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0xC3, 0xCF, 0x87,
  0x8F, 0x0F, 0x1E, 0x1E, 0x3E, 0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x80, 0x1C, 0xF3, 0xE1, 0xDF, 0xFE,
  0x1F, 0xFF, 0xF3, 0xFF, 0xDF, 0x3E, 0x79, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE3, 0xCF, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3E, 0x78, 0xF3, 0xC7, 0x9E,
  0x3C, 0xF9, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3E, 0x78, 0x1C,
  0xF0, 0xEF, 0xC7, 0xFE, 0x7F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9E,
  0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xEF, 0x9E, 0x78, 0xF3, 0xC7, 0x9E,
  0x3C, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xFF, 0x8F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x3E, 0xF7, 0xCF, 0xFC, 0x7F, 0x83,
  0xE0, 0x07, 0x3C, 0x0E, 0xFC, 0x1F, 0xF8, 0x7E, 0xF0, 0xF9, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xF1, 0xE3,
  0xF7, 0x87, 0xFF, 0x0F, 0xFC, 0x1E, 0xF0, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xBC, 0x3F,
  0xF1, 0xFF, 0x8F, 0xBE, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x3C, 0x78,
  0xF1, 0xE3, 0xCF, 0x8F, 0x3E, 0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x0F,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x00, 0x1C, 0xE3, 0xBC, 0x7F, 0x9F, 0xE3, 0xF4, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0x0F, 0xC3, 0xFC, 0xFF, 0x9E, 0x63, 0xC0, 0x78, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x1E, 0x43, 0xCC, 0xF9, 0xFF, 0x3F, 0xC7, 0xF0, 0x0E, 0x07,
  0x07, 0x87, 0xF7, 0xFB, 0xFE, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE4, 0xFE, 0x7F, 0x1F, 0x80, 0x3C, 0x79, 0xE3, 0xCF,
  0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xE7, 0xCF, 0x7C, 0x7F, 0xE3, 0xFF, 0x0F, 0x78, 0xF0, 0xFF,
  0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0xF1,
  0xEF, 0x3E, 0x3D, 0xE7, 0xCF, 0x3D, 0xF9, 0xE7, 0xBF, 0x38, 0xF7, 0xEF,
  0x1D, 0xDD, 0xE3, 0xBB, 0xF8, 0x77, 0x7F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF8,
  0x3F, 0x7F, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0xC0,
  0x1E, 0x3E, 0x3E, 0x78, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xEF, 0x03, 0xDE,
  0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xF8, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0xFC, 0xFF, 0xCF, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x7C, 0x07, 0xC0, 0xFC,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x3F,
  0x01, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x08, 0x00, 0x38, 0x0F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 21, 7, 0, -21 },
  { 25, 11, 8, 12, 3, -21 },
  { 36, 15, 21, 15, 0, -21 },
  { 76, 14, 24, 13, 0, -22 },
  { 118, 19, 21, 22, 2, -21 },
  { 168, 16, 21, 16, 0, -21 },
  { 210, 5, 8, 7, 3, -21 },
  { 215, 10, 26, 8, 0, -21 },
  { 248, 10, 26, 8, -2, -21 },
  { 281, 12, 12, 12, 2, -22 },
  { 299, 12, 14, 14, 1, -17 },
  { 320, 7, 8, 7, -2, -4 },
  { 327, 8, 4, 9, 0, -10 },
  { 331, 5, 5, 7, 0, -5 },
  { 335, 16, 21, 11, -2, -21 },
  { 377, 12, 21, 13, 1, -21 },
  { 409, 10, 21, 13, 3, -21 },
  { 436, 14, 21, 13, -1, -21 },
  { 473, 13, 21, 13, 0, -21 },
  { 508, 13, 21, 13, 0, -21 },
  { 543, 14, 21, 13, 0, -21 },
  { 580, 13, 21, 13, 1, -21 },
  { 615, 14, 21, 13, 1, -21 },
  { 652, 14, 21, 13, 0, -21 },
  { 689, 13, 21, 13, 0, -21 },
  { 724, 7, 16, 7, 0, -16 },
  { 738, 9, 20, 7, -2, -16 },
  { 761, 12, 14, 14, 1, -17 },
  { 782, 12, 10, 14, 1, -15 },
  { 797, 12, 14, 14, 1, -17 },
  { 818, 11, 21, 10, 1, -21 },
  { 847, 19, 23, 20, 1, -21 },
  { 902, 15, 21, 14, -2, -21 },
  { 942, 15, 21, 14, 0, -21 },
  { 982, 14, 21, 13, 1, -21 },
  { 1019, 15, 21, 15, 0, -21 },
  { 1059, 13, 21, 12, 0, -21 },
  { 1094, 13, 21, 11, 0, -21 },
  { 1129, 15, 21, 16, 1, -21 },
  { 1169, 17, 21, 16, 0, -21 },
  { 1214, 13, 21, 10, -1, -21 },
  { 1249, 14, 27, 8, -5, -21 },
  { 1297, 17, 21, 14, 0, -21 },
  { 1342, 10, 21, 11, 0, -21 },
  { 1369, 22, 21, 21, 0, -21 },
  { 1427, 18, 21, 17, 0, -21 },
  { 1475, 15, 21, 16, 1, -21 },
  { 1515, 15, 21, 14, 0, -21 },
  { 1555, 15, 26, 16, 1, -21 },
  { 1604, 14, 21, 14, 0, -21 },
  { 1641, 15, 21, 12, -1, -21 },
  { 1681, 12, 21, 12, 2, -21 },
  { 1713, 16, 21, 15, 1, -21 },
  { 1755, 14, 21, 14, 3, -21 },
  { 1792, 21, 21, 21, 2, -21 },
  { 1848, 18, 21, 14, -2, -21 },
  { 1896, 13, 21, 13, 3, -21 },
  { 1931, 15, 21, 12, -1, -21 },
  { 1971, 12, 26, 8, -1, -21 },
  { 2010, 6, 21, 11, 3, -21 },
  { 2026, 12, 26, 8, -2, -21 },
  { 2065, 13, 13, 13, 0, -21 },
  { 2087, 11, 3, 10, -3, 2 },
  { 2092, 6, 4, 9, 4, -22 },
  { 2095, 14, 16, 14, 0, -16 },
  { 2123, 13, 22, 14, 0, -22 },
  { 2159, 11, 16, 11, 1, -16 },
  { 2181, 15, 22, 14, 0, -22 },
  { 2223, 12, 16, 13, 1, -16 },
  { 2247, 15, 29, 8, -3, -22 },
  { 2302, 15, 23, 14, -1, -16 },
  { 2346, 13, 22, 14, 0, -22 },
  { 2382, 8, 22, 7, 0, -22 },
  { 2404, 12, 29, 7, -4, -22 },
  { 2448, 15, 22, 13, 0, -22 },
  { 2490, 9, 22, 7, 0, -22 },
  { 2515, 20, 16, 20, 0, -16 },
  { 2555, 13, 16, 14, 0, -16 },
  { 2581, 12, 16, 13, 1, -16 },
  { 2605, 15, 23, 14, -2, -16 },
  { 2649, 14, 23, 14, 0, -16 },
  { 2690, 11, 16, 10, 0, -16 },
  { 2712, 11, 16, 11, 0, -16 },
  { 2734, 9, 19, 9, 1, -19 },
  { 2756, 13, 16, 14, 1, -16 },
  { 2782, 12, 16, 12, 2, -16 },
  { 2806, 19, 16, 19, 1, -16 },
  { 2844, 15, 16, 12, -1, -16 },
  { 2874, 16, 23, 12, -2, -16 },
  { 2920, 12, 16, 11, -1, -16 },
  { 2944, 12, 26, 10, 0, -21 },
  { 2983, 3, 29, 11, 4, -22 },
  { 2994, 12, 26, 10, -2, -21 },
  { 3033, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC29PT7B_H_
