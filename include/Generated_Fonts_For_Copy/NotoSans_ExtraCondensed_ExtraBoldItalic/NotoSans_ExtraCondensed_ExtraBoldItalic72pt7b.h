#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x71, 0xF0,
  0x01, 0xFF, 0x1C, 0x1C, 0x00, 0x7F, 0xCF, 0x02, 0x00, 0x1F, 0xF3, 0x80,
  0x00, 0x07, 0xFC, 0xE0, 0x00, 0x01, 0xFF, 0x38, 0x00, 0x00, 0x7F, 0xEE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xDF, 0xF8, 0x00, 0x00, 0xF7, 0xFE, 0x02, 0x00, 0x38,
  0xFF, 0x80, 0xC0, 0x0E, 0x7F, 0xE0, 0x38, 0x03, 0x9F, 0xF8, 0x0F, 0x81,
  0xE7, 0xFC, 0x03, 0xF8, 0x73, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF1, 0xFE, 0x01, 0x80, 0xFE, 0x0F, 0xE3,
  0xFC, 0x1F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xF8, 0xFE, 0x1F, 0xE7,
  0xF8, 0x7F, 0xFC, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F,
  0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F,
  0xE3, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x3F, 0xFC, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x8F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFD, 0xFF, 0xDF,
  0xF8, 0x3F, 0xF9, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x08,
  0x07, 0xF8, 0x00, 0x70, 0x3F, 0xC0, 0x03, 0xC1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x31, 0xFF, 0x7F, 0x0F, 0x8F, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xEF, 0xF8, 0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00,
  0xFF, 0x0F, 0xFC, 0x03, 0xF8, 0x7F, 0xE0, 0x0F, 0x81, 0xFC, 0x00, 0x38,
  0x0F, 0xC0, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0x81, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x9F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87,
  0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xBF, 0xF1, 0xFF, 0xBF, 0xF8, 0x7F, 0x9F, 0xF8, 0x1F, 0x8F, 0xFC, 0x0F,
  0x87, 0xFE, 0x03, 0x87, 0xFF, 0x00, 0x83, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x7F, 0xF8, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0xF0,
  0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xE1,
  0xFF, 0xF0, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0x60, 0x07, 0xFF, 0x00, 0x10,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x7F,
  0xF8, 0x30, 0x00, 0x3F, 0xFC, 0x0F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xF7, 0xFE, 0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00, 0xFE,
  0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x1F, 0xCF, 0xFC, 0x00, 0x0F,
  0xE3, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x01, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0x01, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x81, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x03, 0xFF, 0xC0, 0x78,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xDF, 0xF8, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xFC, 0x1C, 0x03, 0xFF, 0x82, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0x01,
  0xFC, 0x07, 0xFF, 0xF8, 0x7E, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFF, 0xE1, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0x83, 0xF8, 0x7F,
  0x07, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0x87, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F,
  0xE0, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF3, 0xF8, 0x7F,
  0x81, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC,
  0x0F, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFC, 0x7F, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0x83, 0xFE, 0xFF,
  0xE7, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0xDF,
  0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x3F, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0xC0, 0x38, 0x00, 0xFF, 0xF0, 0x01,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x30, 0x01,
  0xFF, 0xF0, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0xF8,
  0x00, 0x20, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x40, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFB,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x3F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xE1,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0xFF, 0xBF, 0xF8, 0x01,
  0xFF, 0xBF, 0xE3, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x9F, 0xF3, 0xFF,
  0x00, 0x3F, 0xF3, 0xFE, 0x7F, 0x8F, 0xFC, 0x00, 0xFF, 0xCF, 0xFB, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xFC, 0x3F,
  0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF7, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xBF, 0xE1, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xF9,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x7F,
  0xC0, 0x07, 0xFE, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFD, 0xFF,
  0xE0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF,
  0xC3, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0x80,
  0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFE,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE7,
  0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xFC,
  0x03, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x20, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0xF0, 0x0F, 0x80,
  0x3F, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE,
  0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x8F, 0xF7, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xBF, 0xC7, 0xFE, 0x00, 0x7F, 0xE7, 0xFF,
  0xFE, 0x7F, 0xF0, 0x03, 0xFE, 0x3F, 0xDF, 0xF3, 0xFF, 0x00, 0x1F, 0xF3,
  0xFE, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x9F, 0xF7, 0xFD, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0x3F, 0xEF, 0xFC, 0x00, 0x3F, 0xEF, 0xF9, 0xFF, 0x7F, 0xE0,
  0x03, 0xFF, 0x7F, 0x8F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xBF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE3,
  0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xCF, 0xF8, 0x03,
  0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x8F,
  0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x7F, 0xDF,
  0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0C, 0x03, 0xFF, 0xC0, 0x20, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x06, 0x03, 0xFF, 0xC0, 0x70, 0x0F, 0xFF, 0x1F, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFC,
  0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF,
  0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x10, 0x1F,
  0xFC, 0x01, 0xC0, 0x7F, 0xFC, 0x7F, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC2, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0xE7, 0xFC,
  0x00, 0x3F, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFD, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xCF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFF, 0x00, 0x00, 0x78, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x03, 0xFF, 0x80, 0x1E,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F,
  0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xE3, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0xF1, 0xFF, 0xF0,
  0x03, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFF, 0x80,
  0x0F, 0xF1, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF,
  0x80, 0x3F, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xCF,
  0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x80,
  0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xF8, 0x00, 0x3F,
  0xEF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x7F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFB,
  0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xC1,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0x80, 0xFF, 0xE0, 0x38, 0x0F,
  0xFE, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x08, 0x00, 0xFF, 0xE0, 0xE0, 0x0F, 0xFE,
  0x0F, 0xC3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xCF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xF8, 0x03,
  0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF,
  0x8F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x00, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFD, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0x3F,
  0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFC, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xF3, 0xFF, 0xFC, 0x7F, 0xC0,
  0xFF, 0xDF, 0xEF, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xBF, 0xCF, 0xF8, 0x0F,
  0xF9, 0xFE, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xF3, 0xFD, 0xFF, 0x00, 0xFF,
  0xBF, 0xCF, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB,
  0xF8, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFB, 0xFE, 0x00, 0xFF, 0xFF,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x3F, 0xF8,
  0x00, 0x0D, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFB, 0x00, 0x0F, 0xFF,
  0xE4, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 22, 52, 18, 0, -51 },
  { 144, 27, 18, 30, 7, -51 },
  { 205, 38, 51, 36, 0, -51 },
  { 448, 34, 59, 32, 0, -55 },
  { 699, 48, 53, 54, 4, -52 },
  { 1017, 40, 53, 40, 0, -52 },
  { 1282, 13, 18, 18, 7, -51 },
  { 1312, 25, 63, 20, 1, -52 },
  { 1509, 25, 64, 20, -6, -53 },
  { 1709, 29, 31, 31, 5, -55 },
  { 1822, 30, 35, 35, 3, -43 },
  { 1954, 17, 20, 18, -4, -10 },
  { 1997, 19, 10, 21, 1, -24 },
  { 2021, 12, 13, 18, 0, -12 },
  { 2041, 38, 53, 28, -4, -52 },
  { 2293, 31, 53, 32, 2, -52 },
  { 2499, 25, 51, 33, 7, -51 },
  { 2659, 35, 52, 32, -2, -52 },
  { 2887, 34, 53, 32, -1, -52 },
  { 3113, 34, 52, 33, -1, -52 },
  { 3334, 33, 52, 32, 1, -51 },
  { 3549, 33, 53, 32, 2, -52 },
  { 3768, 34, 51, 32, 2, -51 },
  { 3985, 34, 53, 32, 0, -52 },
  { 4211, 33, 53, 32, 0, -52 },
  { 4430, 18, 41, 18, 0, -40 },
  { 4523, 22, 50, 18, -4, -40 },
  { 4661, 30, 35, 35, 3, -43 },
  { 4793, 30, 23, 35, 3, -37 },
  { 4880, 30, 35, 35, 3, -43 },
  { 5012, 27, 53, 25, 2, -52 },
  { 5191, 47, 58, 49, 2, -52 },
  { 5532, 36, 52, 36, -4, -52 },
  { 5766, 36, 51, 36, 0, -51 },
  { 5996, 35, 53, 33, 2, -52 },
  { 6228, 38, 51, 38, 0, -51 },
  { 6471, 33, 51, 29, 0, -51 },
  { 6682, 33, 51, 28, 0, -51 },
  { 6893, 38, 53, 39, 3, -52 },
  { 7145, 42, 51, 39, 0, -51 },
  { 7413, 33, 51, 25, -3, -51 },
  { 7624, 32, 67, 19, -11, -51 },
  { 7892, 42, 51, 35, 0, -51 },
  { 8160, 24, 51, 28, 0, -51 },
  { 8313, 54, 51, 52, 0, -51 },
  { 8658, 45, 51, 42, 0, -51 },
  { 8945, 37, 53, 40, 3, -52 },
  { 9191, 36, 51, 34, 0, -51 },
  { 9421, 37, 64, 40, 3, -52 },
  { 9717, 36, 51, 35, 0, -51 },
  { 9947, 35, 53, 30, -1, -52 },
  { 10179, 30, 51, 30, 5, -51 },
  { 10371, 38, 52, 38, 3, -51 },
  { 10618, 35, 51, 35, 7, -51 },
  { 10842, 53, 51, 52, 5, -51 },
  { 11180, 43, 51, 34, -4, -51 },
  { 11455, 32, 51, 33, 7, -51 },
  { 11659, 38, 51, 30, -3, -51 },
  { 11902, 29, 64, 21, -3, -52 },
  { 12134, 16, 53, 28, 7, -52 },
  { 12240, 29, 64, 21, -5, -52 },
  { 12472, 33, 32, 32, -1, -51 },
  { 12604, 27, 6, 25, -7, 6 },
  { 12625, 15, 11, 23, 10, -55 },
  { 12646, 34, 41, 34, 1, -40 },
  { 12821, 34, 56, 34, -1, -55 },
  { 13059, 29, 41, 27, 1, -40 },
  { 13208, 37, 56, 34, 1, -55 },
  { 13467, 30, 41, 32, 1, -40 },
  { 13621, 37, 72, 21, -8, -55 },
  { 13954, 37, 57, 34, -2, -40 },
  { 14218, 34, 55, 34, -1, -55 },
  { 14452, 22, 55, 17, -1, -55 },
  { 14604, 30, 72, 17, -9, -55 },
  { 14874, 37, 55, 33, -1, -55 },
  { 15129, 22, 55, 17, -1, -55 },
  { 15281, 50, 40, 50, -1, -40 },
  { 15531, 34, 40, 34, -1, -40 },
  { 15701, 31, 41, 33, 1, -40 },
  { 15860, 37, 57, 34, -4, -40 },
  { 16124, 34, 57, 34, 1, -40 },
  { 16367, 29, 40, 24, -1, -40 },
  { 16512, 28, 41, 27, 0, -40 },
  { 16656, 22, 49, 23, 3, -48 },
  { 16791, 33, 41, 34, 2, -40 },
  { 16961, 31, 40, 31, 4, -40 },
  { 17116, 46, 40, 46, 4, -40 },
  { 17346, 38, 40, 31, -4, -40 },
  { 17536, 40, 57, 31, -5, -40 },
  { 17821, 31, 40, 26, -3, -40 },
  { 17976, 29, 62, 25, 1, -51 },
  { 18201, 9, 71, 28, 9, -55 },
  { 18281, 28, 62, 25, -4, -51 },
  { 18498, 31, 13, 35, 3, -32 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC72PT7B_H_
