#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x03, 0x39, 0x80, 0xFF, 0x7D, 0xB6,
  0x0D, 0x85, 0x86, 0xCF, 0xF7, 0xF9, 0xB0, 0xD9, 0xFE, 0xFF, 0x36, 0x12,
  0x1B, 0x00, 0x04, 0x0E, 0x3F, 0x3A, 0x38, 0x38, 0x3C, 0x1E, 0x1E, 0x96,
  0xFC, 0xFC, 0x20, 0x20, 0x78, 0xCF, 0x33, 0x64, 0x6D, 0x8D, 0xE1, 0xEF,
  0xFF, 0x78, 0x7B, 0x1B, 0x63, 0x6C, 0xCF, 0x30, 0xE0, 0x1E, 0x0F, 0x8E,
  0xC7, 0xC3, 0xE1, 0xED, 0xF6, 0xDF, 0xEF, 0x77, 0x3F, 0xCF, 0xE0, 0xFB,
  0x60, 0x1C, 0x63, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xE3, 0x86,
  0x00, 0x18, 0x61, 0x87, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x1C, 0x63, 0x8C,
  0x00, 0x18, 0xB1, 0xFF, 0xF3, 0x8D, 0x9B, 0x00, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x18, 0x76, 0x6C, 0x7F, 0xFC, 0x7F, 0x00, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x00, 0x1E,
  0x3F, 0x37, 0x77, 0x77, 0x66, 0x66, 0xE6, 0xEE, 0xEC, 0x7C, 0x78, 0x1C,
  0xE7, 0xBE, 0xB8, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x0F, 0x0F, 0xC4, 0xE0,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x9F, 0xC0, 0x3E, 0x3F,
  0x27, 0x07, 0x0E, 0x3C, 0x3C, 0x0E, 0x0E, 0x8C, 0xFC, 0xF8, 0x07, 0x0F,
  0x0E, 0x1E, 0x3E, 0x2E, 0x6C, 0xCC, 0xFE, 0xFE, 0x1C, 0x18, 0x1F, 0x3F,
  0x30, 0x30, 0x3C, 0x7E, 0x4E, 0x0E, 0x0E, 0x8C, 0xFC, 0xF8, 0x0F, 0x1F,
  0x38, 0x30, 0x7E, 0x7E, 0x76, 0x66, 0xE6, 0x6E, 0x7C, 0x78, 0x3F, 0x9F,
  0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x00,
  0x1E, 0x3F, 0x33, 0x37, 0x3E, 0x3C, 0x7C, 0x6E, 0xE6, 0xCE, 0xFC, 0x78,
  0x1E, 0x3E, 0x77, 0x77, 0x67, 0x7E, 0x7E, 0x3E, 0x0E, 0x1C, 0xF8, 0xF0,
  0x37, 0x00, 0x00, 0x6E, 0xE0, 0x19, 0xC0, 0x00, 0x00, 0x0E, 0x63, 0x30,
  0x06, 0x3D, 0xF7, 0x0F, 0x07, 0x83, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x81, 0xC1, 0xE0, 0xF1, 0xFF, 0x38, 0x40, 0x3C, 0xFD, 0x38, 0x61,
  0xC7, 0x0C, 0x38, 0x00, 0xC1, 0x87, 0x00, 0x07, 0xC3, 0x8C, 0xC0, 0x9B,
  0xD6, 0xDA, 0xD2, 0x56, 0x4E, 0xDB, 0xDB, 0x59, 0xB1, 0x00, 0x30, 0x83,
  0xF0, 0x07, 0x0F, 0x0F, 0x0F, 0x1B, 0x1B, 0x3B, 0x3F, 0x7F, 0x73, 0x63,
  0xE3, 0x3F, 0x1F, 0x8C, 0xE6, 0x63, 0x73, 0xF1, 0xF8, 0xCE, 0x67, 0x73,
  0x3F, 0x9F, 0x80, 0x1F, 0x3E, 0x72, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0xE4, 0xF8, 0x78, 0x3F, 0x1F, 0x8C, 0xE6, 0x73, 0x3B, 0x9D, 0xCE, 0xC6,
  0x67, 0x77, 0x3F, 0x1F, 0x00, 0x3F, 0x3E, 0x30, 0x30, 0x32, 0x7C, 0x7C,
  0x60, 0x60, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x30, 0x30, 0x30, 0x7C, 0x7C,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x1F, 0x9F, 0x9C, 0x4C, 0x0E, 0x07, 0x7B,
  0x3D, 0x8C, 0xC6, 0x77, 0x3F, 0x8F, 0x80, 0x39, 0xCE, 0x73, 0x18, 0xC6,
  0x33, 0x9F, 0xE7, 0xF1, 0x8C, 0x63, 0x39, 0xCE, 0x73, 0x98, 0x1F, 0x1E,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x78, 0xFC, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x78,
  0x70, 0xE0, 0x39, 0xCE, 0xE3, 0x70, 0xD8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0x6E, 0x3B, 0x8E, 0xE3, 0x18, 0x38, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x63,
  0x8F, 0xFE, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x3E, 0xF9,
  0xBF, 0x8D, 0xEC, 0x6F, 0x67, 0x77, 0x3B, 0xB9, 0x99, 0x80, 0x38, 0xE7,
  0x98, 0xF3, 0x1E, 0xE3, 0xDC, 0xFB, 0x1B, 0x63, 0x7C, 0x67, 0x9C, 0xE3,
  0x9C, 0x63, 0x80, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xE3, 0xC7, 0xC7, 0xC6,
  0xCE, 0xFC, 0x78, 0x3F, 0x1F, 0x8C, 0xE6, 0x73, 0x33, 0xB9, 0xF8, 0xF8,
  0x60, 0x70, 0x38, 0x1C, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xE3, 0xC7,
  0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x18, 0x1C, 0x1C, 0x3E, 0x3F, 0x33, 0x33,
  0x37, 0x7F, 0x7E, 0x6C, 0x6C, 0xEE, 0xEE, 0xC6, 0x1F, 0x3F, 0x72, 0x70,
  0x78, 0x3C, 0x1C, 0x0C, 0x0E, 0x9C, 0xFC, 0xF8, 0x7F, 0xFC, 0xE1, 0xC3,
  0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x00, 0x73, 0xB9, 0x98, 0xCC, 0xEE,
  0x77, 0x33, 0x99, 0x8C, 0xCE, 0x67, 0x3F, 0x0F, 0x00, 0xC7, 0xC6, 0xCE,
  0xCC, 0xDC, 0xD8, 0xD8, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x67, 0x3F, 0x39,
  0xB9, 0xDD, 0xDE, 0xCE, 0xF6, 0x7D, 0x73, 0xFB, 0x1F, 0xF8, 0xF7, 0x87,
  0xBC, 0x39, 0xE1, 0xCE, 0x00, 0x19, 0xC7, 0x61, 0xF8, 0x7C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x3E, 0x0D, 0x87, 0x73, 0x9C, 0xCF, 0x9B, 0x76, 0xCF,
  0x9E, 0x3C, 0x30, 0xE1, 0xC3, 0x06, 0x00, 0x1F, 0x8F, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x1F, 0x9F, 0xC0, 0x1E, 0x3C, 0x60,
  0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0E, 0x3C, 0x00, 0xDB,
  0x6D, 0xDB, 0x6D, 0xB0, 0x1E, 0x38, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18,
  0x70, 0xC1, 0x83, 0x1E, 0x38, 0x00, 0x0C, 0x0C, 0x1E, 0x36, 0x36, 0x66,
  0xE6, 0xC3, 0x7F, 0xF8, 0xE7, 0x30, 0x10, 0x3F, 0x7F, 0x77, 0x66, 0xE6,
  0xE6, 0xEE, 0xFE, 0x7C, 0x38, 0x38, 0x30, 0x34, 0x3E, 0x7F, 0x77, 0x67,
  0x67, 0x66, 0xEE, 0xFC, 0xDC, 0x08, 0x7D, 0xF3, 0x86, 0x1C, 0x38, 0x72,
  0x78, 0xF0, 0x03, 0x81, 0xC0, 0xC2, 0x63, 0xF3, 0xF9, 0xDC, 0xCC, 0xE6,
  0x73, 0x3B, 0x9F, 0xC7, 0xC0, 0x3E, 0x6D, 0x9B, 0xFF, 0xDC, 0x38, 0x3E,
  0x7C, 0x07, 0x83, 0x83, 0x81, 0xC1, 0xF0, 0xF0, 0x70, 0x38, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC1, 0xE0, 0xE0, 0x00, 0x08, 0x3F, 0x7F,
  0x77, 0x66, 0xE6, 0xE6, 0xEE, 0xFE, 0x7C, 0x0C, 0x9C, 0xF8, 0xF0, 0x38,
  0x38, 0x30, 0x34, 0x3E, 0x7F, 0x77, 0x66, 0x66, 0x66, 0xEE, 0xEE, 0xCC,
  0x19, 0xC4, 0x03, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x00, 0x06, 0x1C, 0x10,
  0x00, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x78, 0xE0,
  0x38, 0x1C, 0x0C, 0x06, 0x13, 0x73, 0xB1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3B,
  0x19, 0x8C, 0xE0, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x00,
  0x04, 0x43, 0xEE, 0x7F, 0xF7, 0x76, 0x66, 0x66, 0x66, 0x66, 0xEE, 0xEE,
  0xEC, 0xCC, 0xCC, 0x04, 0x3E, 0x7F, 0x77, 0x66, 0x66, 0x66, 0xEE, 0xEE,
  0xCC, 0x08, 0x3E, 0x7E, 0x67, 0x66, 0xE6, 0xE6, 0xEE, 0x7C, 0x78, 0x02,
  0x0F, 0x8F, 0xE7, 0x73, 0x39, 0x9C, 0xCC, 0xEE, 0x7E, 0x37, 0x18, 0x0C,
  0x0E, 0x06, 0x00, 0x08, 0x3F, 0x7F, 0x77, 0x66, 0xE6, 0xE6, 0xEE, 0xFE,
  0x7C, 0x0C, 0x0C, 0x1C, 0x18, 0x06, 0x79, 0xF3, 0x86, 0x0C, 0x18, 0x70,
  0xE1, 0x80, 0x10, 0x7D, 0xF3, 0x07, 0x07, 0x07, 0x4C, 0xF9, 0xE0, 0x33,
  0x3F, 0xFE, 0x73, 0x18, 0xC7, 0x38, 0x33, 0x77, 0x77, 0x66, 0x66, 0x66,
  0xEE, 0xFE, 0x7C, 0xCF, 0x9B, 0x36, 0xCD, 0x9E, 0x3C, 0x78, 0xE0, 0xCE,
  0xFB, 0xDB, 0x7F, 0x6B, 0xCF, 0x59, 0xEE, 0x39, 0xC7, 0x78, 0xEE, 0x00,
  0x3B, 0x8F, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xF8, 0xFC, 0xE6, 0x00, 0x33,
  0x99, 0x8C, 0xC6, 0xC3, 0x61, 0xF0, 0xF0, 0x78, 0x18, 0x1C, 0x0C, 0x1E,
  0x0E, 0x00, 0x3F, 0x3E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x7C, 0xFC, 0x0E,
  0x3C, 0x60, 0xC3, 0x87, 0x1C, 0x70, 0x70, 0xE1, 0xC3, 0x07, 0x0E, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x78, 0x70, 0xE1, 0xC3, 0x07,
  0x86, 0x38, 0x60, 0xC1, 0x87, 0x1C, 0x30, 0x00, 0x03, 0xFF, 0xFC, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 6, 4, 7, 2, -12 },
  { 12, 9, 12, 9, 0, -12 },
  { 26, 8, 14, 8, 0, -13 },
  { 40, 11, 12, 13, 1, -12 },
  { 57, 9, 12, 9, 0, -12 },
  { 71, 3, 4, 4, 2, -12 },
  { 73, 6, 15, 5, 0, -12 },
  { 85, 6, 15, 5, -1, -12 },
  { 97, 7, 7, 7, 1, -13 },
  { 104, 7, 8, 8, 1, -10 },
  { 111, 4, 4, 4, -1, -2 },
  { 113, 5, 3, 5, 0, -6 },
  { 115, 3, 3, 4, 0, -3 },
  { 117, 9, 12, 7, -1, -12 },
  { 131, 8, 12, 8, 0, -12 },
  { 143, 6, 12, 8, 2, -12 },
  { 152, 9, 12, 8, -1, -12 },
  { 166, 8, 12, 8, 0, -12 },
  { 178, 8, 12, 8, 0, -12 },
  { 190, 8, 12, 8, 0, -12 },
  { 202, 8, 12, 8, 0, -12 },
  { 214, 9, 12, 8, 0, -12 },
  { 228, 8, 12, 8, 0, -12 },
  { 240, 8, 12, 8, 0, -12 },
  { 252, 4, 9, 4, 0, -9 },
  { 257, 5, 11, 4, -1, -9 },
  { 264, 7, 8, 8, 1, -10 },
  { 271, 7, 6, 8, 1, -9 },
  { 277, 7, 8, 8, 1, -10 },
  { 284, 7, 12, 6, 0, -12 },
  { 295, 11, 13, 11, 0, -12 },
  { 313, 8, 12, 8, -1, -12 },
  { 325, 9, 12, 8, 0, -12 },
  { 339, 8, 12, 8, 1, -12 },
  { 351, 9, 12, 9, 0, -12 },
  { 365, 8, 12, 7, 0, -12 },
  { 377, 8, 12, 7, 0, -12 },
  { 389, 9, 12, 9, 1, -12 },
  { 403, 10, 12, 9, 0, -12 },
  { 418, 8, 12, 6, -1, -12 },
  { 430, 8, 16, 4, -3, -12 },
  { 446, 10, 12, 8, 0, -12 },
  { 461, 6, 12, 7, 0, -12 },
  { 470, 13, 12, 12, 0, -12 },
  { 490, 11, 12, 10, 0, -12 },
  { 507, 8, 12, 9, 1, -12 },
  { 519, 9, 12, 8, 0, -12 },
  { 533, 8, 15, 9, 1, -12 },
  { 548, 8, 12, 8, 0, -12 },
  { 560, 8, 12, 7, 0, -12 },
  { 572, 7, 12, 7, 1, -12 },
  { 583, 9, 12, 9, 1, -12 },
  { 597, 8, 12, 8, 2, -12 },
  { 609, 13, 12, 12, 1, -12 },
  { 629, 10, 12, 8, -1, -12 },
  { 644, 7, 12, 8, 2, -12 },
  { 655, 9, 12, 7, -1, -12 },
  { 669, 7, 15, 5, -1, -12 },
  { 683, 3, 12, 7, 2, -12 },
  { 688, 7, 15, 5, -1, -12 },
  { 702, 8, 8, 8, 0, -12 },
  { 710, 7, 2, 6, -2, 1 },
  { 712, 4, 3, 5, 2, -13 },
  { 714, 8, 10, 8, 0, -10 },
  { 724, 8, 13, 8, 0, -13 },
  { 737, 7, 10, 6, 0, -10 },
  { 746, 9, 13, 8, 0, -13 },
  { 761, 7, 9, 7, 0, -9 },
  { 769, 9, 17, 5, -2, -13 },
  { 789, 8, 14, 8, 0, -10 },
  { 803, 8, 13, 8, 0, -13 },
  { 816, 5, 13, 4, 0, -13 },
  { 825, 7, 17, 4, -2, -13 },
  { 840, 9, 13, 8, 0, -13 },
  { 855, 5, 13, 4, 0, -13 },
  { 864, 12, 10, 12, 0, -10 },
  { 879, 8, 10, 8, 0, -10 },
  { 889, 8, 10, 8, 0, -10 },
  { 899, 9, 14, 8, -1, -10 },
  { 915, 8, 14, 8, 0, -10 },
  { 929, 7, 10, 6, 0, -10 },
  { 938, 7, 10, 6, 0, -10 },
  { 947, 5, 11, 5, 1, -11 },
  { 954, 8, 9, 8, 0, -9 },
  { 963, 7, 9, 7, 1, -9 },
  { 971, 11, 9, 11, 1, -9 },
  { 984, 9, 9, 7, -1, -9 },
  { 995, 9, 13, 7, -1, -9 },
  { 1010, 8, 9, 6, -1, -9 },
  { 1019, 7, 15, 6, 0, -12 },
  { 1033, 2, 17, 7, 2, -13 },
  { 1038, 7, 15, 6, -1, -12 },
  { 1052, 7, 4, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC17PT7B_H_
