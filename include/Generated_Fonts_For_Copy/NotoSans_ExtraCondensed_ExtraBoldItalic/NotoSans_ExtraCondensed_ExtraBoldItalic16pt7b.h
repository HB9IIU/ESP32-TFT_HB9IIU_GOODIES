#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x80, 0x47, 0x30, 0x6E, 0xD9, 0xB6, 0x40,
  0x0F, 0x0D, 0x86, 0xAF, 0xE3, 0x61, 0xA3, 0xF9, 0xFC, 0x68, 0x2C, 0x36,
  0x00, 0x04, 0x1F, 0x3E, 0x3A, 0x78, 0x38, 0x1C, 0x1C, 0x9C, 0xFC, 0xF8,
  0x20, 0x20, 0x20, 0x0F, 0x33, 0x6C, 0x6D, 0x8D, 0x61, 0xEB, 0xBF, 0x72,
  0x5B, 0x1B, 0x42, 0x58, 0xCF, 0x31, 0xC0, 0x04, 0x0F, 0x0D, 0x86, 0xC3,
  0xE1, 0xE1, 0xEE, 0xFE, 0xCF, 0x67, 0x3F, 0x8F, 0xE0, 0xFB, 0x40, 0x0C,
  0x63, 0x0C, 0x71, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x00, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C, 0xE6, 0x63, 0x00, 0x19, 0x4F, 0xCF,
  0x7B, 0xF4, 0x80, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x76, 0x6C, 0xFF,
  0x80, 0x5F, 0x00, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x1C, 0x00, 0x0C, 0x3C, 0xF9, 0xB6, 0x6C, 0xD9, 0xB7,
  0xED, 0xD9, 0xE3, 0xC0, 0x1C, 0xFF, 0x96, 0x18, 0x63, 0x8C, 0x30, 0xC7,
  0x00, 0x04, 0x1F, 0x3F, 0x13, 0x03, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x7E,
  0xFE, 0x0C, 0x7C, 0xF8, 0x30, 0x67, 0x8F, 0x06, 0x0D, 0x1B, 0xF7, 0xC0,
  0x06, 0x1C, 0x78, 0xF2, 0xCD, 0xB3, 0x7F, 0xFE, 0x30, 0x60, 0x3E, 0x7C,
  0xC1, 0x87, 0xCF, 0x83, 0x86, 0x8D, 0xFB, 0xE0, 0x06, 0x1F, 0x39, 0x30,
  0x74, 0x7E, 0x7E, 0x6E, 0xEE, 0xEC, 0x7C, 0x78, 0x3F, 0x3F, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x0C, 0x7C, 0xD9, 0xB3, 0x67,
  0x8F, 0x36, 0xCD, 0x9B, 0xF3, 0xC0, 0x08, 0x7C, 0xDB, 0xB6, 0x6D, 0xDF,
  0xBF, 0x0C, 0x3B, 0xE7, 0x80, 0x37, 0x20, 0x00, 0x4E, 0xC0, 0x19, 0xC4,
  0x00, 0x00, 0x0E, 0x63, 0x30, 0x04, 0x33, 0xFC, 0xE1, 0xE1, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x1D, 0xEE, 0x20, 0x19, 0xF6, 0xC3,
  0x0C, 0x63, 0x18, 0x00, 0x86, 0x38, 0x03, 0x01, 0xF8, 0x61, 0x19, 0xB6,
  0xF6, 0xD6, 0xD6, 0xDA, 0xDA, 0xDE, 0xDB, 0xF1, 0x00, 0x30, 0x83, 0xE0,
  0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x3B, 0x3F, 0x3F, 0x73, 0x63, 0xE3, 0x3F,
  0x3F, 0x33, 0x37, 0x7E, 0x7E, 0x66, 0x66, 0xEE, 0xFC, 0xF8, 0x0C, 0x7D,
  0xFB, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x93, 0xE3, 0xC0, 0x3E, 0x3F, 0x33,
  0x33, 0x73, 0x63, 0x67, 0x67, 0xEE, 0xFC, 0xF8, 0x3E, 0x7C, 0xC1, 0x87,
  0xCF, 0x98, 0x30, 0xE1, 0xF3, 0xE0, 0x3E, 0x7C, 0xC1, 0x87, 0xCF, 0x9F,
  0x30, 0xE1, 0xC3, 0x00, 0x0C, 0x3F, 0x7E, 0x60, 0xE0, 0xCE, 0xCE, 0xD6,
  0xCE, 0xCC, 0xFC, 0x7C, 0x39, 0x98, 0xCC, 0xE6, 0x67, 0xF3, 0xF9, 0x9C,
  0xCE, 0xE6, 0x73, 0x31, 0x80, 0x1F, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x7C, 0xF8, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x78, 0xF0, 0x3B, 0x9B, 0x8D, 0x87, 0xC7, 0xC3,
  0xE1, 0xF0, 0xD8, 0xEC, 0x77, 0x33, 0x80, 0x39, 0x8C, 0x67, 0x31, 0x8C,
  0xE7, 0xFE, 0x38, 0xF3, 0x8F, 0x38, 0xE3, 0x9E, 0x6D, 0xE6, 0xF6, 0x6F,
  0xE6, 0xEC, 0xEE, 0xCC, 0xCC, 0xCD, 0xC0, 0x38, 0xCE, 0x63, 0x98, 0xF6,
  0x6D, 0x9B, 0xE6, 0xF1, 0xBC, 0xEF, 0x31, 0xCC, 0x70, 0x0C, 0x3E, 0x7F,
  0x67, 0xE7, 0xC7, 0xC7, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x3F, 0x3F, 0x33,
  0x33, 0x77, 0x7E, 0x7C, 0x60, 0xE0, 0xE0, 0xC0, 0x0C, 0x3E, 0x7F, 0x67,
  0xE7, 0xC7, 0xC7, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x38, 0x18, 0x1C, 0x3E,
  0x3F, 0x37, 0x37, 0x76, 0x7E, 0x7C, 0x6C, 0xEC, 0xEE, 0xCE, 0x0C, 0x3F,
  0x3E, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0C, 0x9C, 0xFC, 0xF8, 0x7F, 0xF8,
  0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x80, 0x73, 0x67, 0x66, 0xE6,
  0xE6, 0xCE, 0xCE, 0xCC, 0xCC, 0xFC, 0xF8, 0xE7, 0xE6, 0x66, 0x6E, 0x6C,
  0x7C, 0x78, 0x78, 0x70, 0x70, 0x70, 0xE6, 0x7E, 0xE6, 0xEE, 0x6E, 0xEC,
  0xDE, 0xCD, 0xFC, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x00, 0x19,
  0xC6, 0xC1, 0xB0, 0x78, 0x0E, 0x07, 0x01, 0xE0, 0xF8, 0x36, 0x19, 0x8E,
  0x70, 0xE7, 0x6E, 0x6C, 0x7C, 0x78, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60,
  0x1F, 0x9F, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0x3F,
  0x00, 0x1E, 0x3C, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06,
  0x0E, 0x3C, 0x00, 0xDB, 0x6D, 0xB7, 0x6D, 0xB0, 0x1C, 0x72, 0xC3, 0x18,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x33, 0xCE, 0x00, 0x0C, 0x38, 0xF1, 0xE6,
  0x6C, 0xF1, 0x80, 0x7F, 0xF0, 0xE7, 0x3B, 0x3E, 0x76, 0x66, 0xE6, 0xEE,
  0xEC, 0xFC, 0x6C, 0x38, 0x60, 0xC1, 0xF7, 0xEE, 0xD9, 0xB3, 0x67, 0xDF,
  0xF7, 0xC0, 0x1E, 0x79, 0xC3, 0x0E, 0x1C, 0x39, 0x7C, 0x78, 0x03, 0x03,
  0x03, 0x3F, 0x3E, 0x76, 0x66, 0xE6, 0xEE, 0xEC, 0xFC, 0x7C, 0x1C, 0x7D,
  0x9B, 0x7F, 0xDC, 0x38, 0x7E, 0x78, 0x07, 0x87, 0x83, 0x01, 0xC1, 0xE0,
  0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x83, 0xC1, 0xC0,
  0x1B, 0x3E, 0x76, 0x66, 0xE6, 0xEE, 0xEC, 0xFC, 0x7C, 0x1C, 0x98, 0xF8,
  0xF0, 0x38, 0x60, 0xC1, 0xF7, 0xEE, 0xD9, 0xB3, 0x6F, 0xDB, 0x36, 0x60,
  0x39, 0x80, 0x67, 0x39, 0x8C, 0x67, 0x31, 0x80, 0x0E, 0x18, 0x00, 0x61,
  0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x38, 0x70, 0x38, 0x30,
  0x30, 0x37, 0x76, 0x6C, 0x7C, 0x78, 0x7C, 0xFC, 0xCC, 0xCC, 0x39, 0x8C,
  0x67, 0x39, 0x8C, 0x67, 0x31, 0x80, 0x2E, 0xCF, 0xFD, 0xDB, 0xB3, 0x76,
  0x6C, 0xDD, 0xBB, 0x36, 0x66, 0xCD, 0xC0, 0x2E, 0xFD, 0xDB, 0x36, 0x6D,
  0xFB, 0x66, 0xCC, 0x1C, 0x7D, 0x9B, 0x3E, 0x7D, 0xFB, 0x3E, 0x78, 0x1F,
  0x3F, 0x3B, 0x33, 0x33, 0x33, 0x77, 0x7E, 0x6C, 0x60, 0x60, 0xE0, 0xC0,
  0x1B, 0x3E, 0x76, 0x66, 0x66, 0xEE, 0xEC, 0xFC, 0x7C, 0x1C, 0x1C, 0x18,
  0x18, 0x3D, 0xB7, 0xD8, 0x61, 0x8E, 0x30, 0xC0, 0x3D, 0xF6, 0x5C, 0x78,
  0xE1, 0xBE, 0xF0, 0x33, 0x1F, 0xEE, 0x63, 0x18, 0xC7, 0x38, 0x37, 0x76,
  0x66, 0x66, 0x66, 0x6E, 0xEC, 0xFC, 0x7C, 0xCF, 0x9B, 0x76, 0xCD, 0x9E,
  0x3C, 0x70, 0xE0, 0xCC, 0xF7, 0x7D, 0xDB, 0x76, 0xFF, 0x3F, 0xCE, 0xF3,
  0xB8, 0xCE, 0x00, 0x3B, 0x9F, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0xDC,
  0xEE, 0x00, 0x33, 0x99, 0x8D, 0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x70, 0x38,
  0x18, 0x0C, 0x1C, 0x0C, 0x00, 0x3E, 0x7C, 0x30, 0xE1, 0x86, 0x1C, 0x3E,
  0xFC, 0x1E, 0x38, 0x61, 0xC3, 0x0E, 0x30, 0x70, 0x70, 0xC1, 0x83, 0x07,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF1, 0xC6, 0x18, 0x70, 0xCF,
  0x30, 0xC3, 0x1C, 0xE2, 0x00, 0xE7, 0xF9, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 9, 11, 8, 0, -11 },
  { 25, 8, 13, 7, 0, -12 },
  { 38, 11, 12, 12, 1, -12 },
  { 55, 9, 12, 9, 0, -12 },
  { 69, 3, 4, 4, 2, -11 },
  { 71, 6, 15, 4, 0, -12 },
  { 83, 5, 15, 4, -1, -12 },
  { 93, 6, 7, 7, 1, -12 },
  { 99, 6, 8, 8, 1, -10 },
  { 105, 4, 4, 4, -1, -2 },
  { 107, 5, 2, 5, 0, -5 },
  { 109, 3, 3, 4, 0, -3 },
  { 111, 9, 12, 6, -1, -12 },
  { 125, 7, 12, 7, 0, -12 },
  { 136, 6, 11, 7, 1, -11 },
  { 145, 8, 12, 7, -1, -12 },
  { 157, 7, 12, 7, 0, -12 },
  { 168, 7, 11, 7, 0, -11 },
  { 178, 7, 11, 7, 0, -11 },
  { 188, 8, 12, 7, 0, -12 },
  { 200, 8, 11, 7, 0, -11 },
  { 211, 7, 12, 7, 0, -12 },
  { 222, 7, 12, 7, 0, -12 },
  { 233, 4, 9, 4, 0, -9 },
  { 238, 5, 11, 4, -1, -9 },
  { 245, 6, 8, 8, 1, -10 },
  { 251, 6, 5, 8, 1, -8 },
  { 255, 6, 8, 8, 1, -10 },
  { 261, 6, 12, 6, 0, -12 },
  { 270, 11, 13, 11, 0, -12 },
  { 288, 8, 11, 8, -1, -11 },
  { 299, 8, 11, 8, 0, -11 },
  { 310, 7, 12, 7, 1, -12 },
  { 321, 8, 11, 8, 0, -11 },
  { 332, 7, 11, 7, 0, -11 },
  { 342, 7, 11, 6, 0, -11 },
  { 352, 8, 12, 9, 1, -12 },
  { 364, 9, 11, 9, 0, -11 },
  { 377, 8, 11, 5, -1, -11 },
  { 388, 8, 14, 4, -3, -11 },
  { 402, 9, 11, 8, 0, -11 },
  { 415, 5, 11, 6, 0, -11 },
  { 422, 12, 11, 11, 0, -11 },
  { 439, 10, 11, 9, 0, -11 },
  { 453, 8, 12, 9, 1, -12 },
  { 465, 8, 11, 8, 0, -11 },
  { 476, 8, 15, 9, 1, -12 },
  { 491, 8, 11, 8, 0, -11 },
  { 502, 8, 12, 7, 0, -12 },
  { 514, 7, 11, 7, 1, -11 },
  { 524, 8, 11, 8, 1, -11 },
  { 535, 8, 11, 8, 1, -11 },
  { 546, 12, 11, 12, 1, -11 },
  { 563, 10, 11, 7, -1, -11 },
  { 577, 8, 11, 7, 1, -11 },
  { 588, 9, 11, 7, -1, -11 },
  { 601, 7, 15, 5, -1, -12 },
  { 615, 3, 12, 6, 2, -12 },
  { 620, 6, 15, 5, -1, -12 },
  { 632, 7, 7, 7, 0, -11 },
  { 639, 6, 2, 6, -2, 1 },
  { 641, 4, 2, 5, 2, -12 },
  { 642, 8, 9, 8, 0, -9 },
  { 651, 7, 12, 8, 0, -12 },
  { 662, 7, 9, 6, 0, -9 },
  { 670, 8, 12, 8, 0, -12 },
  { 682, 7, 9, 7, 0, -9 },
  { 690, 9, 16, 5, -2, -12 },
  { 708, 8, 13, 8, 0, -9 },
  { 721, 7, 12, 8, 0, -12 },
  { 732, 5, 12, 4, 0, -12 },
  { 740, 7, 16, 4, -2, -12 },
  { 754, 8, 12, 7, 0, -12 },
  { 766, 5, 12, 4, 0, -12 },
  { 774, 11, 9, 11, 0, -9 },
  { 787, 7, 9, 8, 0, -9 },
  { 795, 7, 9, 7, 0, -9 },
  { 803, 8, 13, 8, -1, -9 },
  { 816, 8, 13, 8, 0, -9 },
  { 829, 6, 9, 5, 0, -9 },
  { 836, 6, 9, 6, 0, -9 },
  { 843, 5, 11, 5, 1, -11 },
  { 850, 8, 9, 8, 0, -9 },
  { 859, 7, 9, 7, 1, -9 },
  { 867, 10, 9, 10, 1, -9 },
  { 879, 9, 9, 7, -1, -9 },
  { 890, 9, 13, 7, -1, -9 },
  { 905, 7, 9, 6, -1, -9 },
  { 913, 7, 14, 5, 0, -11 },
  { 926, 2, 16, 6, 2, -12 },
  { 930, 6, 14, 5, -1, -11 },
  { 941, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC16PT7B_H_
