#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x0F,
  0x87, 0x80, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0x01, 0xE7, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0xCE, 0x03, 0x9E,
  0x03, 0x9C, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x1E, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x38, 0xE0,
  0x39, 0xC0, 0x39, 0xC0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F,
  0x44, 0x1E, 0x80, 0x3D, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x85, 0xE1, 0xCB, 0xC3, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x07, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F,
  0x03, 0xC3, 0xF8, 0x78, 0x7F, 0x87, 0x07, 0x38, 0xF0, 0xF3, 0x8E, 0x0E,
  0x39, 0xE0, 0xE7, 0x9C, 0x0E, 0x7B, 0xC0, 0xE7, 0x38, 0xCE, 0xF7, 0x3E,
  0xFE, 0xF7, 0xFF, 0xEE, 0x77, 0x7D, 0xEE, 0x70, 0x1C, 0xE7, 0x03, 0xDE,
  0x70, 0x39, 0xE7, 0x07, 0x9C, 0x70, 0x71, 0xCE, 0x0E, 0x1C, 0xE0, 0xE1,
  0xFE, 0x1C, 0x1F, 0xC3, 0xC0, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF0, 0x03, 0xF1, 0xE3, 0xFD, 0xF3, 0xFE, 0xF3, 0xEF, 0xF9,
  0xE7, 0xF9, 0xF3, 0xFC, 0xF8, 0xFC, 0x7C, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xF9, 0xF0, 0x7D, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0x01,
  0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC0,
  0x07, 0x00, 0x78, 0x07, 0x86, 0x78, 0x7F, 0x37, 0xFF, 0xFF, 0xF0, 0xFF,
  0x1F, 0x83, 0xFC, 0x7F, 0xC3, 0x9E, 0x11, 0xC0, 0x10, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xF3, 0xE7, 0x9E, 0x3C,
  0xF1, 0xEF, 0x8F, 0x78, 0xFB, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x0F, 0x78,
  0xFB, 0xC7, 0xDE, 0x3C, 0xF3, 0xE7, 0x9E, 0x3F, 0xF1, 0xFF, 0x07, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xE3, 0xFC, 0xFF, 0xBF, 0xE3,
  0xBC, 0x6F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x63, 0xE0, 0x87, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x08, 0x7C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF2, 0x07, 0xCF, 0xFE,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x37, 0x81, 0xFE, 0x0E, 0xF0, 0x7B, 0xC1,
  0xCF, 0x0E, 0x7C, 0x79, 0xF1, 0xC7, 0x8F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xE0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF2, 0x0F, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF6, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x20, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F, 0x7C, 0xF8, 0xF3, 0xE3,
  0xCF, 0x1F, 0x3C, 0x7C, 0xF1, 0xF3, 0xCF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC7, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDE, 0x1F,
  0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E,
  0x3E, 0xF8, 0xF3, 0xE3, 0xCF, 0xBF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00,
  0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0xF8, 0xF3, 0xE3,
  0xCF, 0x1F, 0x3C, 0x7C, 0xF1, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xF8, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x8F, 0xF3, 0xFC, 0x1F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0xFF, 0x9D, 0xF2,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0,
  0x78, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xC3, 0xE0, 0xF0, 0x0E, 0x0E,
  0x00, 0xE1, 0xC3, 0x87, 0x38, 0xFE, 0x73, 0x9F, 0xE7, 0x73, 0xCE, 0x77,
  0x38, 0xE7, 0x73, 0x9C, 0x7E, 0x71, 0xCE, 0xE7, 0x1C, 0xEE, 0x73, 0xCE,
  0xE7, 0x39, 0xCE, 0x77, 0x9C, 0xE7, 0xFF, 0x8E, 0x7D, 0xF0, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x04, 0x07, 0xC3, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xDE, 0x03, 0xDE, 0x07, 0xDE, 0x07, 0x9E, 0x07,
  0x9E, 0x0F, 0x9E, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E,
  0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0x0F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x3E, 0x1E, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0xFC, 0x3C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE1, 0xF0, 0x87, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x43, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C,
  0x1F, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x79, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F,
  0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xF8, 0x21,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7F, 0x1E, 0x3F,
  0x9F, 0x1F, 0xCF, 0x8F, 0xC7, 0xC9, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7E, 0x3C, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x00,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x1F,
  0xE0, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x5F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x78, 0x00, 0x0F, 0x87, 0xC3, 0xE3,
  0xE0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xFF,
  0xFF, 0xEF, 0xFD, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xBD,
  0xE1, 0xEF, 0x7F, 0xC3, 0xDE, 0xEF, 0x87, 0xBF, 0xDE, 0x1F, 0x7F, 0x3C,
  0x3E, 0xFE, 0x78, 0x79, 0xFD, 0xF0, 0xF3, 0xF3, 0xE1, 0xE7, 0xE7, 0x87,
  0xCF, 0x8F, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x7C, 0x00, 0x0F, 0xC1, 0xE1,
  0xF8, 0x3C, 0x3F, 0x0F, 0x87, 0xE1, 0xE0, 0xFC, 0x3C, 0x3F, 0xC7, 0x87,
  0xF9, 0xF0, 0xFF, 0x3E, 0x1F, 0xE7, 0x83, 0xFC, 0xF0, 0xF7, 0x9E, 0x1E,
  0x7F, 0xC3, 0xCF, 0xF0, 0x79, 0xFE, 0x1F, 0x3F, 0xC3, 0xC7, 0xF8, 0x78,
  0xFF, 0x0F, 0x0F, 0xC1, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x07, 0xE1, 0xE0,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7,
  0xCF, 0x8F, 0x1F, 0x1E, 0x3E, 0x3C, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE,
  0x07, 0xFC, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7,
  0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0x8C, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x40, 0xF8, 0x61, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x00, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFC,
  0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x9E, 0x1F,
  0x3C, 0x7C, 0x78, 0xF8, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x0F,
  0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x78, 0x3C, 0x3E, 0xF0, 0xF8,
  0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xE3, 0xE7, 0x8F, 0xC7, 0x8F, 0x1F, 0x9F,
  0x1E, 0x7F, 0x3E, 0x3C, 0xFE, 0x78, 0x79, 0xFD, 0xF1, 0xF7, 0xF3, 0xC3,
  0xEF, 0xE7, 0x87, 0xFD, 0xDF, 0x0F, 0xFB, 0xBC, 0x1E, 0xE7, 0xF8, 0x3F,
  0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3D, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC3,
  0xC1, 0xF0, 0x7C, 0x00, 0xF8, 0x7F, 0xE3, 0xEF, 0x8F, 0x3E, 0x7C, 0xF9,
  0xE1, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0xF1, 0xE3, 0xC3, 0x87,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x70, 0xF1, 0xE3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E,
  0x78, 0xF1, 0xE3, 0xC7, 0x9E, 0x0E, 0xF0, 0x3F, 0xC0, 0xF0, 0x7F, 0xFF,
  0xFE, 0xFF, 0xE0, 0xF8, 0xF8, 0xF1, 0xE1, 0xE0, 0x07, 0x9E, 0x1F, 0xBC,
  0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x78,
  0x78, 0xF0, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0x78, 0x3C, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xCF,
  0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xE7,
  0x8F, 0x9E, 0x3E, 0xFD, 0xF3, 0xFF, 0xCF, 0xFE, 0x39, 0xF0, 0x0F, 0xE1,
  0xFF, 0x3F, 0xE3, 0xFC, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x07, 0xDE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3E, 0x7C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8,
  0x78, 0xF8, 0xF8, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3C, 0xE0,
  0x07, 0xE1, 0xFF, 0x3F, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF9, 0xFF, 0xFE,
  0xFF, 0xCF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x8C, 0xFF, 0xC7, 0xFC,
  0x3F, 0x80, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x17,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xEF, 0x07, 0xEF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x81, 0xF0,
  0xE3, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xBE, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xF3, 0xC7, 0x9F, 0x1E,
  0x7C, 0x79, 0xE3, 0xE7, 0x8F, 0x9E, 0x3C, 0xF8, 0xF3, 0xE3, 0xCF, 0x1F,
  0x3C, 0x7C, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x1E,
  0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC1, 0x7C, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x1F,
  0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x3E, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF0, 0xF0, 0x07, 0x87, 0xC3, 0xE1,
  0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0x1E,
  0xF9, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xE7, 0x8F, 0x1E, 0x7C, 0x78, 0xF3, 0xE7,
  0xC7, 0x9E, 0x3E, 0x7C, 0xF1, 0xE3, 0xE7, 0x8F, 0x1E, 0x7C, 0x78, 0xF3,
  0xE7, 0xC7, 0x9E, 0x3C, 0x7C, 0xF1, 0xE3, 0xC0, 0x1E, 0xF8, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C, 0x79,
  0xF1, 0xE7, 0x8F, 0x9E, 0x3E, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0x3C, 0x7C,
  0xF1, 0xF0, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xCF, 0xBC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE3, 0xEF, 0x1E, 0x7F,
  0xF3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xBE, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xDF, 0x0F, 0x8F, 0x0F, 0x8F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x1F, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3D, 0xF8, 0x3D, 0xF0, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x1F, 0xBC, 0x7F, 0xF0,
  0xFF, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x78, 0x78, 0xF0,
  0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3D, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x1E, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xA3, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xE6, 0x3C,
  0x03, 0xE0, 0x3E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x87,
  0xCF, 0xFC, 0xFF, 0x8F, 0xF8, 0xFE, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x78,
  0x3F, 0xDF, 0xE7, 0xFB, 0xFE, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3E, 0x8F, 0xE3, 0xF8, 0x7E, 0x00, 0x3E, 0x7C,
  0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x7C, 0x79, 0xE3, 0xE7, 0x8F, 0x9E, 0x3C,
  0xF8, 0xF3, 0xE3, 0xCF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0x78, 0x79, 0xC0, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x3E,
  0x79, 0xE3, 0xCF, 0x1E, 0xF0, 0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0xF1, 0xF1, 0xFF, 0x1F,
  0x1E, 0xF3, 0xF3, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xCF, 0x7F, 0x78, 0xF7,
  0xF7, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F,
  0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x87, 0xCF, 0x81, 0xE7, 0x80, 0xF7, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xFB, 0xE0, 0xF9,
  0xF0, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3,
  0xC0, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07,
  0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x0B, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x07, 0xF0, 0x7E, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF0, 0x00, 0x18, 0x0B, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xC0, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 12, 8, 13, 3, -22 },
  { 38, 16, 22, 16, 0, -22 },
  { 82, 15, 26, 14, 0, -24 },
  { 131, 20, 22, 23, 2, -22 },
  { 186, 17, 22, 17, 0, -22 },
  { 233, 6, 8, 8, 3, -22 },
  { 239, 11, 27, 9, 0, -22 },
  { 277, 10, 28, 9, -2, -23 },
  { 312, 12, 14, 13, 2, -24 },
  { 333, 13, 15, 15, 1, -18 },
  { 358, 8, 8, 8, -2, -4 },
  { 366, 9, 4, 9, 0, -10 },
  { 371, 5, 5, 8, 0, -5 },
  { 375, 17, 22, 12, -2, -22 },
  { 422, 13, 22, 14, 1, -22 },
  { 458, 11, 22, 14, 3, -22 },
  { 489, 15, 22, 14, -1, -22 },
  { 531, 14, 22, 14, 0, -22 },
  { 570, 14, 22, 14, 0, -22 },
  { 609, 14, 22, 14, 0, -22 },
  { 648, 14, 22, 14, 1, -22 },
  { 687, 15, 22, 14, 1, -22 },
  { 729, 14, 22, 14, 0, -22 },
  { 768, 14, 22, 14, 0, -22 },
  { 807, 8, 17, 8, 0, -17 },
  { 824, 10, 21, 8, -2, -17 },
  { 851, 13, 15, 15, 1, -19 },
  { 876, 13, 10, 15, 1, -16 },
  { 893, 13, 15, 15, 1, -19 },
  { 918, 11, 22, 11, 1, -22 },
  { 949, 20, 24, 21, 1, -22 },
  { 1009, 16, 22, 15, -2, -22 },
  { 1053, 16, 22, 15, 0, -22 },
  { 1097, 15, 22, 14, 1, -22 },
  { 1139, 16, 22, 16, 0, -22 },
  { 1183, 14, 22, 13, 0, -22 },
  { 1222, 14, 22, 12, 0, -22 },
  { 1261, 17, 22, 17, 1, -22 },
  { 1308, 18, 22, 17, 0, -22 },
  { 1358, 14, 22, 11, -1, -22 },
  { 1397, 14, 29, 8, -5, -22 },
  { 1448, 18, 22, 15, 0, -22 },
  { 1498, 11, 22, 12, 0, -22 },
  { 1529, 23, 22, 22, 0, -22 },
  { 1593, 19, 22, 18, 0, -22 },
  { 1646, 16, 22, 17, 1, -22 },
  { 1690, 16, 22, 15, 0, -22 },
  { 1734, 16, 27, 17, 1, -22 },
  { 1788, 15, 22, 15, 0, -22 },
  { 1830, 16, 22, 13, -1, -22 },
  { 1874, 13, 22, 13, 2, -22 },
  { 1910, 17, 22, 16, 1, -22 },
  { 1957, 15, 22, 15, 3, -22 },
  { 1999, 23, 22, 22, 2, -22 },
  { 2063, 19, 22, 14, -2, -22 },
  { 2116, 14, 22, 14, 3, -22 },
  { 2155, 16, 22, 13, -1, -22 },
  { 2199, 12, 27, 9, -1, -22 },
  { 2240, 7, 22, 12, 3, -22 },
  { 2260, 12, 27, 9, -2, -22 },
  { 2301, 14, 14, 14, 0, -22 },
  { 2326, 12, 3, 11, -3, 2 },
  { 2331, 7, 5, 10, 4, -24 },
  { 2336, 15, 17, 15, 0, -17 },
  { 2368, 14, 24, 15, 0, -24 },
  { 2410, 12, 17, 12, 1, -17 },
  { 2436, 16, 24, 15, 0, -24 },
  { 2484, 12, 17, 14, 1, -17 },
  { 2510, 17, 31, 9, -4, -24 },
  { 2576, 16, 24, 15, -1, -17 },
  { 2624, 14, 24, 15, 0, -24 },
  { 2666, 9, 24, 7, 0, -24 },
  { 2693, 13, 31, 7, -4, -24 },
  { 2744, 16, 24, 14, 0, -24 },
  { 2792, 9, 24, 7, 0, -24 },
  { 2819, 21, 17, 22, 0, -17 },
  { 2864, 14, 17, 15, 0, -17 },
  { 2894, 13, 17, 14, 1, -17 },
  { 2922, 16, 24, 15, -2, -17 },
  { 2970, 15, 24, 15, 0, -17 },
  { 3015, 12, 17, 10, 0, -17 },
  { 3041, 12, 17, 12, 0, -17 },
  { 3067, 10, 21, 10, 1, -21 },
  { 3094, 14, 17, 15, 1, -17 },
  { 3124, 13, 17, 13, 2, -17 },
  { 3152, 20, 17, 20, 2, -17 },
  { 3195, 17, 17, 13, -2, -17 },
  { 3232, 17, 24, 13, -2, -17 },
  { 3283, 13, 17, 11, -1, -17 },
  { 3311, 13, 27, 11, 0, -22 },
  { 3355, 4, 31, 12, 4, -24 },
  { 3371, 12, 27, 11, -2, -22 },
  { 3412, 13, 6, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC31PT7B_H_
