#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0x20, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F,
  0xE3, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7C, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFE, 0x78, 0x07, 0xFB, 0x86, 0x01, 0xFC, 0xE0, 0x80, 0x7F,
  0x30, 0x00, 0x1F, 0xCC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x19, 0xFC, 0x08,
  0x06, 0x7F, 0x03, 0x01, 0x9F, 0xC0, 0xE0, 0xEF, 0xF0, 0x7E, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x7C, 0x07, 0xE0,
  0x07, 0xE3, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8,
  0x3F, 0x00, 0x1F, 0x87, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0xFC,
  0x00, 0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x7E, 0x0F, 0x87, 0xE3,
  0xF3, 0xF1, 0xFF, 0x3F, 0x3F, 0x3F, 0x1F, 0xFD, 0xFF, 0xF9, 0xF9, 0xFF,
  0xEF, 0xFF, 0x9F, 0x9F, 0xFF, 0x3F, 0xF8, 0xFC, 0xFD, 0xF9, 0xFF, 0x8F,
  0xCF, 0xC7, 0xE7, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x07, 0xE7, 0xE1, 0xF8,
  0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0xFC, 0x00, 0x7E, 0x0F, 0xC7,
  0xE0, 0x07, 0xE0, 0x7E, 0x3F, 0x00, 0x7E, 0x03, 0xF3, 0xF0, 0x03, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01,
  0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0xFF, 0x03, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xFD, 0xFE, 0x3F, 0xDF, 0xFF, 0xF0,
  0xFE, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8, 0xFF,
  0x07, 0xFF, 0xC3, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x20, 0x7E, 0x00, 0xE1, 0xF8, 0x03, 0xE7, 0xE0, 0x9F, 0xFF, 0x1E,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFF, 0x7E, 0x07, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0x0F, 0xC0,
  0x38, 0x3E, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xF7, 0xF8, 0x78, 0xFF, 0x0E,
  0x3F, 0xC0, 0x87, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xF3, 0xFF, 0x00, 0xF8, 0x3F, 0xE0, 0x0E, 0x07, 0xFC, 0x01, 0x80, 0xFF,
  0x80, 0x20, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xF1, 0xFF, 0x00, 0x60, 0x3F, 0xC0, 0x10, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC2, 0x00, 0x1F, 0xF0, 0xE0, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xCF, 0xE0, 0x03, 0xF7, 0xF8, 0x01, 0xF9, 0xFE, 0x00,
  0x7C, 0x7F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xC3, 0xFC,
  0x03, 0xF0, 0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x81, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x08, 0x00, 0xFF, 0x83, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x04, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x7F, 0xBF, 0xC0, 0x3F,
  0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0x03, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFE, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07,
  0xFD, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x78, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xF1, 0xFF, 0x0C, 0x07, 0xF8, 0x40, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x1C, 0x03, 0xF0, 0x7E, 0x07, 0xFE,
  0x1F, 0x07, 0xC1, 0xFF, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F, 0x87,
  0xFF, 0xF1, 0xF1, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE1, 0xF3,
  0xF0, 0xF8, 0x7E, 0x1F, 0x3E, 0x1F, 0x87, 0xE1, 0xF3, 0xE1, 0xF0, 0x7C,
  0x3F, 0x3E, 0x3F, 0x07, 0xC3, 0xE7, 0xE3, 0xF0, 0xFC, 0x3E, 0x7C, 0x3E,
  0x0F, 0xC3, 0xE7, 0xC3, 0xE0, 0xF8, 0x7C, 0x7C, 0x7E, 0x1F, 0x87, 0xC7,
  0xC7, 0xE1, 0xF8, 0x7C, 0xFC, 0x7E, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xF0,
  0xF8, 0xF8, 0x7E, 0x7F, 0x9F, 0x0F, 0x87, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0x83, 0xFE, 0x7F, 0xC0, 0xFC, 0x1F, 0xC7, 0xF8, 0x0F,
  0xC0, 0x70, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x3F, 0xC0,
  0x07, 0x00, 0x01, 0xFF, 0xCF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF,
  0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE,
  0x3F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFE, 0x7C, 0x07, 0xFE, 0x06, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x80, 0xFF, 0xC0, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF9, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0xFC, 0x07, 0xFF, 0x00, 0xC0, 0x3F, 0xE0, 0x02, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x1F, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x87, 0xF8,
  0x3F, 0xFC, 0x7F, 0xC1, 0xFF, 0xE3, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF,
  0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x04, 0x7F, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x7E, 0xFF,
  0x00, 0xFE, 0x7E, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0x3F, 0x3F, 0xC0, 0x7F,
  0x9F, 0xBF, 0x9F, 0xE0, 0x3F, 0xCF, 0xDF, 0xCF, 0xE0, 0x1F, 0xC7, 0xEF,
  0xCF, 0xF0, 0x0F, 0xE3, 0xFF, 0xE7, 0xF8, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80,
  0x7F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFE, 0x0F,
  0xF0, 0x0F, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xF8,
  0x7F, 0x80, 0x7F, 0x7F, 0x1F, 0xE0, 0x1F, 0xDF, 0xC7, 0xF8, 0x07, 0xF7,
  0xF1, 0xFC, 0x03, 0xFD, 0xFC, 0x7F, 0x00, 0xFF, 0x7F, 0x1F, 0xC0, 0x3F,
  0x9F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFB, 0xFC, 0x03, 0xF8, 0xFE, 0xFE, 0x01,
  0xFE, 0x3F, 0xBF, 0x80, 0x7F, 0x8F, 0xEF, 0xE0, 0x1F, 0xC3, 0xFF, 0xF8,
  0x07, 0xF0, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0x81, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0xFC, 0x03, 0xF8, 0x1F,
  0xFE, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8,
  0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xF8, 0x1F, 0xE1, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0x81, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0x07, 0x00, 0x7F, 0xC0, 0x60, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x08, 0x01, 0xFF, 0x03, 0x80, 0x3F, 0xC0, 0x7C, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0xFE, 0x07,
  0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFF, 0x83,
  0xFC, 0x1F, 0xC1, 0xFF, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0xE1, 0xFE, 0x07,
  0xF0, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xFE, 0x3F,
  0xC0, 0x7F, 0x9F, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xDF, 0x9F, 0xE0, 0x1F,
  0xE7, 0xEF, 0xCF, 0xF0, 0x0F, 0xF7, 0xF7, 0xE7, 0xF8, 0x07, 0xFB, 0xF3,
  0xF7, 0xF8, 0x03, 0xFF, 0xF9, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0xFD, 0xFC,
  0x00, 0xFE, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x87,
  0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8,
  0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0xFE,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFB, 0xFC, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xF3,
  0xF8, 0x0F, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x9F, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xC0, 0x7F, 0xF7,
  0xF0, 0x0F, 0xF9, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFE, 0x07, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8,
  0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xC0, 0x7E, 0x7F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFE, 0x18, 0x1F, 0xF0, 0x20, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x08, 0x3F, 0xE0,
  0x40, 0xFF, 0xCF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0x83, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xFB, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0x00, 0x3F, 0xE7, 0xE0, 0x01, 0xFC,
  0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFE, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x7F, 0x81, 0xFC, 0xFF,
  0x07, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x10, 0xFF, 0x80, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0xEF, 0xE0, 0x0F, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0x10, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0xFF, 0x00, 0xC0, 0x1F, 0xF0,
  0x0F, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE7, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0xFF, 0x80, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x07,
  0xE3, 0xFC, 0x3F, 0xC0, 0x1F, 0xBF, 0xF9, 0xFF, 0x80, 0xFE, 0xFF, 0xEF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0x9F, 0xF8, 0x0F, 0xEF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xF9, 0xFF,
  0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xF9, 0xFE,
  0x07, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F,
  0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x87, 0xFC,
  0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x7E, 0x7F, 0xC0, 0x0F, 0xEF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F,
  0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xFC, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x40, 0x3F, 0xC7, 0xE0, 0x1F, 0xFB, 0xF8, 0x0F, 0xFE, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE0, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x10, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0x20, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE2, 0x00, 0xFF, 0x18, 0x0F,
  0xF8, 0xF8, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xA0, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F,
  0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFE, 0x03, 0xFE, 0x7E, 0x00,
  0xFE, 0x3F, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xE7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC,
  0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF,
  0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0x7F, 0x87,
  0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0xC3, 0xF9, 0xFE, 0x3F, 0xF8, 0x7F, 0x3F,
  0xC7, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0xE3, 0xF8, 0xFF, 0x3F, 0xFC, 0xFF,
  0x1F, 0xE7, 0xFF, 0x9F, 0xC3, 0xF9, 0xFB, 0xF3, 0xF8, 0x7F, 0x3F, 0x7E,
  0xFF, 0x0F, 0xE7, 0xFF, 0x9F, 0xC1, 0xFD, 0xFB, 0xF3, 0xF8, 0x3F, 0xBF,
  0x7E, 0xFE, 0x07, 0xF7, 0xEF, 0xDF, 0xC0, 0xFF, 0xF9, 0xFB, 0xF8, 0x1F,
  0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0,
  0x0F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x7F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 17, 40, 14, 0, -39 },
  { 86, 21, 14, 23, 5, -39 },
  { 123, 29, 39, 28, 0, -39 },
  { 265, 26, 45, 25, 0, -42 },
  { 412, 37, 41, 41, 3, -40 },
  { 602, 30, 41, 30, 0, -40 },
  { 756, 11, 14, 13, 5, -39 },
  { 776, 19, 49, 15, 1, -40 },
  { 893, 19, 49, 15, -4, -40 },
  { 1010, 22, 24, 23, 4, -42 },
  { 1076, 23, 27, 26, 2, -33 },
  { 1154, 13, 16, 14, -3, -8 },
  { 1180, 15, 7, 16, 1, -18 },
  { 1194, 9, 10, 14, 0, -9 },
  { 1206, 29, 41, 21, -3, -40 },
  { 1355, 24, 41, 25, 1, -40 },
  { 1478, 19, 39, 25, 5, -39 },
  { 1571, 27, 40, 25, -2, -40 },
  { 1706, 26, 41, 25, -1, -40 },
  { 1840, 26, 39, 25, -1, -39 },
  { 1967, 26, 40, 25, 0, -39 },
  { 2097, 25, 41, 25, 2, -40 },
  { 2226, 27, 39, 25, 1, -39 },
  { 2358, 26, 41, 25, 0, -40 },
  { 2492, 25, 41, 25, 0, -40 },
  { 2621, 14, 32, 14, 0, -31 },
  { 2677, 17, 39, 14, -3, -31 },
  { 2760, 23, 27, 26, 2, -33 },
  { 2838, 23, 18, 26, 2, -28 },
  { 2890, 24, 27, 26, 2, -33 },
  { 2971, 21, 41, 19, 1, -40 },
  { 3079, 36, 44, 37, 1, -40 },
  { 3277, 27, 39, 27, -3, -39 },
  { 3409, 28, 39, 27, 0, -39 },
  { 3546, 26, 41, 25, 2, -40 },
  { 3680, 29, 39, 29, 0, -39 },
  { 3822, 25, 39, 22, 0, -39 },
  { 3944, 25, 39, 22, 0, -39 },
  { 4066, 29, 41, 29, 2, -40 },
  { 4215, 32, 39, 30, 0, -39 },
  { 4371, 25, 39, 19, -2, -39 },
  { 4493, 25, 51, 14, -9, -39 },
  { 4653, 32, 39, 27, 0, -39 },
  { 4809, 19, 39, 22, 0, -39 },
  { 4902, 41, 39, 39, 0, -39 },
  { 5102, 34, 39, 32, 0, -39 },
  { 5268, 28, 41, 31, 2, -40 },
  { 5412, 28, 39, 26, 0, -39 },
  { 5549, 28, 49, 31, 2, -40 },
  { 5721, 27, 39, 27, 0, -39 },
  { 5853, 27, 41, 23, -1, -40 },
  { 5992, 23, 39, 23, 4, -39 },
  { 6105, 29, 40, 29, 2, -39 },
  { 6250, 27, 39, 27, 5, -39 },
  { 6382, 41, 39, 40, 4, -39 },
  { 6582, 33, 39, 26, -3, -39 },
  { 6743, 25, 39, 25, 5, -39 },
  { 6865, 28, 39, 23, -2, -39 },
  { 7002, 22, 49, 16, -2, -40 },
  { 7137, 13, 41, 21, 5, -40 },
  { 7204, 22, 49, 16, -4, -40 },
  { 7339, 26, 24, 25, -1, -39 },
  { 7417, 20, 5, 19, -5, 4 },
  { 7430, 11, 9, 17, 8, -42 },
  { 7443, 26, 32, 26, 1, -31 },
  { 7547, 26, 43, 26, -1, -42 },
  { 7687, 22, 32, 21, 1, -31 },
  { 7775, 28, 43, 26, 1, -42 },
  { 7926, 23, 32, 24, 1, -31 },
  { 8018, 28, 55, 16, -6, -42 },
  { 8211, 28, 44, 26, -1, -31 },
  { 8365, 26, 42, 26, -1, -42 },
  { 8502, 17, 42, 13, -1, -42 },
  { 8592, 23, 55, 13, -7, -42 },
  { 8751, 29, 42, 25, -1, -42 },
  { 8904, 17, 42, 13, -1, -42 },
  { 8994, 38, 31, 38, -1, -31 },
  { 9142, 26, 31, 26, -1, -31 },
  { 9243, 23, 32, 25, 1, -31 },
  { 9335, 28, 44, 26, -3, -31 },
  { 9489, 26, 44, 26, 1, -31 },
  { 9632, 22, 31, 18, -1, -31 },
  { 9718, 21, 32, 20, 0, -31 },
  { 9802, 17, 37, 17, 2, -36 },
  { 9881, 25, 31, 26, 1, -30 },
  { 9978, 23, 30, 23, 3, -30 },
  { 10065, 35, 30, 35, 3, -30 },
  { 10197, 29, 30, 24, -3, -30 },
  { 10306, 31, 43, 23, -4, -30 },
  { 10473, 24, 30, 20, -2, -30 },
  { 10563, 23, 48, 19, 0, -39 },
  { 10701, 7, 55, 21, 7, -42 },
  { 10750, 21, 48, 19, -3, -39 },
  { 10876, 24, 9, 26, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC55PT7B_H_
