#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x57, 0x20, 0xB8, 0x35, 0x76, 0xFA, 0x27, 0x42, 0xEC, 0x69, 0xCB,
  0x9B, 0x35, 0x60, 0x25, 0x6F, 0xBF, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92,
  0xB0, 0xDF, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x64, 0x88, 0x25,
  0xFA, 0xAE, 0x7B, 0x25, 0x00, 0x67, 0x26, 0xCE, 0x67, 0x26, 0x2E, 0x32,
  0x6A, 0xE6, 0x74, 0x62, 0x2E, 0x34, 0x6E, 0xAE, 0x71, 0x22, 0x4C, 0x65,
  0x66, 0xAE, 0x67, 0xF6, 0x2C, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86,
  0x3C, 0x74, 0xA1, 0x80, 0x3A, 0x6F, 0xBB, 0xC1, 0xC0, 0x26, 0x66, 0xEB,
  0x75, 0x7E, 0xBE, 0x35, 0x4C, 0xC6, 0x65, 0x5D, 0xBE, 0x74, 0x4E, 0x8E,
  0x74, 0x4E, 0x88, 0x3A, 0x91, 0xED, 0x38, 0x5A, 0x9D, 0xE9, 0x58, 0x69,
  0x25, 0x80, 0x24, 0x94, 0x94, 0x5A, 0x98, 0xCA, 0x50, 0x49, 0x69, 0xC0,
  0x6D, 0xB7, 0xDE, 0xBA, 0xA0, 0x6B, 0x5C, 0xEB, 0x58, 0x35, 0x5D, 0xD6,
  0x75, 0x5E, 0x88, 0x35, 0x5D, 0xD6, 0x20, 0x65, 0x56, 0xAA, 0x75, 0x46,
  0x2E, 0xEB, 0x49, 0x00, 0x5A, 0x95, 0xAB, 0x70, 0xBA, 0xAC, 0xC8, 0xAD,
  0x7F, 0xEB, 0x50, 0x57, 0x66, 0xEA, 0xB7, 0x69, 0x00, 0x72, 0x24, 0xCE,
  0x69, 0x49, 0x30, 0xAA, 0xB0, 0x32, 0x22, 0x26, 0xC0, 0x26, 0x69, 0xE0,
  0xC0, 0x7A, 0xAE, 0x44, 0x7F, 0xAE, 0x72, 0x70, 0x11, 0x7A, 0xAE, 0x7E,
  0x70, 0x32, 0x72, 0x44, 0x4C, 0x7A, 0xAE, 0x2C, 0x44, 0x7E, 0xAA, 0x47,
  0xA0, 0x20, 0xB4, 0x96, 0x45, 0x6E, 0xEA, 0x57, 0xA0, 0x7F, 0x6B, 0x50,
  0x7E, 0xAA, 0x6B, 0xAE, 0x7F, 0xAE, 0x88, 0x7A, 0xAE, 0x26, 0x7A, 0x40,
  0xE9, 0xE0, 0x5D, 0x4C, 0x5E, 0xAE, 0xF6, 0x64, 0xFE, 0xED, 0x34, 0x76,
  0x6A, 0x79, 0x8C, 0x46, 0x60, 0xEB, 0x60, 0x2D, 0x64, 0xB0, 0xFF, 0x49,
  0x35, 0x20, 0x5B,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 4, 6, 4, 0, -6 },
  { 18, 1, 2, 2, 1, -6 },
  { 19, 3, 7, 2, 0, -6 },
  { 22, 3, 7, 2, -1, -6 },
  { 25, 3, 3, 3, 1, -6 },
  { 27, 4, 4, 4, 0, -5 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -3 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 4, 6, 3, 0, -6 },
  { 35, 4, 6, 4, 0, -6 },
  { 38, 3, 6, 4, 1, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 5, 2, 0, -4 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 3, 6, 3, 0, -6 },
  { 76, 5, 7, 5, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 3, 0, -6 },
  { 96, 4, 6, 3, 0, -6 },
  { 99, 5, 6, 4, 0, -6 },
  { 103, 5, 6, 4, 0, -6 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 3, 8, 2, -1, -6 },
  { 113, 5, 6, 4, 0, -6 },
  { 117, 3, 6, 3, 0, -6 },
  { 120, 6, 6, 6, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 4, 6, 4, 0, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 4, 7, 4, 0, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 4, 6, 3, 0, -6 },
  { 145, 3, 6, 3, 1, -6 },
  { 148, 5, 6, 4, 0, -6 },
  { 152, 4, 6, 4, 1, -6 },
  { 155, 5, 6, 6, 1, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 3, 6, 4, 1, -6 },
  { 165, 4, 6, 3, 0, -6 },
  { 168, 3, 7, 2, 0, -6 },
  { 171, 2, 6, 3, 1, -6 },
  { 173, 4, 7, 2, -1, -6 },
  { 177, 4, 4, 4, 0, -6 },
  { 179, 3, 1, 3, -1, 0 },
  { 180, 2, 1, 3, 1, -6 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 6, 4, 0, -6 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 4, 6, 4, 0, -6 },
  { 191, 3, 4, 4, 0, -4 },
  { 193, 4, 8, 2, -1, -6 },
  { 197, 4, 6, 4, 0, -4 },
  { 200, 4, 6, 4, 0, -6 },
  { 203, 2, 6, 2, 0, -6 },
  { 205, 3, 8, 2, -1, -6 },
  { 208, 4, 6, 4, 0, -6 },
  { 211, 2, 6, 2, 0, -6 },
  { 213, 5, 4, 6, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 4, 3, 0, -4 },
  { 230, 3, 5, 3, 0, -5 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 4, 3, 0, -4 },
  { 236, 6, 4, 5, 0, -4 },
  { 239, 4, 4, 3, 0, -4 },
  { 241, 5, 6, 3, -1, -4 },
  { 245, 3, 4, 3, 0, -4 },
  { 247, 3, 7, 3, 0, -6 },
  { 250, 1, 8, 3, 1, -6 },
  { 251, 3, 7, 3, 0, -6 },
  { 254, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC8PT7B_H_
