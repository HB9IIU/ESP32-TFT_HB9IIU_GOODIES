#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x78, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xDE, 0xF7, 0xBD,
  0xCE, 0x73, 0x9C, 0xEF, 0x78, 0x03, 0x98, 0x0E, 0xE0, 0x33, 0x81, 0xCC,
  0x07, 0x70, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x0C, 0xE0, 0x73, 0x81, 0xCC,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC3, 0xB8, 0x0C, 0xE0, 0x73, 0x01, 0xDC,
  0x0E, 0x70, 0x00, 0x00, 0x80, 0x08, 0x03, 0xE0, 0xFF, 0x1F, 0xF1, 0xFE,
  0x3D, 0x23, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x5C,
  0x45, 0xC6, 0x7C, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x0E, 0x07, 0x07, 0xC3, 0x83, 0xF0, 0xC1, 0xCC, 0x70, 0x77, 0x38, 0x19,
  0xCE, 0x06, 0x77, 0x03, 0x9D, 0xC0, 0xEE, 0xE7, 0xBF, 0xBB, 0xE7, 0xDD,
  0xDC, 0xE6, 0x67, 0x03, 0xB9, 0xC0, 0xCE, 0x60, 0x73, 0xB8, 0x38, 0xEE,
  0x0E, 0x3F, 0x07, 0x0F, 0xC3, 0xC1, 0xE0, 0x01, 0xC0, 0x1F, 0x80, 0xFF,
  0x03, 0x9C, 0x1E, 0x70, 0x7B, 0xC1, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x73, 0xFB, 0xDF, 0xEE, 0x73, 0xFB, 0xCF, 0xCF, 0x1F, 0x3C, 0xF8, 0xFF,
  0xF1, 0xFF, 0xC7, 0xEF, 0x80, 0x7B, 0xDE, 0xF7, 0x3B, 0xC0, 0x03, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0,
  0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x83,
  0x83, 0xC0, 0x0E, 0x03, 0x84, 0xE1, 0xFB, 0xFF, 0xDF, 0xF1, 0xF8, 0xF8,
  0xF7, 0x1D, 0xE2, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C, 0xE7, 0x9E,
  0x73, 0xCE, 0x38, 0x7E, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x1F, 0xF3, 0xDE, 0xF3,
  0xDE, 0x7B, 0x8F, 0xF1, 0xFE, 0x3B, 0xCF, 0x79, 0xEE, 0x3D, 0xC7, 0x39,
  0xE7, 0x78, 0xFF, 0x1F, 0xC1, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0xF8, 0x7E,
  0x3F, 0xBF, 0xC7, 0x70, 0xBC, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x3F, 0x83, 0xFC,
  0x3F, 0xF0, 0xC7, 0x84, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x04, 0x7F, 0xC7, 0xFE,
  0x3F, 0xF0, 0x07, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x10, 0xF0, 0x0F, 0x00,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC8, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xDE, 0x1D, 0xC3, 0xBC, 0x33, 0xC7,
  0x3C, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xF8,
  0x3F, 0xC3, 0xFC, 0x13, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xCC, 0x7C,
  0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x01, 0xF0, 0x7E, 0x0F, 0xE1, 0xF2, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0xF8, 0x7F, 0xCF, 0xFC, 0xFB, 0xCF, 0x3C, 0xF3,
  0xCE, 0x3C, 0xE3, 0x8F, 0x78, 0xFF, 0x8F, 0xF0, 0x7E, 0x00, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFE, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF,
  0x1C, 0xE1, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0xC7, 0xBC, 0x71, 0xCF, 0x1E,
  0xF1, 0xCF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0x80, 0xFE, 0x1F,
  0xE1, 0xFF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x79, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFE, 0x19, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0xFF, 0x0F, 0xE0, 0xFC,
  0x00, 0x1C, 0x7C, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x8F,
  0x1E, 0x00, 0x0E, 0x1F, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x20, 0x0C, 0x07,
  0x87, 0xF3, 0xF9, 0xFC, 0x3E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0x80,
  0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xF8, 0x3F,
  0x1F, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x0E, 0x1F, 0xDF, 0xEE, 0xF4,
  0x38, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0xF0, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xE7, 0x83,
  0xC0, 0xE1, 0xC0, 0x31, 0xCF, 0x99, 0xCF, 0xEE, 0xEE, 0x67, 0x67, 0x33,
  0x77, 0x39, 0xBB, 0x9C, 0xD9, 0xCC, 0xEC, 0xCE, 0x66, 0x77, 0x73, 0x3F,
  0xF1, 0x8E, 0x70, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x18, 0x07, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xDC,
  0x0E, 0xE0, 0xF7, 0x07, 0x38, 0x79, 0xC3, 0xCE, 0x1C, 0x71, 0xFF, 0x8F,
  0xFC, 0xFF, 0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0xFE, 0x1E, 0x0F, 0x80, 0x7F,
  0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xE7, 0x9E, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8E, 0x7C, 0xFF,
  0xE7, 0xFE, 0x3F, 0xC0, 0x03, 0xE0, 0x7F, 0x0F, 0xF1, 0xFE, 0x3E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x98, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x0F, 0x00, 0x3F,
  0xC1, 0xFF, 0x87, 0xFE, 0x1E, 0x78, 0x79, 0xF1, 0xC3, 0xCF, 0x1F, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x9F, 0x1D,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0x87,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xFF, 0x8F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE,
  0x3E, 0x10, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x79, 0xFB, 0xCF, 0xCF, 0x3F,
  0x3C, 0xFC, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3E, 0x78, 0x7F, 0xE1, 0xFF,
  0x83, 0xFC, 0x00, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC7, 0x80, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x60, 0x00, 0x0F, 0x1E,
  0x1C, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0x78, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x38, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x80, 0x0F, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0x83, 0xF0, 0xF8,
  0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F,
  0x8F, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xBB, 0xFC, 0x3B, 0xBB, 0x87,
  0xBB, 0xB8, 0x7B, 0xF7, 0x87, 0xBF, 0x78, 0x73, 0xE7, 0x87, 0x3E, 0x70,
  0xF3, 0xCF, 0x0F, 0x3C, 0xF0, 0xF3, 0xCF, 0x00, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x0F, 0x1F, 0x8E, 0x1F, 0x8E, 0x1F, 0x9E, 0x1F, 0x9E, 0x3F, 0x9E,
  0x3F, 0x9C, 0x3B, 0xDC, 0x3B, 0xFC, 0x79, 0xFC, 0x79, 0xFC, 0x79, 0xF8,
  0x71, 0xF8, 0x71, 0xF8, 0xF1, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x03, 0xE0,
  0x3F, 0x87, 0xFE, 0x3F, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0x7C,
  0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x87, 0xFE, 0x3F, 0xF1,
  0xE7, 0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0xF1, 0xFF, 0x8F, 0xF8, 0xFF,
  0x87, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xE0, 0x3F, 0x87, 0xFE, 0x3F, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF,
  0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x78, 0x7B, 0xC7,
  0xDF, 0x7C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x0F, 0x00, 0x7F, 0x87, 0xFC, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C,
  0x71, 0xE7, 0x9E, 0x3C, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xBC, 0x3D,
  0xE1, 0xEF, 0x0E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x78, 0x01, 0xE0, 0x3F,
  0xC3, 0xFE, 0x1F, 0xE1, 0xF1, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF1, 0x07, 0x8E, 0x7C, 0x7F,
  0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x7F, 0xE1, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x70, 0xF3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xFF,
  0xC1, 0xFE, 0x03, 0xF0, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF,
  0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0xF3, 0xC3, 0xBC, 0x1D, 0xE0, 0xEE,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC7, 0x8F, 0x78, 0xF1, 0xEF, 0x3E, 0x3D,
  0xE7, 0xCF, 0x3C, 0xF9, 0xE7, 0xBF, 0x38, 0xF7, 0xEF, 0x1F, 0xFD, 0xE3,
  0xFB, 0xF8, 0x77, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x8F,
  0x07, 0x9E, 0x07, 0x9E, 0x07, 0xBC, 0x07, 0xBC, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF8,
  0xF0, 0xF7, 0x0F, 0x71, 0xE7, 0x9C, 0x7B, 0xC7, 0xB8, 0x7F, 0x87, 0xF0,
  0x7F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0,
  0x07, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xE7, 0x39, 0xCE, 0x7B, 0xCE, 0x73, 0x9C,
  0xE7, 0x3D, 0xE7, 0x39, 0xCE, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x07, 0xC1, 0xF8, 0x3F,
  0x00, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xDE, 0x38, 0xE7, 0x8E, 0x70, 0xEE, 0x0F, 0x7F, 0xFF, 0xF0, 0xF7, 0x9E,
  0x70, 0x02, 0x08, 0x7B, 0x87, 0xFC, 0x7F, 0xE3, 0xCF, 0x3C, 0x79, 0xE3,
  0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x87, 0xFC, 0x3F, 0xE1,
  0xE7, 0x00, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC8, 0x1D,
  0xE3, 0xFF, 0x3F, 0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x78, 0xF7, 0x8E, 0x79,
  0xE7, 0x9E, 0xFB, 0xCF, 0xFC, 0xFF, 0x8E, 0xF0, 0x01, 0x01, 0xFC, 0x7F,
  0x1F, 0xE3, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x3C,
  0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x11, 0xE0, 0xF7, 0x07, 0xFC, 0x3F, 0xF0, 0xF3, 0xC7, 0x8F,
  0x1E, 0x38, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xF3, 0xC1, 0xFF,
  0x07, 0xFC, 0x0E, 0x70, 0x01, 0x01, 0xF8, 0x7F, 0x9F, 0xF3, 0x8E, 0xF1,
  0xDF, 0xFB, 0xFE, 0x7F, 0x0E, 0x03, 0xC0, 0x38, 0x47, 0xF8, 0xFF, 0x0F,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7A, 0x03, 0xC0, 0x0F, 0x00,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01,
  0x04, 0x1E, 0xE0, 0xFF, 0x87, 0xFE, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x0F,
  0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0x7F, 0xE0, 0xFF, 0x83,
  0xDE, 0x00, 0x70, 0x03, 0xC2, 0x0F, 0x0F, 0xF8, 0x3F, 0xE0, 0x7E, 0x00,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC8, 0x1D, 0xE3, 0xFF,
  0x3F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0x0E, 0x1C, 0x78, 0x70, 0x00, 0x07,
  0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x80,
  0x01, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC3, 0xF0, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x71, 0xE7, 0x9E, 0x3D, 0xE1,
  0xFE, 0x0E, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0xF3,
  0xC7, 0x9E, 0x3C, 0xF1, 0xC7, 0x80, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0x00, 0x82, 0x07, 0xFB, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C,
  0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x39, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x1C, 0x73, 0xC7, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xE0,
  0x00, 0x81, 0xDE, 0x3F, 0xF3, 0xFF, 0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x8E,
  0x79, 0xE7, 0x9E, 0x71, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x06,
  0x07, 0xE3, 0xFD, 0xFF, 0x79, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE,
  0x3F, 0x9E, 0xFF, 0xBF, 0xC7, 0xE0, 0x00, 0x20, 0x1D, 0xE0, 0xFF, 0xC3,
  0xFF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x79, 0xE1,
  0xE7, 0x8F, 0xBC, 0x3F, 0xF0, 0xFF, 0x83, 0xBC, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x02, 0x08, 0x7B, 0x87, 0xFC,
  0x7F, 0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0x8F, 0x1C, 0x71, 0xE7, 0x8F, 0x3C,
  0x71, 0xE7, 0x8F, 0xFC, 0x3F, 0xE1, 0xEF, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xC7, 0x73, 0xFC, 0xFE, 0x3F,
  0x8F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x04, 0x07, 0xF3, 0xFC, 0xFE, 0x78, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xC0, 0xF2, 0x3C, 0xFF, 0x3F, 0x8F, 0xC0, 0x0C, 0x1C, 0x1C, 0x7F,
  0xFF, 0xFE, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xFC, 0xFC,
  0x7C, 0x38, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9E,
  0xF3, 0xDC, 0x73, 0x9E, 0x7F, 0xCF, 0xB9, 0xF7, 0x00, 0xE3, 0xF8, 0xFE,
  0x3B, 0x9E, 0xE7, 0x3B, 0xCE, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3C, 0x00, 0x73, 0xE7, 0xB9, 0xF3, 0x9C, 0xFB, 0xCE, 0xFD, 0xE7,
  0x7E, 0xE3, 0xB7, 0xF3, 0xFB, 0xF1, 0xFD, 0xB8, 0xFC, 0xFC, 0x7E, 0xFC,
  0x3F, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0xF7,
  0x87, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xF0, 0xF7, 0x87, 0x3C, 0x78, 0xF0, 0x0E, 0x3E, 0x1C, 0x78,
  0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x3F, 0xCF, 0xF9, 0xFF, 0x00, 0x00, 0x60, 0x7C, 0x1F, 0x03, 0xE0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x80,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x04, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x80, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1E, 0x0F, 0xC1, 0xF8, 0x3C, 0x00, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 10, 7, 11, 2, -19 },
  { 29, 14, 19, 13, 0, -19 },
  { 63, 12, 22, 12, 0, -20 },
  { 96, 18, 19, 19, 1, -19 },
  { 139, 14, 19, 14, 0, -19 },
  { 173, 5, 7, 6, 2, -19 },
  { 178, 9, 23, 7, 0, -19 },
  { 204, 9, 23, 7, -2, -19 },
  { 230, 10, 11, 11, 2, -20 },
  { 244, 11, 12, 13, 1, -15 },
  { 261, 6, 8, 6, -1, -4 },
  { 267, 7, 4, 8, 0, -9 },
  { 271, 4, 4, 6, 0, -4 },
  { 273, 13, 19, 10, -1, -19 },
  { 304, 11, 19, 12, 1, -19 },
  { 331, 10, 19, 12, 2, -19 },
  { 355, 13, 19, 12, -1, -19 },
  { 386, 12, 19, 12, 0, -19 },
  { 415, 12, 19, 12, 0, -19 },
  { 444, 12, 19, 12, 0, -19 },
  { 473, 12, 19, 12, 1, -19 },
  { 502, 12, 19, 12, 1, -19 },
  { 531, 12, 19, 12, 0, -19 },
  { 560, 12, 19, 12, 0, -19 },
  { 589, 7, 14, 7, 0, -14 },
  { 602, 8, 18, 7, -1, -14 },
  { 620, 11, 13, 13, 1, -16 },
  { 638, 11, 8, 13, 1, -13 },
  { 649, 11, 13, 13, 1, -16 },
  { 667, 9, 19, 9, 1, -19 },
  { 689, 17, 21, 18, 1, -19 },
  { 734, 13, 19, 13, -2, -19 },
  { 765, 13, 19, 13, 0, -19 },
  { 796, 12, 19, 12, 1, -19 },
  { 825, 14, 19, 14, 0, -19 },
  { 859, 12, 19, 11, 0, -19 },
  { 888, 12, 19, 10, 0, -19 },
  { 917, 14, 19, 14, 1, -19 },
  { 951, 15, 19, 14, 0, -19 },
  { 987, 12, 19, 9, -1, -19 },
  { 1016, 12, 25, 7, -4, -19 },
  { 1054, 15, 19, 13, 0, -19 },
  { 1090, 9, 19, 10, 0, -19 },
  { 1112, 20, 19, 19, 0, -19 },
  { 1160, 16, 19, 15, 0, -19 },
  { 1198, 13, 19, 15, 1, -19 },
  { 1229, 13, 19, 12, 0, -19 },
  { 1260, 13, 23, 15, 1, -19 },
  { 1298, 13, 19, 13, 0, -19 },
  { 1329, 13, 19, 11, -1, -19 },
  { 1360, 11, 19, 11, 2, -19 },
  { 1387, 14, 19, 14, 1, -19 },
  { 1421, 13, 19, 13, 2, -19 },
  { 1452, 19, 19, 19, 2, -19 },
  { 1498, 16, 19, 12, -2, -19 },
  { 1536, 12, 19, 12, 2, -19 },
  { 1565, 13, 19, 11, -1, -19 },
  { 1596, 10, 23, 7, -1, -19 },
  { 1625, 5, 19, 10, 3, -19 },
  { 1637, 11, 23, 7, -2, -19 },
  { 1669, 12, 12, 12, 0, -19 },
  { 1687, 10, 2, 9, -3, 2 },
  { 1690, 5, 4, 8, 4, -20 },
  { 1693, 13, 15, 12, 0, -15 },
  { 1718, 12, 20, 12, 0, -20 },
  { 1748, 11, 15, 10, 0, -15 },
  { 1769, 14, 20, 12, 0, -20 },
  { 1804, 11, 15, 11, 0, -15 },
  { 1825, 14, 26, 8, -3, -20 },
  { 1871, 14, 21, 12, -1, -15 },
  { 1908, 12, 20, 12, 0, -20 },
  { 1938, 7, 20, 6, 0, -20 },
  { 1956, 10, 26, 6, -3, -20 },
  { 1989, 13, 20, 12, 0, -20 },
  { 2022, 8, 20, 6, 0, -20 },
  { 2042, 18, 15, 18, 0, -15 },
  { 2076, 12, 15, 12, 0, -15 },
  { 2099, 10, 15, 12, 1, -15 },
  { 2118, 14, 21, 12, -2, -15 },
  { 2155, 13, 21, 12, 0, -15 },
  { 2190, 10, 15, 9, 0, -15 },
  { 2209, 10, 15, 10, 0, -15 },
  { 2228, 8, 17, 8, 1, -17 },
  { 2245, 11, 14, 12, 1, -14 },
  { 2265, 10, 14, 11, 2, -14 },
  { 2283, 17, 14, 17, 1, -14 },
  { 2313, 13, 14, 11, -1, -14 },
  { 2336, 15, 20, 11, -2, -14 },
  { 2374, 11, 14, 9, -1, -14 },
  { 2394, 11, 23, 9, 0, -19 },
  { 2426, 3, 26, 10, 3, -20 },
  { 2436, 11, 23, 9, -2, -19 },
  { 2468, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC26PT7B_H_
