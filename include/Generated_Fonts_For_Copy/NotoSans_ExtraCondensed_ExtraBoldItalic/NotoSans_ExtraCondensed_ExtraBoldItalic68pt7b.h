#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x38, 0xF8, 0x01, 0xFF,
  0x38, 0x70, 0x03, 0xFE, 0x70, 0x10, 0x03, 0xFE, 0x70, 0x00, 0x03, 0xFE,
  0x70, 0x00, 0x03, 0xFE, 0x70, 0x00, 0x03, 0xFF, 0x70, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xBF, 0xE0, 0x00, 0x07, 0xBF, 0xE0, 0x20, 0x07,
  0x3F, 0xE0, 0x30, 0x07, 0x3F, 0xE0, 0x38, 0x07, 0x3F, 0xE0, 0x3E, 0x07,
  0x7F, 0xE0, 0x3F, 0x8F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x1F, 0xE0, 0x00, 0x3F,
  0x87, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x8F, 0xF0, 0x3E, 0x0F, 0xE1,
  0xFC, 0x7F, 0x07, 0xFC, 0x7F, 0x1F, 0xE7, 0xF8, 0xFF, 0xF3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0x1F,
  0xC7, 0xFF, 0xF7, 0xFF, 0xF1, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0x8F, 0xE3,
  0xF8, 0xFE, 0xFF, 0xF8, 0xFE, 0x3F, 0x87, 0xF3, 0xFF, 0x0F, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x83, 0xF8,
  0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xF0, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xCF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0x83, 0xFF,
  0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x3F,
  0xC0, 0x0F, 0x07, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x3F, 0x9F, 0xC1, 0xCF,
  0xFF, 0xF9, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x1F, 0xFD, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xC3, 0xFF, 0x01, 0xF8, 0x7F, 0xC0, 0x1E, 0x07, 0xE0,
  0x01, 0x80, 0xF0, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x0F, 0x83, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF9, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF,
  0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80,
  0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF,
  0xF8, 0x7F, 0xDF, 0xF8, 0x3F, 0x9F, 0xF8, 0x3F, 0x1F, 0xF8, 0x1E, 0x1F,
  0xF0, 0x0C, 0x3F, 0xF0, 0x08, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFF,
  0xC0, 0x0F, 0xC0, 0xFF, 0xE0, 0x07, 0x80, 0x7F, 0xF0, 0x01, 0x80, 0x3F,
  0xF8, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x38,
  0x03, 0xFF, 0x00, 0x20, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x80, 0x00, 0xFF, 0xE0, 0xE0, 0x01, 0xFF, 0xE0, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F,
  0xDF, 0xF8, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x7F,
  0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0xFE, 0x3F, 0xF0, 0x01, 0xFC,
  0x3F, 0xF0, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF0,
  0x7F, 0xE0, 0x07, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0x1F, 0xFF, 0x80, 0x10, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x20, 0x00, 0xFF,
  0xE0, 0x70, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x38, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F,
  0xFC, 0x03, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0xE3, 0xFF, 0x83, 0x80, 0xFF, 0xC1, 0x00, 0x3F, 0xE1, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xC7, 0xF0,
  0x7F, 0x03, 0xFF, 0xFC, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x03,
  0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x07, 0xF0,
  0x7E, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0x0F, 0xE0, 0xFC, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC3,
  0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF0, 0xFC, 0x1F, 0xC7, 0xFC,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xDF, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F,
  0xC0, 0x7F, 0xC7, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x1C, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x04,
  0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x78, 0x01, 0xFF, 0xE0,
  0x01, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0x07, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xE0,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x1F, 0xEF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE3, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0x9F, 0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF7,
  0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0xC3, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xBF, 0xE3, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0xFF, 0x80,
  0x1F, 0xF3, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x01, 0xFF,
  0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFD, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0x83, 0xFD, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xF8, 0x0E, 0x00, 0x3F, 0xF8, 0x01,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x04, 0x00, 0x0F, 0xFE, 0x01, 0x00, 0x07, 0xFF, 0x01,
  0xE0, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC7, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x87,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x3F, 0xDF,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF7, 0xF9, 0xFF, 0x80, 0x3F, 0xF7, 0xFD,
  0xFE, 0x7F, 0xC0, 0x0F, 0xFD, 0xFE, 0x7F, 0xBF, 0xF0, 0x03, 0xFE, 0x7F,
  0x9F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE7, 0xFB, 0xFE, 0x00, 0x3F, 0xEF,
  0xF1, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x7F, 0x7F, 0xE0, 0x03, 0xFF,
  0xFE, 0x1F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F,
  0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFD,
  0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x07,
  0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x00,
  0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC7, 0xE0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xDF, 0x01, 0xFF, 0xC0, 0x40, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x04, 0x0F, 0xFE, 0x01, 0x01, 0xFF, 0xC0, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF,
  0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xE0, 0x00, 0x7F, 0xF3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF,
  0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x02, 0x07, 0xFC, 0x00, 0x60, 0x7F, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF1, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xF8, 0x00,
  0x7F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x1C, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x0C, 0x00,
  0x1F, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0x8F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFE,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFB,
  0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x3F, 0xFC,
  0x00, 0xFF, 0x7F, 0xFE, 0x00, 0xFE, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00,
  0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x81,
  0xFF, 0x8F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xFE, 0x00, 0x0F, 0xF3, 0xFF, 0xE0,
  0x03, 0xFE, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xEF, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xFC, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x7F, 0xF9, 0xFE, 0x00, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x7F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFD, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03,
  0xC3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xEC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0x03, 0xFF, 0x01, 0x80, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC2, 0x00, 0x3F, 0xF0, 0xC0, 0x1F, 0xFC, 0x3C, 0x07,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC1,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x00, 0x3F, 0xFC,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xF9, 0xFF, 0x80, 0xFF,
  0xCF, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F,
  0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xC3, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03,
  0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFB,
  0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x7F,
  0xC0, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xFF, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFF, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0xCF, 0xFF, 0xE3, 0xFE,
  0x07, 0xFC, 0xFE, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xEF, 0xE7, 0xFC, 0x07,
  0xFD, 0xFE, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xCF, 0xE7, 0xFC, 0x07, 0xFD,
  0xFC, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xCF, 0xEF, 0xF8, 0x07, 0xFB, 0xF8,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x9F, 0xFF, 0xF0, 0x07, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x23, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00,
  0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xA0, 0x00, 0xFF, 0xF1, 0x00, 0x00, 0xFE,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 20, 50, 17, 0, -49 },
  { 126, 26, 18, 29, 6, -49 },
  { 185, 36, 49, 34, 0, -49 },
  { 406, 32, 56, 30, 0, -52 },
  { 630, 45, 50, 51, 4, -49 },
  { 912, 38, 50, 38, 0, -49 },
  { 1150, 13, 18, 17, 6, -49 },
  { 1180, 23, 60, 19, 1, -49 },
  { 1353, 23, 61, 19, -5, -50 },
  { 1529, 27, 30, 29, 5, -52 },
  { 1631, 28, 32, 33, 3, -40 },
  { 1743, 16, 18, 17, -4, -9 },
  { 1779, 18, 9, 20, 1, -23 },
  { 1800, 11, 12, 17, 0, -11 },
  { 1817, 36, 50, 26, -4, -49 },
  { 2042, 29, 50, 30, 2, -49 },
  { 2224, 24, 49, 31, 6, -49 },
  { 2371, 33, 49, 30, -2, -49 },
  { 2574, 32, 50, 30, -1, -49 },
  { 2774, 32, 49, 31, -1, -49 },
  { 2970, 31, 50, 30, 1, -49 },
  { 3164, 31, 50, 30, 2, -49 },
  { 3358, 32, 48, 30, 2, -48 },
  { 3550, 32, 50, 30, 0, -49 },
  { 3750, 31, 50, 30, 0, -49 },
  { 3944, 17, 39, 17, 0, -38 },
  { 4027, 21, 47, 17, -4, -38 },
  { 4151, 28, 33, 33, 3, -41 },
  { 4267, 28, 22, 33, 3, -35 },
  { 4344, 29, 33, 33, 3, -41 },
  { 4464, 25, 50, 24, 2, -49 },
  { 4621, 44, 54, 46, 2, -49 },
  { 4918, 34, 49, 34, -4, -49 },
  { 5127, 34, 49, 34, 0, -49 },
  { 5336, 33, 50, 31, 2, -49 },
  { 5543, 36, 49, 36, 0, -49 },
  { 5764, 31, 49, 28, 0, -49 },
  { 5954, 31, 49, 27, 0, -49 },
  { 6144, 36, 50, 36, 2, -49 },
  { 6369, 40, 49, 37, 0, -49 },
  { 6614, 31, 49, 23, -3, -49 },
  { 6804, 31, 64, 18, -11, -49 },
  { 7052, 40, 49, 33, 0, -49 },
  { 7297, 23, 49, 27, 0, -49 },
  { 7438, 51, 49, 49, 0, -49 },
  { 7751, 42, 49, 40, 0, -49 },
  { 8009, 36, 50, 38, 2, -49 },
  { 8234, 34, 49, 32, 0, -49 },
  { 8443, 36, 61, 38, 2, -49 },
  { 8718, 34, 49, 33, 0, -49 },
  { 8927, 33, 50, 29, -1, -49 },
  { 9134, 28, 49, 28, 5, -49 },
  { 9306, 37, 50, 36, 2, -49 },
  { 9538, 33, 49, 33, 6, -49 },
  { 9741, 50, 49, 49, 5, -49 },
  { 10048, 41, 49, 32, -4, -49 },
  { 10300, 31, 49, 31, 6, -49 },
  { 10490, 36, 49, 28, -3, -49 },
  { 10711, 28, 60, 19, -3, -49 },
  { 10921, 15, 50, 26, 7, -49 },
  { 11015, 28, 60, 19, -5, -49 },
  { 11225, 32, 31, 30, -1, -49 },
  { 11349, 26, 6, 24, -7, 5 },
  { 11369, 13, 11, 21, 10, -52 },
  { 11387, 32, 39, 32, 1, -38 },
  { 11543, 32, 53, 32, -1, -52 },
  { 11755, 27, 39, 26, 1, -38 },
  { 11887, 35, 53, 32, 1, -52 },
  { 12119, 28, 39, 30, 1, -38 },
  { 12256, 36, 68, 20, -8, -52 },
  { 12562, 35, 54, 32, -2, -38 },
  { 12799, 32, 52, 32, -1, -52 },
  { 13007, 21, 52, 16, -1, -52 },
  { 13144, 29, 68, 16, -9, -52 },
  { 13391, 35, 52, 31, -1, -52 },
  { 13619, 21, 52, 16, -1, -52 },
  { 13756, 47, 38, 47, -1, -38 },
  { 13980, 32, 38, 32, -1, -38 },
  { 14132, 29, 39, 31, 1, -38 },
  { 14274, 35, 54, 32, -4, -38 },
  { 14511, 32, 54, 32, 1, -38 },
  { 14727, 27, 38, 23, -1, -38 },
  { 14856, 26, 39, 25, 0, -38 },
  { 14983, 22, 46, 21, 2, -45 },
  { 15110, 32, 38, 32, 1, -37 },
  { 15262, 29, 37, 29, 4, -37 },
  { 15397, 44, 37, 44, 3, -37 },
  { 15601, 35, 37, 29, -3, -37 },
  { 15763, 38, 53, 29, -5, -37 },
  { 16015, 30, 37, 25, -3, -37 },
  { 16154, 27, 60, 23, 1, -49 },
  { 16357, 9, 68, 26, 8, -52 },
  { 16434, 27, 60, 23, -4, -49 },
  { 16637, 29, 12, 33, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC68PT7B_H_
