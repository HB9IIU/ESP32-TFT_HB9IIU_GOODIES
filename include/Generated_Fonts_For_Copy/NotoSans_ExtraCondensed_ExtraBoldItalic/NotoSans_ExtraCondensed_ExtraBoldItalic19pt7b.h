#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x70, 0x00, 0x38, 0xE3, 0x80,
  0x6F, 0xDF, 0xB6, 0x6D, 0xC0, 0x06, 0xC3, 0x60, 0xD8, 0x36, 0x3F, 0xDF,
  0xF1, 0xB0, 0xCC, 0xFF, 0xBF, 0xE6, 0x61, 0xB0, 0x6C, 0x33, 0x00, 0x02,
  0x07, 0x8F, 0xE7, 0xA3, 0x41, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x95, 0x9F,
  0xCF, 0xC0, 0x80, 0x40, 0x18, 0x63, 0xE7, 0x1B, 0x31, 0x9B, 0x0C, 0xD8,
  0x6D, 0x83, 0x6D, 0xDE, 0xDF, 0x66, 0xD8, 0x6C, 0xC7, 0x6C, 0x33, 0x63,
  0x1F, 0x18, 0x70, 0x06, 0x03, 0xF0, 0x6E, 0x0D, 0xC3, 0xB0, 0x3E, 0x07,
  0x89, 0xE6, 0x7F, 0xDD, 0xF3, 0x9E, 0x73, 0x8F, 0xF8, 0xF7, 0x00, 0x7F,
  0xFC, 0x0E, 0x18, 0x61, 0xC3, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0x60, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xC3, 0x87, 0x0E,
  0x18, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0xE0, 0x10, 0x1C, 0x58, 0x7F, 0xFF,
  0x3C, 0x7C, 0x2E, 0x08, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x37, 0x76, 0xEC, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x00, 0x06, 0x0F, 0x87, 0xC7, 0x73, 0x3B, 0x9D, 0xCC, 0xCE, 0x67,
  0x33, 0xB9, 0x8D, 0xC7, 0xC3, 0xC0, 0x0C, 0x73, 0xDF, 0xFD, 0x63, 0x8E,
  0x38, 0xE3, 0x1C, 0x71, 0xC0, 0x07, 0x03, 0xE1, 0xFC, 0x47, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0x3F, 0xC0, 0x0E,
  0x1F, 0x8F, 0xE4, 0x70, 0x30, 0x38, 0x78, 0x7C, 0x0E, 0x03, 0x81, 0x91,
  0xCF, 0xE7, 0xC0, 0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xF0, 0xF8, 0xD8, 0xCC,
  0x6E, 0x7F, 0xBF, 0xC1, 0x80, 0xC0, 0xE0, 0x1F, 0x8F, 0xC7, 0xC7, 0x03,
  0x81, 0xE0, 0xF8, 0xFE, 0x07, 0x03, 0x83, 0x91, 0xCF, 0xC7, 0xC0, 0x07,
  0x1F, 0x3F, 0x70, 0x70, 0xEC, 0xFE, 0xEE, 0xEE, 0xCE, 0xCE, 0xDC, 0xFC,
  0x78, 0x3F, 0xCF, 0xE3, 0xF8, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x00, 0x0E, 0x0F, 0x8E, 0xE6, 0x73,
  0x39, 0xF8, 0x78, 0x7C, 0x7E, 0x73, 0xB9, 0xDC, 0xCF, 0xE3, 0xE0, 0x0E,
  0x0F, 0x8F, 0xC6, 0x77, 0x3B, 0x9D, 0xDC, 0xFE, 0x3F, 0x03, 0x83, 0x83,
  0xCF, 0xC7, 0xC0, 0x11, 0xCE, 0x60, 0x00, 0x00, 0x67, 0x38, 0x08, 0x71,
  0xC6, 0x00, 0x00, 0x00, 0x31, 0xC7, 0x18, 0xE3, 0x00, 0x03, 0x0F, 0x3E,
  0xF0, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x3E, 0xF0, 0xC0, 0x80, 0x1C, 0x3E, 0x3F,
  0x47, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x60, 0x70, 0xE0, 0x01,
  0xC0, 0x3F, 0x87, 0x0C, 0x30, 0x33, 0x3D, 0xB3, 0x6D, 0xB3, 0x6D, 0xB2,
  0x4D, 0xB6, 0x4D, 0xB3, 0xF9, 0x99, 0x86, 0x00, 0x38, 0x40, 0xFE, 0x00,
  0x03, 0x83, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x76, 0x33, 0x39, 0x9F, 0xDF,
  0xEE, 0x7E, 0x3F, 0x1C, 0x1E, 0x07, 0xE3, 0xFC, 0xE7, 0x39, 0x8C, 0xE3,
  0xF1, 0xFC, 0x73, 0x1C, 0xE6, 0x73, 0x9C, 0xFE, 0x3F, 0x00, 0x0F, 0x0F,
  0xCF, 0xCE, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x8F,
  0xC3, 0xE0, 0x1E, 0x07, 0xE3, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0x1D, 0xC7,
  0x73, 0x9C, 0xE6, 0x7B, 0xFC, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0x8F, 0xC7,
  0x03, 0x81, 0xC0, 0xF8, 0xFC, 0x70, 0x38, 0x18, 0x1C, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0x8F, 0xC7, 0x03, 0x81, 0xC0, 0xF8, 0xFC, 0x7E, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x00, 0x07, 0x07, 0xF3, 0xF9, 0xE2, 0x70, 0x38, 0x0E,
  0x7B, 0xBE, 0xEF, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0x1F, 0x80, 0x1C, 0xE3,
  0x1C, 0xE3, 0x9C, 0x63, 0x9C, 0x73, 0x8F, 0xF3, 0xFE, 0x71, 0x8E, 0x71,
  0x8E, 0x71, 0xCE, 0x39, 0xCE, 0x00, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x07, 0xC7, 0xE0, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0x71, 0x70, 0xF8, 0x78, 0x00, 0x1C, 0xE3, 0x38, 0xE7, 0x1D,
  0xC3, 0xF0, 0x6E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0x98, 0x73, 0x8E,
  0x71, 0xCE, 0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC6, 0x38,
  0xFF, 0xF0, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x1F, 0x3E, 0x78, 0xFB,
  0xE3, 0xEF, 0x9F, 0xFE, 0x7F, 0xB9, 0xBE, 0xC6, 0xF7, 0x3B, 0xDC, 0xEE,
  0x73, 0xB9, 0xC0, 0x1C, 0x71, 0xC7, 0x3C, 0x63, 0xCE, 0x3E, 0xE3, 0xEE,
  0x36, 0xC7, 0x6C, 0x76, 0xC6, 0x7C, 0x67, 0xCE, 0x78, 0xE3, 0x8E, 0x38,
  0x0F, 0x07, 0xE3, 0xF9, 0xCE, 0x71, 0xF8, 0x7E, 0x3B, 0x8E, 0xE3, 0xB8,
  0xEE, 0x73, 0xBC, 0xFE, 0x1F, 0x00, 0x1E, 0x07, 0xE3, 0xF8, 0xE7, 0x39,
  0xCE, 0xE3, 0x39, 0xFC, 0x7E, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x00,
  0x0F, 0x07, 0xE3, 0xF9, 0xCE, 0x71, 0xF8, 0x6E, 0x3B, 0x8E, 0xE3, 0xB8,
  0xEE, 0x73, 0xBC, 0xFE, 0x1F, 0x01, 0xC0, 0x70, 0x1E, 0x00, 0x1E, 0x0F,
  0xCF, 0xE7, 0x73, 0xB9, 0x9C, 0xDE, 0xFE, 0x7E, 0x3F, 0x19, 0x9C, 0xEE,
  0x77, 0x38, 0x0F, 0x0F, 0xCF, 0xC7, 0x23, 0x81, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x23, 0x9B, 0xCF, 0xC7, 0xC0, 0x7F, 0x7F, 0xFF, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x39, 0xCC, 0x77, 0x19,
  0xCE, 0x73, 0x98, 0xEE, 0x3B, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xB8, 0xFE,
  0x1F, 0x00, 0xE3, 0xF1, 0xF9, 0xD8, 0xEC, 0xE6, 0x73, 0x31, 0xB8, 0xD8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0x63, 0x8D, 0x8E, 0x76, 0x39, 0xD9,
  0xEE, 0x67, 0xB9, 0xBE, 0xC6, 0xF7, 0x3B, 0xDC, 0xFB, 0x63, 0xEF, 0x8F,
  0xBE, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x00, 0x1C, 0xE3, 0x9C, 0x77, 0x06,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x1F, 0x03, 0xE0, 0xFC, 0x3B, 0x87,
  0x31, 0xC7, 0x00, 0xE7, 0xE7, 0xEE, 0xEE, 0xFC, 0xFC, 0x78, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x7F, 0x3F, 0x80, 0x0F,
  0x1F, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0xF8, 0xF0, 0xCC, 0xEE, 0xE6, 0x66, 0x66, 0x77, 0x73, 0x1E,
  0x3C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C,
  0x78, 0xF0, 0x06, 0x07, 0x03, 0x83, 0xC1, 0xF1, 0xB9, 0xCC, 0xC6, 0xE3,
  0x80, 0xFF, 0xFC, 0xEE, 0x70, 0x08, 0x1F, 0xCF, 0xEE, 0x77, 0x33, 0x3B,
  0x9D, 0xCE, 0xEF, 0x7F, 0x1D, 0x80, 0x1C, 0x1C, 0x0E, 0x07, 0x43, 0x71,
  0xFD, 0xCE, 0xE7, 0x73, 0xB1, 0x99, 0xDC, 0xEF, 0xE6, 0xE0, 0x0E, 0x1F,
  0x3E, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE4, 0x7C, 0x7C, 0x01, 0xC0, 0x70,
  0x18, 0x26, 0x3F, 0x8F, 0xE7, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x73, 0xB8,
  0xFE, 0x1D, 0x80, 0x0C, 0x1F, 0x3F, 0x73, 0x67, 0x7E, 0xF8, 0xE0, 0xE2,
  0x7E, 0x7C, 0x01, 0x01, 0xF0, 0x78, 0x18, 0x0E, 0x87, 0xC1, 0xF0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x3C,
  0x0F, 0x03, 0x00, 0x04, 0x07, 0xB1, 0xFC, 0xE7, 0x39, 0x8C, 0xE7, 0x39,
  0xCE, 0x77, 0x9F, 0xC3, 0xF0, 0x1C, 0x87, 0x3F, 0x8F, 0xC0, 0xC0, 0x1C,
  0x1C, 0x0E, 0x07, 0x43, 0xF1, 0xFD, 0xCE, 0xE6, 0x77, 0x33, 0x99, 0xDC,
  0xEE, 0x67, 0x70, 0x08, 0xCE, 0x00, 0x1C, 0xCE, 0x73, 0x98, 0xCE, 0x73,
  0x80, 0x02, 0x0C, 0x38, 0x00, 0x01, 0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x71, 0xE3, 0x86, 0x00, 0x1C, 0x0E, 0x03, 0x80, 0xE1,
  0x33, 0x8D, 0xC7, 0x61, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xB8, 0xEE, 0x39,
  0xC0, 0x1C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x80,
  0x02, 0x31, 0xFB, 0xCF, 0xFE, 0xE7, 0x77, 0x33, 0xBB, 0x99, 0x9C, 0xCC,
  0xEE, 0xE6, 0x77, 0x33, 0xBB, 0x98, 0x02, 0x1F, 0x8F, 0xEE, 0x77, 0x33,
  0x99, 0x9C, 0xCE, 0xE7, 0x73, 0x3B, 0x80, 0x0C, 0x1F, 0x3F, 0x73, 0x73,
  0x63, 0xE7, 0xE7, 0xEE, 0x7E, 0x7C, 0x01, 0x06, 0xE1, 0xFC, 0xE7, 0x39,
  0xCE, 0x63, 0x18, 0xCE, 0x73, 0x9F, 0xC7, 0xE1, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0x08, 0x1E, 0xCF, 0xEE, 0x77, 0x33, 0x1B, 0x9D, 0xCE, 0xEE,
  0x7F, 0x1F, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x02, 0x6C, 0xFB, 0xC7,
  0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x80, 0x1C, 0x7D, 0xFB, 0x87, 0x07, 0x8F,
  0x0E, 0x9D, 0xFB, 0xE0, 0x30, 0xC3, 0x7E, 0xF9, 0x8E, 0x38, 0xE3, 0x0C,
  0x3C, 0xF0, 0x3B, 0x99, 0xDC, 0xEE, 0x67, 0x73, 0x39, 0x9D, 0xDC, 0xFE,
  0x3B, 0x00, 0xE7, 0xE6, 0xEE, 0xEC, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0,
  0xEF, 0x7E, 0xF6, 0xEF, 0x6F, 0xEE, 0xFE, 0xCD, 0xFC, 0xF7, 0x8F, 0x78,
  0xE7, 0x8E, 0x70, 0x39, 0xC6, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0,
  0xD8, 0x77, 0x39, 0xC0, 0x39, 0xCE, 0x63, 0xB8, 0xEC, 0x3F, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xF0, 0x38, 0x0C, 0x00, 0x3F,
  0x9F, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x7E, 0x7F, 0x00, 0x03,
  0x0F, 0x1E, 0x1C, 0x1C, 0x18, 0x38, 0x78, 0xF0, 0xF0, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x10, 0x38, 0x70, 0x60, 0xC3, 0x87, 0x0F, 0x0E, 0x3C, 0xE1, 0xC3, 0x86,
  0x1C, 0x78, 0xE0, 0xF9, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 10, 14, 10, 0, -14 },
  { 35, 9, 15, 9, 0, -14 },
  { 52, 13, 14, 14, 1, -14 },
  { 75, 11, 14, 11, 0, -14 },
  { 95, 3, 5, 5, 2, -14 },
  { 97, 7, 17, 5, 0, -14 },
  { 112, 7, 17, 5, -2, -14 },
  { 127, 8, 9, 8, 1, -15 },
  { 136, 8, 9, 9, 1, -11 },
  { 145, 4, 6, 5, -1, -3 },
  { 148, 5, 2, 6, 0, -6 },
  { 150, 3, 3, 5, 0, -3 },
  { 152, 10, 14, 7, -1, -14 },
  { 170, 9, 14, 9, 0, -14 },
  { 186, 6, 14, 9, 2, -14 },
  { 197, 10, 14, 9, -1, -14 },
  { 215, 9, 14, 9, 0, -14 },
  { 231, 9, 14, 9, 0, -14 },
  { 247, 9, 14, 9, 0, -14 },
  { 263, 8, 14, 9, 1, -14 },
  { 277, 10, 14, 9, 0, -14 },
  { 295, 9, 14, 9, 0, -14 },
  { 311, 9, 14, 9, 0, -14 },
  { 327, 5, 11, 5, 0, -11 },
  { 334, 6, 14, 5, -1, -11 },
  { 345, 8, 9, 9, 1, -11 },
  { 354, 8, 6, 9, 1, -10 },
  { 360, 8, 9, 9, 1, -11 },
  { 369, 8, 14, 7, 0, -14 },
  { 383, 13, 15, 13, 0, -14 },
  { 408, 9, 14, 9, -1, -14 },
  { 424, 10, 14, 9, 0, -14 },
  { 442, 9, 14, 9, 1, -14 },
  { 458, 10, 14, 10, 0, -14 },
  { 476, 9, 14, 8, 0, -14 },
  { 492, 9, 14, 7, 0, -14 },
  { 508, 10, 14, 10, 1, -14 },
  { 526, 11, 14, 10, 0, -14 },
  { 546, 9, 14, 7, -1, -14 },
  { 562, 9, 18, 5, -3, -14 },
  { 583, 11, 14, 9, 0, -14 },
  { 603, 6, 14, 7, 0, -14 },
  { 614, 14, 14, 14, 0, -14 },
  { 639, 12, 14, 11, 0, -14 },
  { 660, 10, 14, 11, 1, -14 },
  { 678, 10, 14, 9, 0, -14 },
  { 696, 10, 17, 11, 1, -14 },
  { 718, 9, 14, 9, 0, -14 },
  { 734, 9, 14, 8, 0, -14 },
  { 750, 8, 14, 8, 1, -14 },
  { 764, 10, 14, 10, 1, -14 },
  { 782, 9, 14, 9, 2, -14 },
  { 798, 14, 14, 14, 1, -14 },
  { 823, 11, 14, 9, -1, -14 },
  { 843, 8, 14, 9, 2, -14 },
  { 857, 10, 14, 8, -1, -14 },
  { 875, 8, 17, 5, -1, -14 },
  { 892, 4, 14, 7, 2, -14 },
  { 899, 7, 17, 5, -1, -14 },
  { 914, 9, 9, 9, 0, -14 },
  { 925, 7, 2, 7, -2, 1 },
  { 927, 4, 3, 6, 3, -15 },
  { 929, 9, 11, 9, 0, -11 },
  { 942, 9, 14, 9, 0, -14 },
  { 958, 8, 11, 7, 0, -11 },
  { 969, 10, 14, 9, 0, -14 },
  { 987, 8, 11, 8, 0, -11 },
  { 998, 10, 20, 6, -2, -15 },
  { 1023, 10, 16, 9, -1, -11 },
  { 1043, 9, 14, 9, 0, -14 },
  { 1059, 5, 15, 5, 0, -15 },
  { 1069, 7, 20, 5, -2, -15 },
  { 1087, 10, 14, 9, 0, -14 },
  { 1105, 6, 14, 5, 0, -14 },
  { 1116, 13, 11, 13, 0, -11 },
  { 1134, 9, 11, 9, 0, -11 },
  { 1147, 8, 11, 9, 0, -11 },
  { 1158, 10, 16, 9, -1, -11 },
  { 1178, 9, 16, 9, 0, -11 },
  { 1196, 7, 11, 6, 0, -11 },
  { 1206, 7, 11, 7, 0, -11 },
  { 1216, 6, 13, 6, 1, -13 },
  { 1226, 9, 10, 9, 0, -10 },
  { 1238, 8, 10, 8, 1, -10 },
  { 1248, 12, 10, 12, 1, -10 },
  { 1263, 10, 10, 8, -1, -10 },
  { 1276, 10, 15, 8, -1, -10 },
  { 1295, 9, 10, 7, -1, -10 },
  { 1307, 8, 17, 6, 0, -14 },
  { 1324, 3, 19, 7, 2, -15 },
  { 1332, 7, 17, 6, -1, -14 },
  { 1347, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC19PT7B_H_
