#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7C, 0x00, 0x7F, 0x3F, 0x7E, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8,
  0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x3E, 0x00,
  0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03, 0xE7, 0xC0,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x01, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x81, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF1, 0xF0, 0x03,
  0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFB, 0xC0, 0xFD, 0x88,
  0x0F, 0x98, 0x00, 0xFB, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x5F, 0x80, 0x0D, 0xF8, 0x40, 0xDF, 0x86, 0x0D, 0xF8, 0x78,
  0xDF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1E, 0x01, 0xFF,
  0x83, 0xE0, 0x3E, 0xF8, 0x3C, 0x03, 0xC7, 0x87, 0xC0, 0x7C, 0xF8, 0x78,
  0x07, 0x8F, 0x8F, 0x80, 0x78, 0xF9, 0xF0, 0x07, 0x8F, 0x1F, 0x00, 0xF8,
  0xF3, 0xE0, 0x0F, 0x9F, 0x3C, 0x00, 0xF9, 0xF7, 0xC7, 0xCF, 0x9E, 0x79,
  0xFE, 0xFF, 0xEF, 0x9F, 0xF7, 0xFC, 0xF3, 0xFF, 0x7F, 0x9F, 0x7C, 0xF3,
  0xF1, 0xE7, 0x8F, 0x00, 0x3E, 0x78, 0xF0, 0x07, 0xCF, 0x8F, 0x00, 0x78,
  0xF8, 0xF0, 0x0F, 0x8F, 0x1F, 0x00, 0xF0, 0xF1, 0xF0, 0x1F, 0x0F, 0x1E,
  0x01, 0xE0, 0xF3, 0xE0, 0x3E, 0x0F, 0x3C, 0x03, 0xC0, 0xFF, 0xC0, 0x7C,
  0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x1F, 0x87, 0xFE, 0x3F, 0x1F, 0xFE, 0xFC, 0x7F, 0xFD,
  0xF9, 0xFD, 0xFF, 0xE3, 0xF3, 0xFF, 0xC7, 0xC3, 0xFF, 0x1F, 0x87, 0xFE,
  0x3F, 0x0F, 0xF8, 0x7E, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0x03, 0xFC, 0x7F, 0x00,
  0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3C, 0x07, 0x9E, 0x03, 0xEF, 0x39,
  0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x03, 0xFF, 0xC3, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xF7, 0xC0, 0xF9, 0xF0, 0x38, 0xFC, 0x08, 0x78, 0x04,
  0x10, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0,
  0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFE, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xF7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0xFF, 0xF9, 0xFB, 0xF1, 0xEF, 0xC1, 0x9F, 0x82, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3C, 0x7F, 0x03,
  0x83, 0xF0, 0x30, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0x1F, 0xC0, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC4, 0x03, 0xF8, 0xC0, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x0F,
  0xFE, 0x01, 0xEF, 0xC0, 0x79, 0xF8, 0x1F, 0x3F, 0x03, 0xCF, 0xC0, 0xF1,
  0xF8, 0x3E, 0x3F, 0x07, 0x87, 0xE1, 0xF0, 0xF8, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x08, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x08, 0x07, 0xF0, 0xE0,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x60, 0x1F, 0xBF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E,
  0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFE,
  0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFB, 0xF0, 0x3F, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xCF, 0xC3, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC7,
  0xF3, 0xF8, 0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFD, 0xF8, 0x3F, 0x7E, 0x01, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1C, 0x3F, 0x10, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x81, 0xF0,
  0x00, 0x78, 0x7C, 0x0C, 0x0F, 0x0F, 0x0F, 0xF9, 0xE3, 0xC3, 0xFF, 0x3C,
  0x78, 0xFF, 0xE7, 0x9E, 0x3E, 0x7C, 0xF3, 0xC7, 0x8F, 0x1E, 0xF9, 0xF1,
  0xE3, 0xDE, 0x3C, 0x3C, 0x7B, 0xC7, 0x8F, 0x8F, 0x79, 0xE1, 0xE1, 0xDE,
  0x3C, 0x3C, 0x7B, 0xC7, 0x87, 0x8F, 0x78, 0xF1, 0xF3, 0xCF, 0x1E, 0x3C,
  0x79, 0xE3, 0xEF, 0xDE, 0x3C, 0x7F, 0xFF, 0x87, 0x8F, 0xEF, 0xF0, 0xF0,
  0xF8, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x04, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x00,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFC, 0x7E,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF8, 0x7E, 0x3F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFC, 0x60,
  0x3F, 0x81, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x40, 0x7F,
  0x0E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0xC1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F,
  0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07,
  0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC1, 0xC1, 0xFE, 0x02, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0xFF, 0xCF, 0xE3, 0xFE, 0x3F, 0x8F, 0xF8, 0xFC, 0x3F,
  0xE3, 0xF1, 0xFF, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x02, 0x7F, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xF1, 0xFC,
  0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F,
  0xBE, 0xFF, 0xF0, 0x1F, 0x3E, 0xFB, 0xF0, 0x1F, 0x3E, 0xFB, 0xF0, 0x3F,
  0x3F, 0xF3, 0xF0, 0x3F, 0x3F, 0xF3, 0xE0, 0x3F, 0x3F, 0xE7, 0xE0, 0x3E,
  0x3F, 0xE7, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E,
  0x3F, 0xCF, 0xC0, 0x7E, 0x3F, 0x8F, 0xC0, 0x7C, 0x3F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x1F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xF0, 0x7E,
  0x07, 0xFC, 0x1F, 0x81, 0xFF, 0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0,
  0x7C, 0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0xFF, 0xE3, 0xF0, 0x3E,
  0xF8, 0xFC, 0x0F, 0xBE, 0x3E, 0x07, 0xEF, 0x9F, 0x81, 0xFB, 0xF7, 0xE0,
  0x7E, 0xFD, 0xF8, 0x1F, 0x3F, 0x7C, 0x07, 0xC7, 0xDF, 0x03, 0xF1, 0xFF,
  0xC0, 0xFC, 0x7F, 0xF0, 0x3F, 0x1F, 0xFC, 0x0F, 0x87, 0xFE, 0x07, 0xE0,
  0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xF8, 0x1F, 0x83, 0xFE, 0x07,
  0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x3F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xF3, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xBF,
  0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x83,
  0xF8, 0x7F, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xF3, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x0F,
  0xCF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFD, 0xF0,
  0x1F, 0xC1, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0x00, 0xFE, 0x0C, 0x07, 0xF0, 0x7C,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x7E, 0xFC, 0x0F, 0x81,
  0xF9, 0xF8, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x1F,
  0x8F, 0x83, 0xF8, 0x3F, 0x1F, 0x07, 0xF0, 0xFE, 0x3E, 0x1F, 0xE1, 0xF8,
  0x7C, 0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x8F, 0xC3, 0xF1, 0xFF, 0x1F, 0x87,
  0xE3, 0xFE, 0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x1F, 0x9F, 0xF9, 0xF8, 0x3F,
  0x3F, 0xF7, 0xE0, 0x7E, 0xFB, 0xEF, 0xC0, 0xFD, 0xF7, 0xDF, 0x81, 0xFF,
  0xCF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x00,
  0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C,
  0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x3E, 0x1F, 0x83,
  0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3F, 0xFC, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x3F, 0x1F,
  0x1F, 0x0F, 0x03, 0xF3, 0xE0, 0xFE, 0x7C, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7E, 0x1F, 0xCF,
  0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0xFC, 0x0F, 0x8F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFB, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xFC,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3E, 0xFF, 0x07, 0xCF,
  0xC0, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x84, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x08, 0xFC,
  0x30, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0xBF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87,
  0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0xF8, 0x07, 0xC7, 0x80, 0x01,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7C,
  0xFC, 0x3E, 0xFC, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x02, 0x3F, 0x8F, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x8F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x0F,
  0xF7, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF9, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x3E, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x20, 0x1F, 0xC1, 0xC1, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFB, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x09, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xCF, 0xE0, 0x7E, 0x7E,
  0x03, 0xF7, 0xE0, 0x1F, 0xFE, 0x00, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0x9F, 0x87,
  0xE0, 0xFB, 0xFC, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFC, 0xFF, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0xFE,
  0x3F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC3, 0xE3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F,
  0x87, 0xE7, 0xE1, 0xF8, 0x7C, 0x7E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC,
  0x7C, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0xFC, 0xFC, 0x3F, 0x0F, 0x8F, 0xC3,
  0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0x9F, 0x81, 0xF7, 0xF8, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC0, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7,
  0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0xFE, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF3, 0xF0, 0x07, 0xDF,
  0xE0, 0x1F, 0x7F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF3, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0x3F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0xFC, 0x0F, 0x9F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x9F, 0x0F,
  0xBF, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xDE, 0x3F, 0x84, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x81, 0xFC, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0xF3, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE1, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC3, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFB, 0xE0, 0xFF, 0x7C, 0x0F, 0xCF,
  0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x87, 0xE7,
  0xC3, 0xF3, 0xE3, 0xF1, 0xF1, 0xF8, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C,
  0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x7C, 0x3F, 0x87, 0xEF, 0x87, 0xF0, 0xFD, 0xF0, 0xFE, 0x3F,
  0x3E, 0x3F, 0xC7, 0xE7, 0xC7, 0xF8, 0xF8, 0xF9, 0xFF, 0x3F, 0x1F, 0x3F,
  0xE7, 0xE7, 0xE7, 0xFC, 0xF8, 0xFD, 0xFF, 0xBF, 0x1F, 0xBF, 0xF7, 0xC3,
  0xF7, 0xBE, 0xF8, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE, 0xF7, 0xC1, 0xFF, 0x9E,
  0xF8, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F,
  0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x1F,
  0x87, 0xE0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x02, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x14,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x5F, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x0F, 0xFA, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 13, 30, 11, 0, -30 },
  { 50, 16, 11, 18, 4, -30 },
  { 72, 22, 30, 21, 0, -30 },
  { 155, 20, 34, 19, 0, -32 },
  { 240, 28, 30, 31, 2, -30 },
  { 345, 23, 30, 23, 0, -30 },
  { 432, 8, 11, 10, 4, -30 },
  { 443, 14, 37, 12, 1, -30 },
  { 508, 14, 38, 12, -3, -31 },
  { 575, 17, 18, 18, 3, -32 },
  { 614, 17, 20, 20, 2, -25 },
  { 657, 10, 12, 10, -2, -6 },
  { 672, 12, 6, 12, 0, -14 },
  { 681, 7, 7, 10, 0, -7 },
  { 688, 22, 30, 16, -2, -30 },
  { 771, 18, 30, 19, 1, -30 },
  { 839, 15, 30, 19, 4, -30 },
  { 896, 20, 30, 19, -1, -30 },
  { 971, 19, 30, 19, 0, -30 },
  { 1043, 19, 30, 19, 0, -30 },
  { 1115, 20, 30, 19, 0, -30 },
  { 1190, 19, 30, 19, 1, -30 },
  { 1262, 20, 30, 19, 1, -30 },
  { 1337, 20, 30, 19, 0, -30 },
  { 1412, 19, 30, 19, 0, -30 },
  { 1484, 11, 23, 11, 0, -23 },
  { 1516, 13, 29, 11, -2, -23 },
  { 1564, 17, 20, 20, 2, -25 },
  { 1607, 17, 14, 20, 2, -22 },
  { 1637, 18, 20, 20, 2, -25 },
  { 1682, 16, 30, 15, 1, -30 },
  { 1742, 27, 33, 28, 1, -30 },
  { 1854, 21, 30, 21, -3, -30 },
  { 1933, 21, 30, 21, 0, -30 },
  { 2012, 21, 30, 19, 1, -30 },
  { 2091, 22, 30, 22, 0, -30 },
  { 2174, 19, 30, 17, 0, -30 },
  { 2246, 19, 30, 17, 0, -30 },
  { 2318, 22, 30, 23, 2, -30 },
  { 2401, 24, 30, 23, 0, -30 },
  { 2491, 20, 30, 14, -2, -30 },
  { 2566, 20, 39, 11, -7, -30 },
  { 2664, 24, 30, 20, 0, -30 },
  { 2754, 14, 30, 16, 0, -30 },
  { 2807, 32, 30, 30, 0, -30 },
  { 2927, 26, 30, 24, 0, -30 },
  { 3025, 22, 30, 23, 1, -30 },
  { 3108, 21, 30, 20, 0, -30 },
  { 3187, 22, 37, 23, 1, -30 },
  { 3289, 21, 30, 20, 0, -30 },
  { 3368, 21, 30, 18, -1, -30 },
  { 3447, 18, 30, 17, 3, -30 },
  { 3515, 23, 30, 22, 1, -30 },
  { 3602, 20, 30, 21, 4, -30 },
  { 3677, 31, 30, 30, 3, -30 },
  { 3794, 25, 30, 20, -2, -30 },
  { 3888, 19, 30, 19, 4, -30 },
  { 3960, 22, 30, 17, -2, -30 },
  { 4043, 17, 37, 12, -2, -30 },
  { 4122, 9, 30, 16, 4, -30 },
  { 4156, 17, 37, 12, -3, -30 },
  { 4235, 20, 19, 19, -1, -30 },
  { 4283, 16, 4, 15, -4, 3 },
  { 4291, 8, 7, 13, 6, -32 },
  { 4298, 19, 23, 20, 1, -23 },
  { 4353, 19, 32, 20, 0, -32 },
  { 4429, 16, 23, 16, 1, -23 },
  { 4475, 21, 32, 20, 1, -32 },
  { 4559, 17, 23, 18, 1, -23 },
  { 4608, 22, 42, 12, -5, -32 },
  { 4724, 21, 33, 20, -1, -23 },
  { 4811, 19, 32, 20, 0, -32 },
  { 4887, 12, 32, 10, 0, -32 },
  { 4935, 17, 42, 10, -5, -32 },
  { 5025, 21, 32, 19, 0, -32 },
  { 5109, 12, 32, 10, 0, -32 },
  { 5157, 28, 23, 29, 0, -23 },
  { 5238, 19, 23, 20, 0, -23 },
  { 5293, 18, 24, 19, 1, -24 },
  { 5347, 22, 33, 20, -3, -23 },
  { 5438, 19, 33, 20, 1, -23 },
  { 5517, 16, 23, 14, 0, -23 },
  { 5563, 16, 23, 16, 0, -23 },
  { 5609, 14, 28, 13, 1, -28 },
  { 5658, 19, 23, 20, 1, -23 },
  { 5713, 17, 23, 18, 3, -23 },
  { 5762, 27, 23, 27, 2, -23 },
  { 5840, 22, 23, 18, -2, -23 },
  { 5904, 23, 33, 18, -3, -23 },
  { 5999, 19, 23, 15, -2, -23 },
  { 6054, 17, 37, 14, 0, -30 },
  { 6133, 5, 42, 16, 5, -32 },
  { 6160, 16, 37, 14, -2, -30 },
  { 6234, 18, 8, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC42PT7B_H_
