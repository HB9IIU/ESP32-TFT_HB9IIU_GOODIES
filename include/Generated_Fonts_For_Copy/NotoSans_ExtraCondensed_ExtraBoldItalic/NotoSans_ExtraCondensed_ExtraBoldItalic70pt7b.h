#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x1F,
  0xFC, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFE,
  0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0xC7,
  0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0xF1, 0xE0, 0x03, 0xFE, 0x70, 0x70,
  0x01, 0xFE, 0x38, 0x08, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0xFF, 0x8E, 0x00,
  0x00, 0x7F, 0xEE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xEF, 0xFC, 0x00, 0x00, 0x73, 0xFE, 0x00, 0x00,
  0x39, 0xFF, 0x01, 0x00, 0x1C, 0xFF, 0x80, 0xE0, 0x1E, 0x7F, 0xC0, 0x78,
  0x0E, 0x7F, 0xE0, 0x3F, 0x07, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x87, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE3,
  0xFC, 0x07, 0x83, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x8F, 0xE1, 0xFC, 0x7F,
  0x87, 0xFF, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0x8F, 0xF1,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x7F,
  0xFF, 0xDF, 0xFF, 0x8F, 0xF1, 0xFE, 0x7F, 0x7F, 0xFE, 0x3F, 0x8F, 0xF1,
  0xFC, 0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF1, 0xFF, 0x07, 0xF1, 0xFE, 0x1F,
  0xC1, 0xE0, 0x3F, 0xC7, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x00, 0x7F,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x3F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0x81, 0xFF,
  0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x18, 0x1F, 0xE0, 0x01, 0xC1, 0xFE, 0x00, 0x3F, 0x1F, 0xE0,
  0x23, 0xFD, 0xFC, 0x1E, 0x7F, 0xFF, 0xCF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0x3F, 0xE0, 0x3F, 0xF3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0,
  0x0F, 0xC1, 0xFF, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0x80, 0xF8, 0x00, 0x10,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xDF, 0xF8, 0x3F, 0xCF, 0xFC, 0x0F, 0xCF, 0xFC, 0x07,
  0xC7, 0xFE, 0x01, 0xC3, 0xFF, 0x00, 0x41, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xF0, 0x03,
  0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0xC0,
  0x06, 0x00, 0x7F, 0xE0, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xC0, 0x07,
  0x80, 0xFF, 0xE0, 0x03, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x00,
  0xFF, 0xE0, 0xC0, 0x00, 0xFF, 0xF0, 0x78, 0x00, 0xFF, 0xF0, 0x3F, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xFC, 0x00, 0x07, 0xF7, 0xFE, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x07,
  0xFB, 0xFF, 0x00, 0x03, 0xF9, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0xC0, 0x03,
  0xFC, 0x7F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x01, 0xFC, 0x3F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF8, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x80, 0x01, 0xFF, 0xC0, 0x80, 0x03, 0xFF, 0xC0, 0xE0,
  0x07, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x0C, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x38, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0, 0x70,
  0x0F, 0xFC, 0x18, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFC, 0x7F, 0x07, 0xF0, 0x3F,
  0xFF, 0xE1, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7E, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE7, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xFB,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x9F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE7, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x7F, 0x07,
  0xF0, 0x3F, 0x83, 0xF3, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0x9F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x0F, 0xC1, 0xFE, 0x7F, 0xE7, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xEF, 0xFF, 0x80,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0x3F,
  0x80, 0x7C, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F,
  0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF,
  0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF, 0x01, 0xC0, 0x07,
  0xFF, 0x80, 0x10, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x1F, 0xFE, 0x01, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xF1,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF3, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xE0, 0x07, 0xFF, 0xC0, 0x02, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x20, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0x80,
  0x0F, 0xFB, 0xFC, 0x1F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x7F,
  0xBF, 0xF0, 0x01, 0xFF, 0x3F, 0xC7, 0xFD, 0xFF, 0x80, 0x0F, 0xF9, 0xFE,
  0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0xCF, 0xF3, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0x9F, 0xE3, 0xFE, 0x00, 0x3F, 0xE3, 0xFD, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x7F, 0xE0, 0x07,
  0xFD, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x9F, 0xF1, 0xFF, 0x00, 0x3F, 0xF3,
  0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF9,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xE7, 0xFC,
  0x00, 0xFF, 0xC3, 0xFE, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xDF, 0xF0, 0x03,
  0xFE, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xEF,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF,
  0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xE0, 0x07, 0xFF, 0x80,
  0x70, 0x01, 0xFF, 0xC0, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x02, 0x00, 0x07, 0xFE, 0x00, 0xC0, 0x03, 0xFF, 0x80,
  0x7C, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE4,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFC, 0x1F,
  0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFC,
  0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC7,
  0xFB, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xBF, 0xC7, 0xFE, 0x00, 0x7F,
  0xCF, 0xFB, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x3F, 0xCF, 0xFC, 0x00,
  0xFF, 0xCF, 0xF3, 0xFD, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x7F, 0xDF, 0xF8,
  0x00, 0xFF, 0xDF, 0xE7, 0xFD, 0xFF, 0x80, 0x0F, 0xFD, 0xFE, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE7, 0xFB, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x7F,
  0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0x3F, 0xE0,
  0x1F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0x8F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xF0, 0x03,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xDF, 0xFE, 0x00, 0x7F, 0xDF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xC0, 0x0F, 0xF1,
  0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x30, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x08, 0x0F, 0xFE, 0x01, 0x80, 0x7F, 0xF0, 0x78, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0x00,
  0x0F, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xC7, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x81, 0xFF,
  0x80, 0x1C, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x88, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0xFB,
  0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFD, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xF0, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xDF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x41, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xEF,
  0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0x80, 0x1F, 0xE7,
  0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC,
  0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00,
  0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xE3, 0xFF, 0xC0, 0x01, 0xFE,
  0x7F, 0xFC, 0x00, 0x1F, 0xEF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x7F,
  0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xF0, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x81, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xBF,
  0xE0, 0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x07, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0x01, 0xFF,
  0x80, 0x60, 0x3F, 0xF0, 0x04, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x08, 0x00, 0xFF, 0xE1, 0x80, 0x1F, 0xF8, 0x3E, 0x0F, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x84, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0xC7,
  0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF,
  0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xCF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFE, 0x7F, 0xE0, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0x87,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7,
  0xF7, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0xBF, 0x9F, 0xF8, 0x1F, 0xF3, 0xFD,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xDF, 0xE7, 0xFC, 0x07, 0xFD, 0xFE, 0xFF,
  0x7F, 0xE0, 0x3F, 0xEF, 0xF7, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0x3F, 0xDF,
  0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x04, 0xFF, 0xF0, 0x00, 0x37, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xEC,
  0x00, 0x3F, 0xFF, 0x20, 0x00, 0x3F, 0xF0, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 21, 51, 18, 0, -50 },
  { 135, 26, 18, 29, 7, -50 },
  { 194, 37, 50, 35, 0, -50 },
  { 426, 33, 57, 31, 0, -53 },
  { 662, 46, 52, 52, 4, -51 },
  { 961, 39, 52, 39, 0, -51 },
  { 1215, 13, 18, 17, 7, -50 },
  { 1245, 24, 62, 19, 1, -51 },
  { 1431, 25, 62, 19, -6, -51 },
  { 1625, 28, 31, 30, 5, -54 },
  { 1734, 29, 34, 34, 3, -42 },
  { 1858, 17, 20, 17, -4, -10 },
  { 1901, 19, 10, 21, 1, -24 },
  { 1925, 12, 12, 17, 0, -11 },
  { 1943, 37, 52, 27, -4, -51 },
  { 2184, 30, 52, 31, 2, -51 },
  { 2379, 25, 50, 32, 6, -50 },
  { 2536, 34, 51, 31, -2, -51 },
  { 2753, 33, 52, 31, -1, -51 },
  { 2968, 33, 50, 32, -1, -50 },
  { 3175, 32, 51, 31, 1, -50 },
  { 3379, 32, 52, 31, 2, -51 },
  { 3587, 33, 50, 31, 2, -50 },
  { 3794, 33, 52, 31, 0, -51 },
  { 4009, 32, 52, 31, 0, -51 },
  { 4217, 18, 40, 18, 0, -39 },
  { 4307, 22, 49, 18, -4, -39 },
  { 4442, 29, 34, 34, 3, -42 },
  { 4566, 29, 23, 34, 3, -36 },
  { 4650, 30, 34, 34, 3, -42 },
  { 4778, 26, 52, 25, 2, -51 },
  { 4947, 45, 56, 47, 2, -51 },
  { 5262, 35, 50, 35, -4, -50 },
  { 5481, 35, 50, 35, 0, -50 },
  { 5700, 34, 52, 32, 2, -51 },
  { 5921, 37, 50, 37, 0, -50 },
  { 6153, 32, 50, 29, 0, -50 },
  { 6353, 32, 50, 28, 0, -50 },
  { 6553, 37, 52, 38, 3, -51 },
  { 6794, 41, 50, 38, 0, -50 },
  { 7051, 32, 50, 24, -3, -50 },
  { 7251, 32, 65, 18, -11, -50 },
  { 7511, 41, 50, 34, 0, -50 },
  { 7768, 24, 50, 27, 0, -50 },
  { 7918, 53, 50, 50, 0, -50 },
  { 8250, 43, 50, 41, 0, -50 },
  { 8519, 37, 52, 39, 2, -51 },
  { 8760, 35, 50, 33, 0, -50 },
  { 8979, 37, 63, 39, 2, -51 },
  { 9271, 35, 50, 34, 0, -50 },
  { 9490, 34, 52, 30, -1, -51 },
  { 9711, 29, 50, 29, 5, -50 },
  { 9893, 38, 51, 37, 2, -50 },
  { 10136, 35, 50, 34, 6, -50 },
  { 10355, 52, 50, 50, 5, -50 },
  { 10680, 42, 50, 33, -4, -50 },
  { 10943, 32, 50, 32, 6, -50 },
  { 11143, 37, 50, 29, -3, -50 },
  { 11375, 28, 62, 20, -3, -51 },
  { 11592, 15, 52, 27, 7, -51 },
  { 11690, 28, 62, 20, -5, -51 },
  { 11907, 33, 31, 31, -1, -50 },
  { 12035, 26, 7, 25, -7, 5 },
  { 12058, 14, 12, 22, 10, -54 },
  { 12079, 33, 40, 33, 1, -39 },
  { 12244, 33, 54, 33, -1, -53 },
  { 12467, 28, 40, 27, 1, -39 },
  { 12607, 36, 54, 33, 1, -53 },
  { 12850, 29, 40, 31, 1, -39 },
  { 12995, 36, 71, 20, -8, -54 },
  { 13315, 36, 56, 33, -2, -39 },
  { 13567, 33, 53, 33, -1, -53 },
  { 13786, 21, 54, 17, -1, -54 },
  { 13928, 29, 71, 17, -9, -54 },
  { 14186, 36, 53, 32, -1, -53 },
  { 14425, 22, 53, 17, -1, -53 },
  { 14571, 48, 39, 49, -1, -39 },
  { 14805, 33, 39, 33, -1, -39 },
  { 14966, 30, 40, 32, 1, -39 },
  { 15116, 36, 56, 33, -4, -39 },
  { 15368, 33, 56, 33, 1, -39 },
  { 15599, 28, 39, 24, -1, -39 },
  { 15736, 27, 40, 26, 0, -39 },
  { 15871, 22, 47, 22, 2, -46 },
  { 16001, 33, 39, 33, 1, -38 },
  { 16162, 30, 38, 30, 4, -38 },
  { 16305, 45, 38, 45, 4, -38 },
  { 16519, 37, 38, 30, -4, -38 },
  { 16695, 39, 55, 30, -5, -38 },
  { 16964, 31, 38, 25, -3, -38 },
  { 17112, 28, 61, 24, 1, -50 },
  { 17326, 8, 70, 27, 9, -54 },
  { 17396, 27, 61, 24, -4, -50 },
  { 17602, 30, 13, 34, 3, -31 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC70PT7B_H_
