#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0xC0, 0x00, 0x71, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xCF, 0x00,
  0x79, 0xE0, 0x1E, 0x38, 0x03, 0xCF, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0E,
  0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x00, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1E, 0xCC, 0x1F, 0x60, 0x0F, 0xB0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x6F, 0x08, 0x37, 0x87, 0x17, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x07,
  0x80, 0x78, 0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0xF0, 0x3F, 0xE1, 0xE0, 0x79,
  0xE1, 0xE0, 0x79, 0xE3, 0xC0, 0x71, 0xE3, 0xC0, 0xF1, 0xE7, 0x80, 0xF1,
  0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xF3, 0xDE, 0x3C, 0xF3, 0x9E, 0x7E, 0xF7,
  0xBC, 0xFE, 0xFF, 0x3D, 0xFF, 0x7E, 0x79, 0xCF, 0x3C, 0x7B, 0xCF, 0x00,
  0xF3, 0xCF, 0x00, 0xE3, 0x8F, 0x01, 0xE7, 0x8F, 0x03, 0xC7, 0x8E, 0x03,
  0xC7, 0x9E, 0x07, 0x87, 0x9E, 0x07, 0x87, 0xBC, 0x0F, 0x07, 0xFC, 0x0F,
  0x03, 0xF8, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x7D,
  0xF0, 0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF1, 0xF1, 0xFF, 0x3E, 0x3F, 0xFB, 0xE3, 0xFF, 0xFE, 0x7C, 0xFF, 0xC7,
  0xCF, 0xFC, 0xF8, 0x7F, 0x8F, 0x87, 0xF0, 0xF8, 0x7F, 0x0F, 0xCF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xF8, 0xFC, 0x3E, 0x7D,
  0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x7C, 0x11, 0xE0, 0x77, 0x83,
  0xFE, 0xEF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x7E, 0x03, 0xFC, 0x1F, 0xF8,
  0xFD, 0xE1, 0xE7, 0xC3, 0x1E, 0x04, 0x20, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78,
  0xF0, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0xFC, 0x7D, 0xF0, 0xFB,
  0xE1, 0xF7, 0xC3, 0xFF, 0x8F, 0xFE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF1,
  0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF8, 0xFF, 0xDF, 0xFC, 0x7B, 0xE1, 0x9F, 0x08, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x38, 0x7C,
  0x08, 0x3E, 0x04, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x20, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x88, 0x0F, 0xC7, 0x1F, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xDF,
  0x01, 0xDF, 0x01, 0xEF, 0x81, 0xE7, 0xC0, 0xE3, 0xE0, 0xF1, 0xF0, 0xF1,
  0xF0, 0x78, 0xF9, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xA0, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x23, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x88, 0x0F, 0xC7, 0x9F, 0xC3, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xF7, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x70, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC,
  0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8,
  0xF8, 0xFD, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E,
  0x0F, 0x9F, 0x07, 0xDF, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x7E, 0x7C, 0x3E, 0x3F, 0x3E, 0x0F, 0x9F,
  0x0F, 0x8F, 0x87, 0xC7, 0xE3, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x3F, 0x3E, 0x3F, 0x3F, 0x7F, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x83, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xDF, 0x88,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x83, 0xE0, 0x7C, 0x03,
  0xC1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x1F, 0xE7, 0x3C, 0x7F, 0xCE,
  0x79, 0xFF, 0x9C, 0xE3, 0x8E, 0x3B, 0xCF, 0x1C, 0x77, 0x1C, 0x78, 0xEE,
  0x78, 0xF3, 0xFC, 0xF1, 0xC7, 0x79, 0xC7, 0x8E, 0xE3, 0x8F, 0x3D, 0xC7,
  0x1E, 0x73, 0x8F, 0x7D, 0xE7, 0x1F, 0xFF, 0x8E, 0x3F, 0x7E, 0x1C, 0x3C,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0x00, 0xFC, 0x3E,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x0F, 0xCF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF3, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x3F, 0x87, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0x81, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x08, 0x1F, 0x9E, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x9F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1,
  0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC7, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x81, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x1F, 0xE7, 0xE7, 0xF8,
  0xF8, 0xFF, 0x1F, 0x1F, 0xE7, 0xE3, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF0, 0xFE, 0x7E, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x3F,
  0x07, 0xC1, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFC,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xC7,
  0xC0, 0x3E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8,
  0xF7, 0xC1, 0xFF, 0x1F, 0xF8, 0x3D, 0xE7, 0xBE, 0x0F, 0xBE, 0xF7, 0xC1,
  0xF7, 0xFE, 0xF8, 0x3E, 0xFF, 0x9F, 0x07, 0xDF, 0xF7, 0xC1, 0xF3, 0xFC,
  0xF8, 0x3E, 0x7F, 0x9F, 0x07, 0xCF, 0xE3, 0xE0, 0xF9, 0xFC, 0x7C, 0x1F,
  0x3F, 0x1F, 0x07, 0xC7, 0xE3, 0xE0, 0xF8, 0xFC, 0x7C, 0x1F, 0x1F, 0x0F,
  0x80, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7F, 0x07, 0xC1, 0xFC, 0x1F,
  0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0F,
  0xF8, 0xF8, 0x7F, 0xE7, 0xC1, 0xFF, 0x9F, 0x07, 0xFE, 0x7C, 0x1F, 0x79,
  0xF0, 0x79, 0xE7, 0x83, 0xE7, 0xFE, 0x0F, 0x9F, 0xF8, 0x3E, 0x7F, 0xE0,
  0xF9, 0xFF, 0x87, 0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC1, 0xF0,
  0xFF, 0x07, 0xC3, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xF8, 0x0F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xF8, 0x0F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F,
  0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0x7C, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xEF,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7E, 0x3E, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF0, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE1,
  0x01, 0xF8, 0x60, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xFD, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF1,
  0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF8,
  0x3E, 0x7C, 0x07, 0x9F, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x03, 0xEF, 0x81, 0xE0,
  0xFD, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xE7, 0xC3, 0xF0, 0xFC, 0xF8,
  0x7E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE3, 0xE3, 0xF8, 0xF8, 0x7C, 0x7F, 0x1F,
  0x0F, 0x9F, 0xE7, 0xE1, 0xF3, 0xFC, 0xF8, 0x3E, 0x7F, 0x9F, 0x07, 0xDE,
  0xF7, 0xC0, 0xFB, 0xDE, 0xF8, 0x1F, 0xFB, 0xDF, 0x03, 0xFE, 0x7F, 0xC0,
  0x7B, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF8, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x1F, 0x9F,
  0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3, 0xE0, 0xFB, 0xF0,
  0x7D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xF1, 0xE3, 0xC7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3,
  0xE7, 0xCF, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xF3, 0xE7, 0xCF, 0x8F, 0x1E,
  0x3C, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0xBE, 0x1F, 0x3E, 0x1E,
  0x1E, 0x3E, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0xF9, 0xF1, 0xF3, 0xE3, 0xC0, 0x07, 0xCF, 0x0F, 0xDF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x7F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0xFC, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0xF8, 0x7C, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xBC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x9F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0xFF, 0xFC,
  0xFF, 0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x87,
  0xFE, 0x3F, 0x31, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x82, 0x3F, 0x30, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x7C, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFD, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x9F, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xBE, 0x07, 0xCF, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE3, 0xE3, 0xEF, 0xC7, 0xDF, 0x0F, 0x3E, 0x3E, 0xFF, 0xF9, 0xFF,
  0xF3, 0xFF, 0x87, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x08,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x5F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xDF, 0xC7,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFB, 0xE0, 0x7D, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC2, 0x03, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xBE, 0x0F, 0x7F,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8,
  0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0x00,
  0x0C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x83, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x3E, 0x3E, 0x0F, 0x7F, 0x7F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0x1F, 0x9F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x1F,
  0x3E, 0x3E, 0x1F, 0x3E, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x3E,
  0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xF8, 0x7C, 0x7C, 0xF8, 0x7C, 0x7C, 0xF8, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0x0F, 0x3E, 0x0F, 0x7F, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xF7, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x1F, 0xBE, 0x3E, 0x7C, 0xFC, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0xF7, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF1, 0xF8, 0x7E, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFB, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x7E, 0x7E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFE, 0xF8, 0x7D, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x3C,
  0x3D, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0x41, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xF0, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFE, 0x3F, 0x30, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC8, 0x3F, 0x30,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x03, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0xF3, 0xFE, 0x7F, 0xE7, 0xFE, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x88, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0xF0, 0x7C, 0xF0,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xE0, 0xF7, 0xC1, 0xEF, 0x83, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x7C, 0x3F, 0xF1, 0xF8, 0x7F, 0xE3, 0xF1, 0xF7, 0xC7,
  0xE3, 0xEF, 0x9F, 0xC7, 0x9F, 0x3F, 0x9F, 0x3E, 0xFF, 0x3E, 0x7D, 0xFE,
  0xF8, 0xFB, 0xFD, 0xF1, 0xFF, 0x7B, 0xC3, 0xFE, 0xFF, 0x87, 0xBD, 0xFF,
  0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x00,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8,
  0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x1E, 0x01, 0x7F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 26, 9, 0, -26 },
  { 37, 14, 10, 15, 3, -26 },
  { 55, 19, 26, 18, 0, -26 },
  { 117, 17, 29, 16, 0, -27 },
  { 179, 24, 26, 27, 2, -26 },
  { 257, 20, 26, 20, 0, -26 },
  { 322, 7, 10, 9, 3, -26 },
  { 331, 13, 32, 10, 0, -26 },
  { 383, 13, 32, 10, -3, -26 },
  { 435, 14, 16, 15, 3, -28 },
  { 463, 15, 17, 17, 2, -21 },
  { 495, 8, 10, 9, -2, -5 },
  { 505, 10, 5, 11, 0, -12 },
  { 512, 6, 6, 9, 0, -6 },
  { 517, 19, 26, 14, -2, -26 },
  { 579, 15, 26, 16, 1, -26 },
  { 628, 13, 26, 16, 3, -26 },
  { 671, 17, 26, 16, -1, -26 },
  { 727, 17, 26, 16, 0, -26 },
  { 783, 17, 26, 16, 0, -26 },
  { 839, 17, 26, 16, 0, -26 },
  { 895, 16, 26, 16, 1, -26 },
  { 947, 17, 26, 16, 1, -26 },
  { 1003, 17, 26, 16, 0, -26 },
  { 1059, 16, 26, 16, 0, -26 },
  { 1111, 9, 20, 9, 0, -20 },
  { 1134, 11, 25, 9, -2, -20 },
  { 1169, 16, 18, 17, 1, -22 },
  { 1205, 16, 12, 17, 1, -19 },
  { 1229, 15, 18, 17, 2, -22 },
  { 1263, 13, 26, 13, 1, -26 },
  { 1306, 23, 29, 24, 1, -26 },
  { 1390, 18, 26, 18, -2, -26 },
  { 1449, 18, 26, 18, 0, -26 },
  { 1508, 18, 26, 16, 1, -26 },
  { 1567, 19, 26, 19, 0, -26 },
  { 1629, 16, 26, 15, 0, -26 },
  { 1681, 16, 26, 14, 0, -26 },
  { 1733, 19, 26, 19, 1, -26 },
  { 1795, 21, 26, 20, 0, -26 },
  { 1864, 16, 26, 12, -1, -26 },
  { 1916, 17, 34, 9, -6, -26 },
  { 1989, 21, 26, 17, 0, -26 },
  { 2058, 12, 26, 14, 0, -26 },
  { 2097, 27, 26, 26, 0, -26 },
  { 2185, 22, 26, 21, 0, -26 },
  { 2257, 19, 26, 20, 1, -26 },
  { 2319, 18, 26, 17, 0, -26 },
  { 2378, 19, 32, 20, 1, -26 },
  { 2454, 18, 26, 17, 0, -26 },
  { 2513, 18, 26, 15, -1, -26 },
  { 2572, 15, 26, 15, 3, -26 },
  { 2621, 19, 26, 19, 1, -26 },
  { 2683, 18, 26, 18, 3, -26 },
  { 2742, 27, 26, 26, 2, -26 },
  { 2830, 21, 26, 17, -2, -26 },
  { 2899, 17, 26, 16, 3, -26 },
  { 2955, 18, 26, 15, -1, -26 },
  { 3014, 15, 32, 10, -2, -26 },
  { 3074, 7, 26, 14, 4, -26 },
  { 3097, 15, 32, 10, -3, -26 },
  { 3157, 16, 16, 16, 0, -26 },
  { 3189, 13, 3, 13, -3, 3 },
  { 3194, 7, 6, 11, 5, -28 },
  { 3200, 16, 20, 17, 1, -20 },
  { 3240, 16, 27, 17, 0, -27 },
  { 3294, 14, 20, 14, 1, -20 },
  { 3329, 18, 27, 17, 1, -27 },
  { 3390, 15, 20, 16, 1, -20 },
  { 3428, 19, 37, 11, -4, -28 },
  { 3516, 18, 29, 17, -1, -20 },
  { 3582, 16, 27, 17, 0, -27 },
  { 3636, 10, 28, 9, 0, -28 },
  { 3671, 15, 37, 9, -5, -28 },
  { 3741, 18, 27, 16, 0, -27 },
  { 3802, 11, 27, 9, 0, -27 },
  { 3840, 24, 20, 25, 0, -20 },
  { 3900, 16, 20, 17, 0, -20 },
  { 3940, 15, 20, 17, 1, -20 },
  { 3978, 18, 29, 17, -2, -20 },
  { 4044, 16, 29, 17, 1, -20 },
  { 4102, 14, 20, 12, 0, -20 },
  { 4137, 14, 20, 13, 0, -20 },
  { 4172, 12, 24, 11, 1, -24 },
  { 4208, 16, 20, 17, 1, -20 },
  { 4248, 15, 20, 15, 2, -20 },
  { 4286, 23, 20, 23, 2, -20 },
  { 4344, 19, 20, 15, -2, -20 },
  { 4392, 19, 29, 15, -2, -20 },
  { 4461, 15, 20, 13, -1, -20 },
  { 4499, 15, 32, 12, 0, -26 },
  { 4559, 5, 36, 14, 4, -28 },
  { 4582, 14, 32, 12, -2, -26 },
  { 4638, 16, 7, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC36PT7B_H_
