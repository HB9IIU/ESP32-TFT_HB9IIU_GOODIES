#ifndef _ROBOTOCONDENSED_BOLD71PT7B_H_
#define _ROBOTOCONDENSED_BOLD71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E,
  0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0x9F,
  0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x06, 0x00, 0x3F, 0x07, 0xF0,
  0x0F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x7E, 0x00,
  0x3F, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0xFF,
  0x8F, 0xC0, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x01, 0xFF, 0xFC, 0x7E, 0x00,
  0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x00,
  0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x0F, 0xC7, 0xFF, 0xF8, 0x00, 0x3F, 0x1F,
  0xFF, 0xF0, 0x00, 0x7E, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0xFE, 0x0F, 0xE0,
  0x03, 0xF1, 0xFC, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x3F, 0xC0, 0x0C, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFD, 0xFF, 0xCF, 0xF8, 0xFF, 0xC7, 0xFF, 0x7F, 0xC7, 0xFE, 0x3F,
  0xFB, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x02, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x04, 0x20, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x07,
  0xC0, 0x08, 0xF8, 0x0F, 0x80, 0xF1, 0xFC, 0x1F, 0x07, 0xE3, 0xFF, 0x3E,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x03,
  0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFC,
  0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE,
  0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFF,
  0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x01,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x03,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xF9, 0xFF,
  0x80, 0x0F, 0xF3, 0xFF, 0x00, 0x1F, 0xC7, 0xFE, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0xFF, 0x1F, 0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0x81, 0xFF, 0xE0, 0x3C, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7,
  0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x07, 0xFE, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xE1, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F,
  0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xF1,
  0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03,
  0xFF, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F,
  0xE0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF,
  0xFC, 0x0F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xE1, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xEF,
  0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x9F, 0xF0,
  0x03, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F,
  0xE3, 0xFC, 0x07, 0x00, 0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x7F, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3E, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0x07,
  0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xE3,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xFC, 0x3F, 0x01, 0xF9,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7E,
  0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x0F,
  0xBF, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xDF, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xEF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF7, 0xF0, 0x3F, 0x80, 0x7F, 0x00,
  0xFB, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7D, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3E, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xBF, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x81, 0xFE, 0x03, 0xF8,
  0x07, 0xEF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x80, 0xFE,
  0x01, 0xFB, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF9, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0x7E, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x87, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F,
  0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x83, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xEF,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0,
  0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xEF,
  0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF0, 0x07, 0xFB, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xFF,
  0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF,
  0x3F, 0xC3, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF,
  0xF3, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0x9F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xF0,
  0x3F, 0xEF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF,
  0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0,
  0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F,
  0xE1, 0xFF, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFF, 0x87, 0xFC, 0x07,
  0xFE, 0x3F, 0xDF, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xF7, 0xF8, 0xFF, 0xC0,
  0x3F, 0xE3, 0xFD, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x3F, 0xCF, 0xF8,
  0x03, 0xFF, 0x3F, 0xCF, 0xF3, 0xFE, 0x00, 0xFF, 0xDF, 0xE3, 0xFC, 0xFF,
  0x80, 0x1F, 0xF7, 0xF8, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x3F, 0xDF,
  0xF8, 0x01, 0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xE1, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07,
  0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFE, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xF0, 0xFF, 0xF3, 0xFF,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F,
  0x80, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0x07, 0xFD, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFE,
  0x07, 0xFF, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xE1,
  0xFF, 0x3F, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x9F,
  0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x03, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80,
  0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x9F,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x3F, 0xF0, 0x00, 0xC1,
  0xFF, 0xC0, 0x0F, 0x07, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xC8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x1F,
  0xF0, 0x3F, 0xFE, 0x7F, 0xC1, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x81,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0x83, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x20, 0x00, 0xFF, 0xC0, 0xC0,
  0x07, 0xFE, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFF, 0x0F,
  0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0xFF, 0x80, 0x7F, 0xF3, 0xFE, 0x03, 0xFF, 0x8F, 0xF8,
  0x1F, 0xFE, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x0F,
  0xFE, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE3, 0xFF, 0x80, 0xFF, 0x8F, 0xFC,
  0x03, 0xFE, 0x7F, 0xF0, 0x0F, 0xFB, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE, 0x3F,
  0xE0, 0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xF3, 0xFE, 0x01, 0xFF, 0xCF, 0xF8,
  0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F,
  0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFF,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFE,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE7, 0xFF, 0xC1,
  0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0x03,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0,
  0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFF, 0xF8, 0x7F, 0xCF, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0,
  0x3C, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE,
  0x7F, 0xC3, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x7F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xCF, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xBF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF,
  0x7F, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0x9F,
  0xF0, 0x3F, 0xF1, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07,
  0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xEF, 0xF8, 0x07, 0xF0, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF0, 0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0xF8, 0xFF, 0x81,
  0xFF, 0x1F, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0xE3, 0xFE, 0x07, 0xFC,
  0x7F, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xFF, 0xCF, 0xF8, 0x0F, 0xF3, 0xFB,
  0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x7F, 0x3F, 0xC0, 0x3F, 0xEF, 0xEF, 0xEF,
  0xF8, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03, 0xFF,
  0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0,
  0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0xF0,
  0x07, 0xF1, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF,
  0xC1, 0xFE, 0x7F, 0xFF, 0xF1, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xC1,
  0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF, 0xC7, 0xF0,
  0x0F, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80,
};

const GFXglyph RobotoCondensed_Bold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 51, 19, 4, -50 },
  { 72, 18, 19, 23, 2, -53 },
  { 115, 32, 50, 37, 3, -50 },
  { 315, 30, 66, 36, 3, -58 },
  { 563, 39, 52, 45, 3, -51 },
  { 817, 37, 52, 41, 3, -51 },
  { 1058, 8, 19, 11, 2, -53 },
  { 1077, 17, 72, 23, 4, -56 },
  { 1230, 17, 72, 23, 2, -56 },
  { 1383, 31, 31, 32, 1, -50 },
  { 1504, 29, 37, 34, 2, -42 },
  { 1639, 12, 21, 17, 1, -9 },
  { 1671, 17, 8, 26, 4, -26 },
  { 1688, 12, 11, 21, 4, -10 },
  { 1705, 22, 54, 24, 0, -50 },
  { 1854, 30, 52, 36, 3, -51 },
  { 2049, 20, 50, 36, 5, -50 },
  { 2174, 31, 51, 36, 2, -51 },
  { 2372, 30, 52, 36, 2, -51 },
  { 2567, 31, 50, 36, 2, -50 },
  { 2761, 30, 51, 36, 3, -50 },
  { 2953, 30, 51, 36, 3, -50 },
  { 3145, 31, 50, 36, 2, -50 },
  { 3339, 29, 52, 36, 3, -51 },
  { 3528, 29, 51, 36, 3, -51 },
  { 3713, 12, 39, 19, 4, -38 },
  { 3772, 13, 50, 18, 2, -38 },
  { 3854, 25, 33, 32, 2, -38 },
  { 3958, 26, 23, 36, 5, -34 },
  { 4033, 26, 33, 32, 4, -38 },
  { 4141, 27, 52, 32, 2, -51 },
  { 4317, 49, 65, 54, 3, -49 },
  { 4716, 41, 50, 42, 1, -50 },
  { 4973, 33, 50, 40, 4, -50 },
  { 5180, 35, 52, 40, 3, -51 },
  { 5408, 33, 50, 40, 4, -50 },
  { 5615, 29, 50, 35, 4, -50 },
  { 5797, 28, 50, 34, 4, -50 },
  { 5972, 35, 52, 42, 3, -51 },
  { 6200, 35, 50, 44, 4, -50 },
  { 6419, 10, 50, 19, 5, -50 },
  { 6482, 29, 51, 35, 2, -50 },
  { 6667, 36, 50, 39, 4, -50 },
  { 6892, 28, 50, 34, 4, -50 },
  { 7067, 46, 50, 54, 4, -50 },
  { 7355, 35, 50, 43, 4, -50 },
  { 7574, 37, 52, 43, 3, -51 },
  { 7815, 34, 50, 40, 4, -50 },
  { 8028, 37, 60, 43, 3, -51 },
  { 8306, 34, 50, 39, 4, -50 },
  { 8519, 33, 52, 38, 3, -51 },
  { 8734, 35, 50, 39, 2, -50 },
  { 8953, 33, 51, 41, 4, -50 },
  { 9164, 39, 50, 41, 1, -50 },
  { 9408, 50, 50, 53, 2, -50 },
  { 9721, 38, 50, 40, 1, -50 },
  { 9959, 37, 50, 39, 1, -50 },
  { 10191, 33, 50, 38, 2, -50 },
  { 10398, 13, 71, 19, 4, -59 },
  { 10514, 28, 54, 27, 0, -50 },
  { 10703, 14, 71, 19, 1, -59 },
  { 10828, 24, 25, 28, 2, -50 },
  { 10903, 27, 8, 28, 1, 0 },
  { 10930, 18, 11, 24, 2, -54 },
  { 10955, 28, 40, 33, 3, -39 },
  { 11095, 29, 54, 35, 4, -53 },
  { 11291, 29, 40, 33, 2, -39 },
  { 11436, 30, 54, 35, 2, -53 },
  { 11639, 29, 40, 34, 3, -39 },
  { 11784, 22, 54, 23, 1, -54 },
  { 11933, 30, 53, 36, 2, -39 },
  { 12132, 28, 53, 35, 3, -53 },
  { 12318, 10, 53, 18, 4, -53 },
  { 12385, 16, 67, 17, -2, -53 },
  { 12519, 30, 53, 34, 4, -53 },
  { 12718, 10, 53, 18, 4, -53 },
  { 12785, 45, 39, 53, 4, -39 },
  { 13005, 28, 39, 35, 3, -39 },
  { 13142, 31, 40, 35, 2, -39 },
  { 13297, 29, 53, 35, 4, -39 },
  { 13490, 30, 53, 35, 2, -39 },
  { 13689, 18, 39, 24, 4, -39 },
  { 13777, 28, 40, 32, 2, -39 },
  { 13917, 19, 48, 22, 1, -47 },
  { 14031, 28, 39, 35, 3, -38 },
  { 14168, 30, 38, 32, 1, -38 },
  { 14311, 43, 38, 45, 1, -38 },
  { 14516, 30, 38, 32, 1, -38 },
  { 14659, 30, 52, 32, 1, -38 },
  { 14854, 26, 38, 32, 3, -38 },
  { 14978, 17, 67, 21, 2, -55 },
  { 15121, 6, 59, 18, 6, -50 },
  { 15166, 17, 67, 21, 2, -55 },
  { 15309, 33, 16, 40, 3, -29 },
};

const GFXfont RobotoCondensed_Bold71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_BOLD71PT7B_H_
