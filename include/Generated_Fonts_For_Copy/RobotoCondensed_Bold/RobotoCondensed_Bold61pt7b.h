#ifndef _ROBOTOCONDENSED_BOLD61PT7B_H_
#define _ROBOTOCONDENSED_BOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0x9F, 0x80, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xBF, 0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF,
  0xE0, 0x7F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x7F, 0xCF, 0xFE, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x08, 0x03, 0xF0, 0xFC, 0x07, 0x01, 0xF8, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x07,
  0xC3, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF1, 0xF8, 0x07, 0xE1,
  0xF8, 0xF8, 0x03, 0xF0, 0xFC, 0xFC, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0x7F,
  0xFE, 0x7C, 0x00, 0x1F, 0xFE, 0x3E, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x01,
  0xFE, 0x1F, 0x00, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x03, 0xF3, 0xFF,
  0xE0, 0x01, 0xF3, 0xFF, 0xF0, 0x01, 0xF9, 0xFF, 0xFC, 0x00, 0xF9, 0xF8,
  0x7E, 0x00, 0xF8, 0xFC, 0x1F, 0x00, 0x7C, 0x7E, 0x0F, 0x80, 0x7C, 0x3F,
  0x07, 0xC0, 0x3E, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0x80,
  0x7F, 0xFF, 0x00, 0x40, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x81, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x7F,
  0xDF, 0xF3, 0xFC, 0x7F, 0x8F, 0xFB, 0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF,
  0x87, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xF8, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00,
  0x08, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x20,
  0x40, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x7C, 0x06, 0x7C,
  0x1F, 0x0F, 0x9F, 0xE7, 0xCF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3E, 0x01, 0xF0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x08, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0x3C, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE,
  0x7F, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F,
  0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7,
  0xFC, 0x1F, 0xE1, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF,
  0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE7, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0,
  0x3F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xF8, 0xFE, 0x07, 0xFC, 0x06, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xCF,
  0xF8, 0x3F, 0xE7, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x7F, 0xBF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x07,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFC,
  0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x03,
  0xFE, 0x7F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF,
  0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE,
  0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xEF, 0xF0, 0x0F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1C, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE,
  0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0xCF, 0xFB,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x02, 0x00, 0x06, 0x03, 0xF8,
  0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC1, 0xF0, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE1,
  0xF8, 0x03, 0xFF, 0x80, 0xF8, 0x7E, 0x01, 0xFF, 0xF0, 0x3E, 0x1F, 0x00,
  0xFF, 0xFE, 0x0F, 0x8F, 0xC0, 0x7F, 0xFF, 0x81, 0xF3, 0xF0, 0x1F, 0xC7,
  0xE0, 0x7C, 0xF8, 0x0F, 0xE1, 0xF8, 0x1F, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xDF, 0x81, 0xF8, 0x1F, 0x81, 0xF7, 0xE0, 0x7E, 0x07, 0xE0, 0x7D, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xDF, 0x03, 0xF0,
  0x1F, 0x01, 0xF7, 0xC0, 0xFC, 0x07, 0xC0, 0x7F, 0xF0, 0x3F, 0x03, 0xF0,
  0x1F, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xFF,
  0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0x9F, 0x07, 0xF0, 0x3F, 0x03, 0xE7, 0xC1, 0xFC, 0x1F,
  0xC0, 0xF9, 0xF0, 0x3F, 0x07, 0xF0, 0x7C, 0x7C, 0x0F, 0xE3, 0xFC, 0x1F,
  0x1F, 0x83, 0xFF, 0xFF, 0x8F, 0x87, 0xE0, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFD, 0xFF, 0xF0, 0x3E, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F,
  0x07, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x1F, 0xFC, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF7, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0x3F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF1, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xCF,
  0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x3F, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF,
  0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xFC, 0x3F,
  0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0xFF, 0xEF, 0xF0, 0x03,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0xE3, 0xFC, 0x03, 0xFF,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0x03,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF,
  0x0F, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xCF,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0xFF,
  0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xE3, 0xFC, 0x01, 0xFF,
  0x8F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xFB,
  0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFE,
  0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE7, 0xFF, 0xFB, 0xF8, 0x1F, 0xCF, 0xFF, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF,
  0xEF, 0xF0, 0xFF, 0x3F, 0xFF, 0xCF, 0xE1, 0xFC, 0xFF, 0xFF, 0x9F, 0xC3,
  0xF9, 0xFF, 0xFF, 0x3F, 0xC7, 0xF3, 0xFF, 0xFE, 0x7F, 0x9F, 0xC7, 0xFF,
  0xFC, 0x7F, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0x7F, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0xCF,
  0xF0, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xFC, 0x1F, 0xEF,
  0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xF0, 0x0F, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x13,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xF8, 0xFF, 0x00,
  0x7F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F,
  0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F,
  0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x1F, 0xF1, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1,
  0xFE, 0x01, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFC,
  0x01, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x00,
  0xFF, 0xBF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0,
  0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFC,
  0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xF0,
  0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF7,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xFF, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0xFC,
  0x7F, 0x80, 0xFF, 0x3F, 0x9F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF3, 0xF9, 0xFE,
  0x03, 0xFC, 0xFE, 0x7F, 0x7F, 0x80, 0x3F, 0xDF, 0xCF, 0xEF, 0xF0, 0x07,
  0xFB, 0xF9, 0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xBF, 0xC0, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE,
  0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xE3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7,
  0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0xCF,
  0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD,
  0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xF1, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFD, 0xFE, 0x07, 0xF8, 0xFF, 0x80, 0x20, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0x7F,
  0xF0, 0xFF, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFD, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xEF, 0xFF, 0x8F, 0xF3, 0xFF, 0x87, 0xF8, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xF7, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xF7, 0xFF, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x01, 0x03, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0xFE, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFE, 0x07, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xEF, 0xF0, 0xFF, 0xF7, 0xF8, 0x1F, 0xE3, 0xFC, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xF7, 0xFE,
  0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x04, 0x3F, 0xF0, 0x0F, 0x0F, 0xFF, 0x7F, 0xC7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x8F, 0xF0, 0x7F, 0xFB, 0xFC, 0x3F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xC0,
  0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x08, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x04, 0x00, 0xFF, 0x83, 0xC0, 0x7F, 0xE0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xF8, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F,
  0xFB, 0xFC, 0x0F, 0xFC, 0xFF, 0x03, 0xFF, 0x3F, 0xC1, 0xFF, 0x8F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03,
  0xFE, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFE, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x02, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0xFF, 0xE1, 0xFF,
  0xC7, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xF8,
  0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F,
  0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFF,
  0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x3F, 0xDF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0x81,
  0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFD, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFD, 0xFF, 0xF1, 0xFE, 0xFF,
  0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x81, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x1F,
  0xC3, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xE0, 0x7F, 0xDF, 0xFD, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0x03, 0xFC,
  0x7F, 0x80, 0x10, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x10, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x07, 0xF8,
  0xFF, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0,
  0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xFC,
  0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xF8, 0x0F,
  0xF7, 0xF8, 0x0F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0x03, 0xFC, 0xFF, 0x07,
  0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFF, 0x07, 0xF1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0xC7, 0xF0, 0x7F,
  0x8F, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0xF3, 0xFC, 0x0F, 0xE7, 0xFF, 0xDF,
  0xE0, 0x7F, 0x3F, 0x7E, 0xFF, 0x03, 0xFD, 0xFB, 0xF7, 0xF0, 0x1F, 0xFF,
  0xDF, 0xBF, 0x80, 0x7F, 0xFC, 0xFD, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0,
  0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF,
  0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xBF,
  0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0,
  0x0F, 0xF7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x70, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x60, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0x1F, 0xFC, 0x03, 0xF3, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x07, 0xF7, 0xFF,
  0xFC, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF,
  0xCF, 0xE0, 0x7F, 0xFC, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Bold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 44, 16, 4, -43 },
  { 51, 16, 16, 20, 2, -46 },
  { 83, 28, 43, 32, 2, -43 },
  { 234, 25, 57, 31, 3, -50 },
  { 413, 33, 45, 39, 3, -44 },
  { 599, 32, 45, 35, 2, -44 },
  { 779, 6, 16, 10, 2, -46 },
  { 791, 14, 62, 20, 4, -48 },
  { 900, 15, 62, 20, 2, -48 },
  { 1017, 26, 26, 28, 1, -43 },
  { 1102, 25, 32, 29, 2, -37 },
  { 1202, 10, 18, 15, 1, -7 },
  { 1225, 14, 7, 22, 4, -22 },
  { 1238, 10, 10, 18, 4, -9 },
  { 1251, 19, 47, 20, 0, -43 },
  { 1363, 25, 45, 31, 3, -44 },
  { 1504, 16, 43, 31, 5, -43 },
  { 1590, 26, 44, 31, 2, -44 },
  { 1733, 26, 45, 31, 2, -44 },
  { 1880, 27, 43, 31, 2, -43 },
  { 2026, 25, 44, 31, 3, -43 },
  { 2164, 26, 44, 31, 3, -43 },
  { 2307, 26, 43, 31, 2, -43 },
  { 2447, 25, 45, 31, 3, -44 },
  { 2588, 25, 44, 31, 3, -44 },
  { 2726, 10, 34, 17, 4, -33 },
  { 2769, 11, 44, 15, 2, -33 },
  { 2830, 22, 29, 27, 2, -33 },
  { 2910, 23, 20, 31, 4, -29 },
  { 2968, 22, 29, 28, 4, -33 },
  { 3048, 23, 45, 27, 2, -44 },
  { 3178, 42, 56, 47, 2, -42 },
  { 3472, 35, 43, 36, 1, -43 },
  { 3661, 27, 43, 34, 4, -43 },
  { 3807, 30, 45, 35, 3, -44 },
  { 3976, 28, 43, 34, 4, -43 },
  { 4127, 24, 43, 30, 4, -43 },
  { 4256, 23, 43, 29, 4, -43 },
  { 4380, 30, 45, 36, 3, -44 },
  { 4549, 30, 43, 37, 4, -43 },
  { 4711, 9, 43, 16, 4, -43 },
  { 4760, 25, 44, 30, 1, -43 },
  { 4898, 30, 43, 34, 4, -43 },
  { 5060, 24, 43, 29, 4, -43 },
  { 5189, 39, 43, 46, 4, -43 },
  { 5399, 30, 43, 37, 4, -43 },
  { 5561, 31, 45, 37, 3, -44 },
  { 5736, 28, 43, 35, 4, -43 },
  { 5887, 31, 52, 37, 3, -44 },
  { 6089, 29, 43, 34, 4, -43 },
  { 6245, 29, 45, 33, 2, -44 },
  { 6409, 30, 43, 33, 2, -43 },
  { 6571, 29, 44, 35, 3, -43 },
  { 6731, 34, 43, 35, 1, -43 },
  { 6914, 43, 43, 46, 1, -43 },
  { 7146, 32, 43, 34, 1, -43 },
  { 7318, 33, 43, 33, 0, -43 },
  { 7496, 28, 43, 32, 2, -43 },
  { 7647, 12, 60, 16, 3, -50 },
  { 7737, 24, 47, 23, 0, -43 },
  { 7878, 12, 60, 16, 1, -50 },
  { 7968, 21, 22, 24, 1, -43 },
  { 8026, 23, 7, 24, 1, 0 },
  { 8047, 15, 9, 20, 2, -46 },
  { 8064, 25, 34, 29, 2, -33 },
  { 8171, 25, 47, 30, 3, -46 },
  { 8318, 24, 34, 28, 2, -33 },
  { 8420, 25, 47, 30, 2, -46 },
  { 8567, 25, 34, 29, 2, -33 },
  { 8674, 18, 47, 20, 1, -47 },
  { 8780, 26, 45, 31, 2, -33 },
  { 8927, 24, 46, 30, 3, -46 },
  { 9065, 9, 45, 15, 3, -45 },
  { 9116, 14, 57, 15, -2, -45 },
  { 9216, 26, 46, 29, 3, -46 },
  { 9366, 9, 46, 15, 3, -46 },
  { 9418, 39, 33, 45, 3, -33 },
  { 9579, 24, 33, 30, 3, -33 },
  { 9678, 26, 34, 30, 2, -33 },
  { 9789, 25, 45, 30, 3, -33 },
  { 9930, 25, 45, 30, 2, -33 },
  { 10071, 16, 33, 20, 3, -33 },
  { 10137, 24, 34, 28, 2, -33 },
  { 10239, 16, 41, 19, 1, -40 },
  { 10321, 24, 33, 30, 3, -32 },
  { 10420, 25, 32, 27, 1, -32 },
  { 10520, 37, 32, 39, 1, -32 },
  { 10668, 26, 32, 28, 1, -32 },
  { 10772, 26, 44, 27, 1, -32 },
  { 10915, 23, 32, 28, 2, -32 },
  { 11007, 15, 59, 18, 2, -48 },
  { 11118, 5, 51, 15, 5, -43 },
  { 11150, 15, 59, 18, 2, -48 },
  { 11261, 28, 13, 34, 3, -24 },
};

const GFXfont RobotoCondensed_Bold61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_BOLD61PT7B_H_
