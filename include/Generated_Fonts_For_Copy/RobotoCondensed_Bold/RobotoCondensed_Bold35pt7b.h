#ifndef _ROBOTOCONDENSED_BOLD35PT7B_H_
#define _ROBOTOCONDENSED_BOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x78,
  0x00, 0x07, 0x7F, 0xFF, 0x70, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0x80, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x9C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x07, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xFF, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0xFD, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x73, 0xC3, 0x0E,
  0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xE7, 0x07, 0x1D, 0xC0, 0xE7, 0xB8, 0x1F,
  0xEE, 0x01, 0xFD, 0xC0, 0x1F, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x9E, 0x00,
  0x77, 0xF0, 0x1D, 0xFE, 0x03, 0xB9, 0xE0, 0xE7, 0x1C, 0x1D, 0xE3, 0x87,
  0x3C, 0x71, 0xC3, 0x8E, 0x38, 0x73, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xE7, 0x80, 0x78, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x78, 0x7F, 0x8F, 0x1F,
  0xF9, 0xE3, 0xEF, 0xBC, 0xF9, 0xFF, 0x9F, 0x1F, 0xF3, 0xE1, 0xFC, 0x7C,
  0x3F, 0x87, 0xC7, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x01, 0x03, 0x07, 0x0F, 0x1E,
  0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x01, 0x40, 0x70, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x08, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x61, 0xC6, 0x7D, 0x9E,
  0x7F, 0xFE, 0x1F, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x70,
  0x1C, 0x78, 0x1C, 0x38, 0x08, 0x10, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0xBC, 0xF1, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF,
  0x07, 0xF8, 0x0F, 0x80, 0x01, 0x83, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC7, 0xEF,
  0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFB, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFE, 0x30, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xF9, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8,
  0x0F, 0xC0, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE,
  0x1F, 0x7C, 0xFD, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8,
  0x79, 0xF3, 0xE7, 0xFF, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0xEF, 0xCF, 0xBE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC,
  0xFC, 0xFB, 0xE3, 0xEF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1E,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xF7, 0x80, 0x3D, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0xCF, 0x3D, 0xE7, 0xBC, 0x20, 0x00,
  0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xF3, 0xFE, 0xFF, 0x8F, 0xE0, 0xF8,
  0x0F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00,
  0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0xF8,
  0x1F, 0xC3, 0xFE, 0xFF, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x80,
  0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE1,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x0E, 0x3C, 0x1F, 0x0E, 0x38, 0x3F, 0xC7, 0x38, 0x7F, 0xC7,
  0x78, 0xF1, 0xC7, 0x70, 0xE3, 0xC7, 0x71, 0xE3, 0xC7, 0x71, 0xE3, 0xC7,
  0x71, 0xE3, 0xC7, 0xF1, 0xC3, 0x87, 0xF1, 0xC3, 0x87, 0xF1, 0xC3, 0x87,
  0xF1, 0xC3, 0x87, 0xF1, 0xC7, 0x87, 0x71, 0xE7, 0x8E, 0x71, 0xFF, 0xFE,
  0x70, 0xFD, 0xFC, 0x78, 0x78, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x81, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE0, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0,
  0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3,
  0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3,
  0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xE1, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFD, 0xFF, 0xE7, 0xFF, 0x0F, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x83, 0xF3, 0xE1, 0xF8, 0xF8,
  0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xFB, 0xF0, 0x3E, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFC, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xF8,
  0x7E, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0x80, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7B, 0xFF, 0xF1, 0xEF, 0xFB, 0xC7, 0xBF, 0xEF, 0x3C, 0xFF, 0xBC, 0xF3,
  0xFE, 0xFB, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x9F, 0xE3, 0xFE,
  0x3F, 0x8F, 0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0xFF, 0x87, 0xC3, 0xFE, 0x1F,
  0x0F, 0xF8, 0x78, 0x3C, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0x7C, 0xFF, 0xBE, 0x7F, 0xCF, 0xBF, 0xE7, 0xDF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x3F, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0x7E, 0x3F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F,
  0x3F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0x7E, 0x3F,
  0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x0F, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xEF, 0x83, 0xE7, 0xE1, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0,
  0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x3C, 0x1F, 0x7C, 0x1F, 0x0F,
  0xBE, 0x0F, 0x87, 0xDF, 0x0F, 0xC3, 0xE7, 0x87, 0xE1, 0xF3, 0xE3, 0xF0,
  0xF9, 0xF1, 0xF8, 0x78, 0xF8, 0xFE, 0x7C, 0x7C, 0xFF, 0x3E, 0x3E, 0x7F,
  0x9F, 0x0F, 0x3F, 0xCF, 0x87, 0x9F, 0xE7, 0x83, 0xEF, 0x7B, 0xC1, 0xF7,
  0x3D, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0x7E, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F,
  0x1F, 0x87, 0xC7, 0xC1, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0x3B, 0xC7, 0x9C, 0x79, 0xE7,
  0x1E, 0xF0, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0x7D, 0xE1, 0xF0, 0x07, 0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0xC7,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D,
  0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xBF, 0xFE, 0xF7, 0xF3, 0xCF, 0x80, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x83, 0xFE,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xF8, 0x7D, 0xF1, 0xF7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0x3E,
  0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F,
  0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x1E, 0x7C, 0x07, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x8F, 0x83, 0x1F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x80, 0x0F, 0xBE, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F,
  0x7C, 0x00, 0xF8, 0x01, 0xF1, 0x07, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC,
  0x0F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8,
  0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xF0,
  0x77, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFC, 0xF8,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0xFD, 0xF1, 0xF3, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87,
  0xDF, 0x0F, 0x9F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x7D, 0xF0,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xE1, 0xF3, 0xDF, 0xDF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xE3, 0xE1, 0xFF, 0x87,
  0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87,
  0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE,
  0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xF0, 0xF3, 0xE3, 0xDF, 0xCF,
  0xFF, 0xBF, 0xFE, 0xF8, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x8F, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0,
  0x0F, 0xC0, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xEF, 0x8F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x3E,
  0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F,
  0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x1E, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0xF3, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0x78, 0x79, 0xE1, 0xF7, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0x3E, 0xF8, 0x7F, 0xE1, 0xF7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0,
  0x3F, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7C, 0xF9, 0xF0, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7,
  0xC7, 0xCF, 0x8F, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0xF0, 0xF0, 0xF7, 0x87, 0x87, 0xBE, 0x3C, 0x7D, 0xF3, 0xF3, 0xE7,
  0x9F, 0x9F, 0x3C, 0xFC, 0xF1, 0xE7, 0xE7, 0x8F, 0x3F, 0xBC, 0x7F, 0xFD,
  0xE1, 0xFE, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x3C,
  0x00, 0xF8, 0x7F, 0xF3, 0xE7, 0xCF, 0x8F, 0xBC, 0x3F, 0xF0, 0x7F, 0x81,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC7, 0xCF, 0x9F, 0x3E, 0xF8, 0x7F, 0xE1, 0xF0, 0xFC, 0x3E, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x9E, 0x0F, 0x7C,
  0x1E, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3C, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x03, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE3, 0xF1, 0xF0, 0xF0, 0x7C, 0x1F, 0x07,
  0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8,
  0x3C, 0x0E, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1F, 0x1F, 0x0F, 0x1F, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0xF8, 0xF0,
  0x40, 0x1E, 0x00, 0x7F, 0x0F, 0x7F, 0x8F, 0xFF, 0xCF, 0xF3, 0xFE, 0xE1,
  0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 9, 9, 11, 1, -26 },
  { 28, 16, 25, 18, 1, -25 },
  { 78, 14, 32, 18, 2, -29 },
  { 134, 19, 25, 22, 2, -25 },
  { 194, 19, 25, 20, 1, -25 },
  { 254, 4, 9, 6, 1, -26 },
  { 259, 8, 36, 11, 2, -28 },
  { 295, 9, 36, 11, 1, -28 },
  { 336, 16, 15, 16, 0, -25 },
  { 366, 14, 18, 17, 1, -21 },
  { 398, 6, 10, 9, 1, -4 },
  { 406, 8, 4, 13, 2, -13 },
  { 410, 6, 5, 10, 2, -5 },
  { 414, 11, 27, 12, 0, -25 },
  { 452, 14, 25, 18, 2, -25 },
  { 496, 9, 25, 18, 3, -25 },
  { 525, 15, 25, 18, 1, -25 },
  { 572, 15, 25, 18, 1, -25 },
  { 619, 15, 25, 18, 1, -25 },
  { 666, 14, 25, 18, 2, -25 },
  { 710, 14, 25, 18, 2, -25 },
  { 754, 15, 25, 18, 1, -25 },
  { 801, 14, 25, 18, 2, -25 },
  { 845, 14, 25, 18, 2, -25 },
  { 889, 6, 19, 10, 2, -19 },
  { 904, 6, 25, 9, 1, -19 },
  { 923, 12, 17, 16, 1, -19 },
  { 949, 13, 12, 18, 2, -17 },
  { 969, 13, 17, 16, 2, -19 },
  { 997, 13, 25, 16, 1, -25 },
  { 1038, 24, 32, 27, 1, -24 },
  { 1134, 21, 25, 21, 0, -25 },
  { 1200, 16, 25, 20, 2, -25 },
  { 1250, 17, 25, 20, 2, -25 },
  { 1304, 16, 25, 20, 2, -25 },
  { 1354, 14, 25, 17, 2, -25 },
  { 1398, 14, 25, 17, 2, -25 },
  { 1442, 17, 25, 20, 2, -25 },
  { 1496, 17, 25, 21, 2, -25 },
  { 1550, 5, 25, 9, 2, -25 },
  { 1566, 14, 25, 17, 1, -25 },
  { 1610, 18, 25, 19, 2, -25 },
  { 1667, 14, 25, 17, 2, -25 },
  { 1711, 22, 25, 27, 2, -25 },
  { 1780, 17, 25, 21, 2, -25 },
  { 1834, 18, 25, 21, 2, -25 },
  { 1891, 17, 25, 20, 2, -25 },
  { 1945, 18, 29, 21, 2, -25 },
  { 2011, 17, 25, 19, 2, -25 },
  { 2065, 17, 25, 19, 1, -25 },
  { 2119, 17, 25, 19, 1, -25 },
  { 2173, 16, 25, 20, 2, -25 },
  { 2223, 20, 25, 20, 0, -25 },
  { 2286, 25, 25, 26, 1, -25 },
  { 2365, 18, 25, 20, 1, -25 },
  { 2422, 19, 25, 19, 0, -25 },
  { 2482, 16, 25, 19, 1, -25 },
  { 2532, 7, 35, 9, 2, -29 },
  { 2563, 14, 27, 13, 0, -25 },
  { 2611, 6, 35, 9, 1, -29 },
  { 2638, 12, 12, 14, 1, -25 },
  { 2656, 14, 4, 14, 0, 0 },
  { 2663, 9, 5, 12, 1, -26 },
  { 2669, 14, 18, 16, 1, -18 },
  { 2701, 14, 26, 17, 2, -26 },
  { 2747, 14, 18, 16, 1, -18 },
  { 2779, 15, 26, 17, 1, -26 },
  { 2828, 15, 18, 17, 1, -18 },
  { 2862, 10, 26, 11, 1, -26 },
  { 2895, 15, 25, 18, 1, -18 },
  { 2942, 14, 26, 17, 2, -26 },
  { 2988, 5, 25, 9, 2, -25 },
  { 3004, 8, 32, 9, -1, -25 },
  { 3036, 15, 26, 17, 2, -26 },
  { 3085, 5, 26, 9, 2, -26 },
  { 3102, 22, 18, 26, 2, -18 },
  { 3152, 14, 18, 17, 2, -18 },
  { 3184, 15, 18, 17, 1, -18 },
  { 3218, 14, 25, 17, 2, -18 },
  { 3262, 15, 25, 17, 1, -18 },
  { 3309, 9, 18, 12, 2, -18 },
  { 3330, 14, 18, 16, 1, -18 },
  { 3362, 10, 23, 11, 0, -23 },
  { 3391, 14, 18, 17, 2, -18 },
  { 3423, 15, 18, 16, 0, -18 },
  { 3457, 21, 18, 22, 1, -18 },
  { 3505, 14, 18, 16, 1, -18 },
  { 3537, 15, 25, 16, 0, -18 },
  { 3584, 13, 18, 16, 1, -18 },
  { 3614, 9, 33, 10, 1, -27 },
  { 3652, 3, 30, 9, 3, -25 },
  { 3664, 8, 33, 10, 1, -27 },
  { 3697, 16, 8, 20, 2, -14 },
};

const GFXfont RobotoCondensed_Bold35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_BOLD35PT7B_H_
