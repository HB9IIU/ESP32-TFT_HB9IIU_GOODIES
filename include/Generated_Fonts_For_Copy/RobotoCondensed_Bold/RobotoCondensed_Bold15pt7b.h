#ifndef _ROBOTOCONDENSED_BOLD15PT7B_H_
#define _ROBOTOCONDENSED_BOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDD, 0xDD, 0x28, 0xA2, 0xBF, 0x69, 0xE5, 0xBF,
  0x51, 0x45, 0x00, 0x30, 0xC7, 0xBF, 0xCF, 0x0E, 0x1E, 0x1F, 0x3C, 0xFF,
  0x78, 0x80, 0xE0, 0xB4, 0xB4, 0xBC, 0xE8, 0x10, 0x16, 0x2B, 0x29, 0x4B,
  0x06, 0x70, 0xF3, 0x26, 0xC7, 0x0E, 0x3D, 0xEF, 0xDD, 0xF9, 0xD8, 0xFF,
  0x25, 0x2D, 0xB6, 0xDB, 0x24, 0xC8, 0x44, 0x62, 0x33, 0x33, 0x33, 0x32,
  0x64, 0x40, 0x10, 0x23, 0xF9, 0x82, 0x89, 0x00, 0x18, 0x30, 0x67, 0xFF,
  0xE3, 0x06, 0x0C, 0x6D, 0xE0, 0xFC, 0xF0, 0x18, 0x84, 0x63, 0x11, 0x8C,
  0x42, 0x31, 0x80, 0x73, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xE7, 0x00,
  0x1F, 0xF3, 0x33, 0x33, 0x33, 0x30, 0x7B, 0xEC, 0xC3, 0x18, 0x63, 0x1C,
  0x63, 0xFF, 0xC0, 0x3C, 0xF9, 0x98, 0x31, 0xC3, 0x81, 0x83, 0x66, 0xF8,
  0xE0, 0x0C, 0x38, 0x71, 0xE3, 0xCD, 0x9B, 0x3F, 0x7E, 0x18, 0x30, 0xFF,
  0xFC, 0x30, 0xFB, 0xF0, 0xC3, 0xCF, 0xE7, 0x80, 0x39, 0xEE, 0x30, 0xFB,
  0xFC, 0xF3, 0xCF, 0xF7, 0x80, 0xFF, 0xFC, 0x10, 0x60, 0xC3, 0x06, 0x0C,
  0x30, 0x60, 0xC0, 0x7B, 0xEC, 0xF3, 0xF9, 0xEC, 0xF3, 0xCF, 0xE7, 0x80,
  0x73, 0xEC, 0xF3, 0xCF, 0xF7, 0xC3, 0x19, 0xE6, 0x00, 0xF0, 0x0F, 0x6C,
  0x00, 0x1B, 0x78, 0x04, 0x77, 0xB0, 0x78, 0x70, 0x40, 0xFF, 0xF0, 0x3F,
  0xFC, 0x87, 0x1E, 0x37, 0xF2, 0x00, 0x39, 0xFC, 0xC3, 0x0C, 0x63, 0x0C,
  0x00, 0xC3, 0x00, 0x1E, 0x1C, 0x64, 0x0B, 0x3B, 0x9A, 0x64, 0x9B, 0x66,
  0xDB, 0xB6, 0xA6, 0xEC, 0x01, 0x88, 0x3E, 0x00, 0x1C, 0x0E, 0x07, 0x06,
  0xC3, 0x61, 0xB0, 0xD8, 0xFE, 0x7F, 0x31, 0xB8, 0xE0, 0xF9, 0xFB, 0x3E,
  0x6F, 0xDF, 0xB3, 0xE3, 0xCF, 0xFB, 0xE0, 0x79, 0xFB, 0x1E, 0x3C, 0x18,
  0x30, 0x63, 0xC7, 0xF9, 0xE0, 0xF9, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE3,
  0xCD, 0xFB, 0xE0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0xFF, 0xC0,
  0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x7D, 0xFB, 0x1E,
  0x3C, 0x1B, 0xF7, 0xE3, 0xC7, 0xFC, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF,
  0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFF, 0xFC, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0xEC, 0xF8, 0xE0, 0xCF, 0x9B, 0x76, 0xCF, 0x1F, 0x3E,
  0x6E, 0xCD, 0x9F, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF,
  0xC0, 0xE1, 0xF8, 0xFE, 0x3F, 0xCF, 0xF2, 0xFD, 0xFD, 0x7F, 0x77, 0xDD,
  0xF7, 0x7C, 0xDC, 0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x8F,
  0x18, 0x39, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFC, 0xF0, 0xF9,
  0xFB, 0x1E, 0x3C, 0x7F, 0xBE, 0x60, 0xC1, 0x83, 0x00, 0x39, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFC, 0xF0, 0x30, 0x20, 0xF9, 0xFB, 0x3E,
  0x3C, 0xFF, 0xBE, 0x6E, 0xCD, 0x9B, 0x18, 0x79, 0xFB, 0x36, 0x0F, 0x0F,
  0x07, 0x66, 0xCD, 0xF9, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xF9, 0xE0, 0xE3, 0x31, 0x98, 0xCC, 0xE7, 0x61, 0xB0, 0xD8, 0x78, 0x1C,
  0x0E, 0x07, 0x00, 0xE6, 0x6D, 0xCD, 0xBB, 0x37, 0x66, 0xEC, 0xD7, 0x9A,
  0xF1, 0xDE, 0x3B, 0x87, 0x30, 0xC6, 0x00, 0x63, 0x66, 0x36, 0x3C, 0x3C,
  0x1C, 0x3C, 0x3C, 0x76, 0x66, 0xE7, 0xE3, 0x66, 0x66, 0x36, 0x3C, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF0, 0xC6, 0x38, 0xC7, 0x18, 0xC3,
  0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6F, 0xC0, 0xC1, 0x86, 0x18, 0x70,
  0xC3, 0x0E, 0x18, 0x61, 0x83, 0xFD, 0xB6, 0xDB, 0x6D, 0xBF, 0xC0, 0x30,
  0xC7, 0x96, 0x48, 0xFF, 0xF0, 0x63, 0x73, 0xED, 0x9E, 0xDB, 0x6F, 0xBE,
  0xC3, 0x0C, 0x30, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0x77, 0xF3, 0x8C,
  0x67, 0xEE, 0x06, 0x0C, 0x18, 0x33, 0x6F, 0xD9, 0xF3, 0xE6, 0xCD, 0xF9,
  0xB0, 0x73, 0xEC, 0xF3, 0xFF, 0x0F, 0x9E, 0x3B, 0xD8, 0xCF, 0xFD, 0x8C,
  0x63, 0x18, 0xC0, 0x3E, 0xFD, 0x9B, 0x36, 0x6C, 0xDF, 0x9B, 0x06, 0xF8,
  0xF0, 0xC3, 0x0C, 0x30, 0xFB, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xF3, 0xFF,
  0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C, 0x30, 0xDF, 0x6F,
  0x3C, 0xF3, 0x6D, 0xB3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF3, 0x79, 0xBC,
  0xDE, 0x6F, 0x37, 0x9B, 0xFB, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0x7B, 0xEC,
  0xF3, 0xCF, 0x3F, 0x9E, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0xC3, 0x0C,
  0x00, 0x36, 0xFD, 0x9F, 0x3E, 0x6C, 0xDF, 0x9B, 0x06, 0x0C, 0x18, 0xFF,
  0xCC, 0xCC, 0xCC, 0x39, 0xF6, 0x1E, 0x3F, 0x37, 0xCE, 0x66, 0xFF, 0x66,
  0x66, 0x73, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDB, 0xCC, 0xD9, 0xB3, 0x67,
  0x87, 0x0E, 0x18, 0xCD, 0xA6, 0xDF, 0x6F, 0xB7, 0x73, 0xB8, 0xCC, 0x66,
  0x6C, 0xD8, 0xE1, 0xC3, 0x8F, 0x1B, 0x76, 0xCC, 0xD9, 0xB3, 0x67, 0x87,
  0x0E, 0x18, 0x30, 0xE1, 0x80, 0xFF, 0xCC, 0x66, 0x63, 0xFF, 0x13, 0x26,
  0x66, 0xEC, 0x66, 0x66, 0x23, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x46, 0x66,
  0x66, 0x33, 0x66, 0x66, 0x66, 0x40, 0x67, 0xFA, 0x70,
};

const GFXglyph RobotoCondensed_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 5, 0, -11 },
  { 6, 6, 11, 8, 1, -11 },
  { 15, 6, 14, 8, 1, -13 },
  { 26, 8, 11, 10, 1, -11 },
  { 37, 7, 11, 9, 1, -11 },
  { 47, 2, 4, 2, 0, -11 },
  { 48, 3, 15, 5, 1, -12 },
  { 54, 4, 15, 5, 0, -12 },
  { 62, 7, 6, 7, 0, -11 },
  { 68, 7, 8, 7, 0, -9 },
  { 75, 3, 4, 4, 0, -2 },
  { 77, 3, 2, 5, 1, -6 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 5, 12, 5, 0, -11 },
  { 87, 6, 11, 8, 1, -11 },
  { 96, 4, 11, 8, 1, -11 },
  { 102, 6, 11, 8, 1, -11 },
  { 111, 7, 11, 8, 0, -11 },
  { 121, 7, 11, 8, 0, -11 },
  { 131, 6, 11, 8, 1, -11 },
  { 140, 6, 11, 8, 1, -11 },
  { 149, 7, 11, 8, 0, -11 },
  { 159, 6, 11, 8, 1, -11 },
  { 168, 6, 11, 8, 1, -11 },
  { 177, 2, 8, 4, 1, -8 },
  { 179, 3, 10, 4, 0, -8 },
  { 183, 6, 7, 7, 0, -8 },
  { 189, 6, 5, 8, 1, -7 },
  { 193, 5, 7, 7, 1, -8 },
  { 198, 6, 11, 7, 0, -11 },
  { 207, 10, 13, 11, 1, -10 },
  { 224, 9, 11, 9, 0, -11 },
  { 237, 7, 11, 8, 1, -11 },
  { 247, 7, 11, 9, 1, -11 },
  { 257, 7, 11, 8, 1, -11 },
  { 267, 6, 11, 7, 1, -11 },
  { 276, 6, 11, 7, 1, -11 },
  { 285, 7, 11, 9, 1, -11 },
  { 295, 7, 11, 9, 1, -11 },
  { 305, 2, 11, 4, 1, -11 },
  { 308, 7, 11, 7, 0, -11 },
  { 318, 7, 11, 8, 1, -11 },
  { 328, 6, 11, 7, 1, -11 },
  { 337, 10, 11, 11, 1, -11 },
  { 351, 7, 11, 9, 1, -11 },
  { 361, 7, 11, 9, 1, -11 },
  { 371, 7, 11, 9, 1, -11 },
  { 381, 7, 13, 9, 1, -11 },
  { 393, 7, 11, 8, 1, -11 },
  { 403, 7, 11, 8, 1, -11 },
  { 413, 8, 11, 8, 0, -11 },
  { 424, 7, 11, 9, 1, -11 },
  { 434, 9, 11, 9, 0, -11 },
  { 447, 11, 11, 11, 0, -11 },
  { 463, 8, 11, 8, 0, -11 },
  { 474, 8, 11, 8, 0, -11 },
  { 485, 6, 11, 8, 1, -11 },
  { 494, 3, 14, 4, 1, -12 },
  { 500, 6, 12, 6, 0, -11 },
  { 509, 3, 14, 4, 0, -12 },
  { 515, 6, 5, 6, 0, -11 },
  { 519, 6, 2, 6, 0, 0 },
  { 521, 4, 2, 5, 0, -11 },
  { 522, 6, 8, 7, 1, -8 },
  { 528, 6, 12, 7, 1, -12 },
  { 537, 5, 8, 7, 1, -8 },
  { 542, 7, 12, 7, 0, -12 },
  { 553, 6, 8, 7, 1, -8 },
  { 559, 5, 12, 5, 0, -12 },
  { 567, 7, 11, 8, 0, -8 },
  { 577, 6, 12, 7, 1, -12 },
  { 586, 2, 11, 4, 1, -11 },
  { 589, 3, 14, 4, 0, -11 },
  { 595, 6, 12, 7, 1, -12 },
  { 604, 2, 12, 4, 1, -12 },
  { 607, 9, 8, 11, 1, -8 },
  { 616, 6, 8, 7, 1, -8 },
  { 622, 6, 8, 7, 1, -8 },
  { 628, 6, 11, 7, 1, -8 },
  { 637, 7, 11, 7, 0, -8 },
  { 647, 4, 8, 5, 1, -8 },
  { 651, 6, 8, 7, 0, -8 },
  { 657, 4, 10, 5, 0, -10 },
  { 662, 6, 8, 7, 1, -8 },
  { 668, 7, 8, 7, 0, -8 },
  { 675, 9, 8, 10, 0, -8 },
  { 684, 7, 8, 7, 0, -8 },
  { 691, 7, 11, 7, 0, -8 },
  { 701, 5, 8, 7, 1, -8 },
  { 706, 4, 15, 4, 0, -12 },
  { 714, 2, 13, 4, 1, -11 },
  { 718, 4, 15, 4, 0, -12 },
  { 726, 7, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Bold15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_BOLD15PT7B_H_
