#ifndef _ROBOTOCONDENSED_BOLD53PT7B_H_
#define _ROBOTOCONDENSED_BOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x01, 0xFD, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x7C, 0x0E,
  0x03, 0xE1, 0xE0, 0x78, 0x1E, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x3C, 0x07,
  0x83, 0xE3, 0xE0, 0x3C, 0x1F, 0x1E, 0x01, 0xE0, 0xF9, 0xF0, 0x0F, 0x87,
  0x8F, 0x00, 0x7C, 0x7C, 0xF8, 0x03, 0xFF, 0xE7, 0x80, 0x0F, 0xFE, 0x7C,
  0x00, 0x3F, 0xF3, 0xC0, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x81, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x00,
  0x78, 0xFE, 0x00, 0x07, 0xCF, 0xF8, 0x00, 0x7C, 0xFF, 0xE0, 0x03, 0xCF,
  0xFF, 0x80, 0x3E, 0x7C, 0x7C, 0x01, 0xE3, 0xC3, 0xE0, 0x1F, 0x3E, 0x0F,
  0x00, 0xF1, 0xF0, 0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0x78, 0x7C, 0x1F, 0x07,
  0xC3, 0xE0, 0xF0, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0x7C, 0x7C, 0x02, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x1F,
  0xC7, 0xFF, 0xF9, 0xFC, 0x7F, 0x7F, 0xDF, 0x8F, 0xF3, 0xFD, 0xF8, 0xFE,
  0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F,
  0xF0, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFB, 0xFE, 0x07, 0xFE, 0x1F, 0xE0, 0x02, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x20, 0x03,
  0x80, 0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xE0, 0x07, 0x00,
  0x18, 0x20, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1E,
  0x02, 0x3C, 0x3C, 0x1E, 0xFF, 0x79, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xC0, 0x38, 0x00, 0x80, 0x40, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF,
  0xFD, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xCF, 0xE0,
  0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x10, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F,
  0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7D, 0xFE, 0x01, 0xFB,
  0xFC, 0x03, 0xE7, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F, 0x9F, 0xE0, 0x7E, 0x3F,
  0xC0, 0xFC, 0x7F, 0x83, 0xF0, 0xFF, 0x07, 0xE1, 0xFE, 0x1F, 0x83, 0xFC,
  0x3F, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0x83, 0xFE, 0x04, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x0F, 0xEF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xE3, 0xFE, 0xFF, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F,
  0xBF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF1,
  0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFD, 0xFC, 0x07, 0xCF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x1F, 0x1F, 0xDF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE3, 0xE0, 0x40, 0x00, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xC3, 0xC0,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xF1, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x07, 0xC1, 0xF0, 0x1F,
  0xF8, 0x1E, 0x1F, 0x01, 0xFF, 0xE0, 0xF0, 0xF8, 0x1F, 0xFF, 0x87, 0xC7,
  0xC0, 0xFF, 0xFC, 0x3E, 0x7C, 0x0F, 0xC3, 0xE0, 0xF3, 0xE0, 0x7C, 0x3E,
  0x07, 0x9F, 0x07, 0xE1, 0xF0, 0x3C, 0xF8, 0x3E, 0x0F, 0x81, 0xE7, 0x81,
  0xF0, 0x7C, 0x0F, 0x7C, 0x1F, 0x83, 0xE0, 0x7B, 0xE0, 0xF8, 0x1F, 0x03,
  0xDF, 0x07, 0xC0, 0xF8, 0x1E, 0xF8, 0x3E, 0x07, 0xC0, 0xF7, 0xC1, 0xF0,
  0x3E, 0x07, 0xBE, 0x1F, 0x81, 0xF0, 0x3D, 0xF0, 0xFC, 0x0F, 0x81, 0xEF,
  0x87, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F, 0x07, 0xE0, 0xF3, 0xE0, 0xF8, 0x3F,
  0x07, 0x9F, 0x07, 0xE3, 0xF8, 0x7C, 0x78, 0x3F, 0x9F, 0xC7, 0xC3, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0x07, 0xFE, 0xFF, 0xE0, 0xF8, 0x1F, 0xE7, 0xFE,
  0x07, 0xE0, 0x7E, 0x1F, 0xE0, 0x1F, 0x00, 0x80, 0x30, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x0F, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F,
  0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7,
  0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F,
  0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0xDF,
  0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F,
  0x80, 0x7F, 0xCF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0xFC,
  0x0F, 0xDF, 0xFF, 0xBF, 0x83, 0xF7, 0xFF, 0xEF, 0xE1, 0xF9, 0xFF, 0xF9,
  0xF8, 0x7E, 0x7F, 0xFE, 0x7E, 0x1F, 0x9F, 0xFF, 0x9F, 0xCF, 0xE7, 0xFF,
  0xE3, 0xF3, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE,
  0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF8, 0x7F,
  0xFE, 0xFE, 0x1F, 0xFF, 0x9F, 0xC7, 0xFF, 0xE7, 0xF1, 0xFF, 0xF8, 0xFE,
  0x7F, 0xFE, 0x3F, 0x9F, 0xFF, 0x87, 0xF7, 0xFF, 0xE1, 0xFD, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x4F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0,
  0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC,
  0x7F, 0x80, 0xFF, 0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xDF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFC,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF,
  0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x87,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0,
  0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x80, 0xFE, 0x7F,
  0x01, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0xFE,
  0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC3,
  0xFC, 0x3F, 0xC7, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0x8F,
  0xE0, 0x7F, 0x3F, 0xFE, 0x3F, 0x81, 0xFC, 0xFC, 0xFD, 0xFC, 0x03, 0xFB,
  0xF3, 0xF7, 0xF0, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x3F, 0x7F,
  0x00, 0xFE, 0xFC, 0xFD, 0xFC, 0x03, 0xFF, 0xE1, 0xF7, 0xE0, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFE, 0x7F,
  0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xDF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x81, 0xF3, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xE3, 0xE0,
  0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xDF, 0x03, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE,
  0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xC7, 0xF3,
  0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xFC, 0x1F, 0xDF, 0xF3, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xF7, 0xF0, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x10, 0x0F, 0xE7, 0xF8, 0x7F, 0x7F, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFB, 0xFF, 0x1F, 0x8F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF3, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xF7, 0xF1, 0xFF, 0xDF, 0xC1, 0xFC, 0x7F, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xFB, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x87, 0xF8,
  0x0F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x1F, 0xE7,
  0xF0, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F,
  0x07, 0xF9, 0xFC, 0x03, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x08,
  0x03, 0xFC, 0x78, 0x1F, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x7F, 0x8F, 0xEF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0x03, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F,
  0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xFB, 0xF8, 0x3F, 0xEF, 0xE1, 0xFF, 0x3F, 0x87, 0xF8, 0xFE, 0x3F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xE7, 0xF8, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xF3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFE, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0xFF, 0x0F, 0xEF,
  0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x3F, 0xE0, 0xFE,
  0xFE, 0x07, 0xF8, 0x3F, 0xBF, 0x81, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x03,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07,
  0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0xFC,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x03, 0xFD, 0xFE, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xE0,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x07, 0xE3, 0xFC, 0x3F, 0xBF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFD, 0xFF, 0x8F,
  0xE7, 0xF8, 0x7F, 0x04, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xF1, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x07, 0xF3, 0xFC, 0x02, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF9,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x06, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x18, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xDF, 0xCF, 0xFE, 0xFE, 0x3F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF9, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0xFE,
  0xFE, 0x07, 0xE0, 0xFE, 0x7E, 0x0F, 0xE0, 0xFE, 0x7F, 0x0F, 0xE0, 0xFE,
  0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFC, 0x7F, 0x1F, 0xF1, 0xFC,
  0x3F, 0x1F, 0xF1, 0xFC, 0x3F, 0x1F, 0xF9, 0xFC, 0x3F, 0x9F, 0xF9, 0xF8,
  0x3F, 0xBF, 0xF9, 0xF8, 0x1F, 0xBF, 0xF9, 0xF8, 0x1F, 0xBE, 0xFF, 0xF8,
  0x1F, 0xBE, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xFD, 0xFE,
  0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF,
  0x81, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFC, 0xFE, 0x0F,
  0xF3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0x7F, 0x01, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xF3, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x8F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x78,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x03, 0xC0, 0x1F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F,
  0x80, 0x78, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0x3F,
  0xF0, 0x1F, 0x7F, 0xF8, 0x3F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7E, 0xFC,
  0x7F, 0xFE, 0xFC, 0x3F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF8,
  0x07, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Bold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 39, 14, 3, -38 },
  { 40, 13, 14, 17, 2, -40 },
  { 63, 24, 38, 28, 2, -38 },
  { 177, 22, 50, 27, 2, -44 },
  { 315, 29, 40, 34, 3, -39 },
  { 460, 28, 40, 31, 2, -39 },
  { 600, 5, 14, 9, 2, -40 },
  { 609, 13, 54, 17, 3, -42 },
  { 697, 13, 54, 17, 1, -42 },
  { 785, 23, 23, 24, 1, -38 },
  { 852, 21, 28, 25, 2, -31 },
  { 926, 9, 16, 13, 1, -6 },
  { 944, 13, 6, 19, 3, -19 },
  { 954, 9, 9, 15, 3, -8 },
  { 965, 17, 41, 18, 0, -38 },
  { 1053, 22, 40, 27, 2, -39 },
  { 1163, 15, 38, 27, 4, -38 },
  { 1235, 23, 39, 27, 2, -39 },
  { 1348, 22, 40, 27, 2, -39 },
  { 1458, 23, 38, 27, 2, -38 },
  { 1568, 22, 39, 27, 3, -38 },
  { 1676, 22, 39, 27, 3, -38 },
  { 1784, 23, 38, 27, 2, -38 },
  { 1894, 21, 40, 27, 3, -39 },
  { 1999, 22, 39, 27, 2, -39 },
  { 2107, 9, 30, 14, 3, -29 },
  { 2141, 9, 39, 13, 2, -29 },
  { 2185, 18, 25, 24, 2, -29 },
  { 2242, 20, 17, 27, 3, -25 },
  { 2285, 19, 25, 24, 3, -29 },
  { 2345, 21, 40, 24, 1, -39 },
  { 2450, 37, 49, 41, 2, -37 },
  { 2677, 30, 38, 32, 1, -38 },
  { 2820, 24, 38, 30, 3, -38 },
  { 2934, 27, 40, 30, 2, -39 },
  { 3069, 24, 38, 30, 3, -38 },
  { 3183, 22, 38, 26, 3, -38 },
  { 3288, 21, 38, 25, 3, -38 },
  { 3388, 27, 40, 31, 2, -39 },
  { 3523, 26, 38, 33, 3, -38 },
  { 3647, 8, 38, 14, 3, -38 },
  { 3685, 22, 39, 26, 1, -38 },
  { 3793, 27, 38, 29, 3, -38 },
  { 3922, 21, 38, 25, 3, -38 },
  { 4022, 34, 38, 40, 3, -38 },
  { 4184, 26, 38, 32, 3, -38 },
  { 4308, 28, 40, 32, 2, -39 },
  { 4448, 25, 38, 30, 3, -38 },
  { 4567, 28, 46, 32, 2, -39 },
  { 4728, 25, 38, 29, 3, -38 },
  { 4847, 25, 40, 29, 2, -39 },
  { 4972, 26, 38, 29, 1, -38 },
  { 5096, 25, 39, 30, 3, -38 },
  { 5218, 29, 38, 31, 1, -38 },
  { 5356, 38, 38, 40, 1, -38 },
  { 5537, 28, 38, 30, 1, -38 },
  { 5670, 28, 38, 29, 0, -38 },
  { 5803, 24, 38, 28, 2, -38 },
  { 5917, 10, 53, 14, 3, -44 },
  { 5984, 21, 41, 20, 0, -38 },
  { 6092, 10, 53, 14, 1, -44 },
  { 6159, 18, 19, 21, 1, -38 },
  { 6202, 20, 6, 21, 1, 0 },
  { 6217, 14, 8, 18, 1, -40 },
  { 6231, 21, 30, 25, 2, -29 },
  { 6310, 21, 41, 26, 3, -40 },
  { 6418, 21, 30, 24, 2, -29 },
  { 6497, 22, 41, 26, 2, -40 },
  { 6610, 22, 30, 25, 2, -29 },
  { 6693, 16, 41, 17, 1, -41 },
  { 6775, 22, 40, 27, 2, -29 },
  { 6885, 20, 40, 26, 3, -40 },
  { 6985, 8, 39, 13, 3, -39 },
  { 7024, 11, 50, 13, -1, -39 },
  { 7093, 22, 40, 25, 3, -40 },
  { 7203, 7, 40, 13, 3, -40 },
  { 7238, 34, 29, 39, 3, -29 },
  { 7362, 20, 29, 26, 3, -29 },
  { 7435, 23, 30, 26, 2, -29 },
  { 7522, 21, 40, 26, 3, -29 },
  { 7627, 22, 40, 26, 2, -29 },
  { 7737, 14, 29, 18, 3, -29 },
  { 7788, 20, 30, 24, 2, -29 },
  { 7863, 14, 36, 16, 1, -35 },
  { 7926, 21, 29, 26, 3, -28 },
  { 8003, 22, 28, 24, 1, -28 },
  { 8080, 32, 28, 34, 1, -28 },
  { 8192, 22, 28, 24, 1, -28 },
  { 8269, 23, 39, 24, 0, -28 },
  { 8382, 20, 28, 24, 2, -28 },
  { 8452, 13, 50, 16, 1, -41 },
  { 8534, 5, 45, 13, 4, -38 },
  { 8563, 13, 50, 16, 1, -41 },
  { 8645, 24, 12, 30, 3, -22 },
};

const GFXfont RobotoCondensed_Bold53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_BOLD53PT7B_H_
