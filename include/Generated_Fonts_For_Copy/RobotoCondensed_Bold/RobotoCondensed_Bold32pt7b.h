#ifndef _ROBOTOCONDENSED_BOLD32PT7B_H_
#define _ROBOTOCONDENSED_BOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00,
  0x1D, 0xEF, 0xFD, 0xC0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x00, 0xCE,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0xE0, 0x39, 0x80, 0x73, 0x00,
  0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x39, 0x80, 0x63,
  0x00, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x9F, 0x1E, 0x7C,
  0x7D, 0xF1, 0xF7, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x1F, 0x78, 0x7D, 0xE1, 0xF7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1C, 0xE3, 0x8C, 0x71, 0x86, 0x39,
  0xC3, 0x1C, 0xC1, 0xCE, 0xE0, 0xFF, 0x60, 0x3F, 0x70, 0x0F, 0x70, 0x00,
  0x38, 0x00, 0x39, 0xE0, 0x1D, 0xF8, 0x1D, 0xFE, 0x0E, 0xE7, 0x0E, 0xE3,
  0x86, 0x71, 0xC7, 0x18, 0xE3, 0x0E, 0x70, 0x87, 0xF8, 0x01, 0xF8, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xCF, 0x01,
  0xE3, 0x80, 0xF1, 0xC0, 0x79, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xFC, 0xF3, 0xFE, 0x7B, 0xEF, 0xBD, 0xF3, 0xFC, 0xF9,
  0xFE, 0x7C, 0x7F, 0x3E, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3E, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x0C, 0x38, 0xF1, 0xC7, 0x0E,
  0x3C, 0x70, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0x81, 0x80, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xF0, 0xE0, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x73, 0x9D, 0xFF, 0xF7, 0xFF, 0xC3, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xEE, 0x0F, 0x1C, 0x38, 0x70, 0x20, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x7B, 0xDE, 0xF7,
  0xBD, 0xDE, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x83,
  0xFF, 0x0F, 0xFE, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDE, 0x1F,
  0x78, 0x79, 0xE1, 0xE7, 0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C,
  0x00, 0x01, 0x83, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFE, 0x78, 0xFB,
  0xE1, 0xEF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0xF8, 0xFB, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0xFC,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE7, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF7, 0x87, 0xFF, 0x3F, 0xFD,
  0xF7, 0xE1, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE,
  0x3D, 0xFF, 0xE7, 0xFE, 0x1F, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x87, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF7, 0xC7, 0xFF,
  0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xFE, 0x3E, 0xFF, 0xE7, 0xFE, 0x1F, 0xF0, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0x9F, 0x78,
  0x7B, 0xC3, 0xDE, 0x1E, 0xF9, 0xF3, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFE,
  0x7C, 0xFB, 0xC3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3D, 0xFF, 0xE7,
  0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC,
  0x7C, 0xF9, 0xE1, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0x7B, 0xE1, 0xF7, 0x87,
  0xDE, 0x1F, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x83, 0xDE, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0x39, 0xF7,
  0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x38, 0xE3,
  0x9E, 0x79, 0xCF, 0x18, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFF, 0xFF,
  0x3F, 0x07, 0x80, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3E, 0x01, 0xC0,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x0F,
  0xF8, 0x3F, 0xC1, 0xF8, 0x0F, 0x07, 0xE3, 0xFF, 0xFE, 0x7F, 0x0F, 0x81,
  0xC0, 0x20, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFF, 0xF9, 0xFF, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x0F, 0x87,
  0x70, 0x7F, 0x1D, 0xC3, 0xFC, 0x77, 0x1E, 0x71, 0xDC, 0x71, 0xC3, 0xE1,
  0xC7, 0x0F, 0x8F, 0x1C, 0x3E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3, 0x87,
  0x1F, 0x8E, 0x3C, 0x7E, 0x3C, 0xF3, 0x9C, 0xFF, 0xFE, 0x71, 0xFF, 0xF1,
  0xC3, 0xCF, 0x87, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x07, 0x9E, 0x00, 0xF8, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xFB, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F,
  0x78, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xC3, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x7E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x03, 0xF0, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3D, 0xFF,
  0xE7, 0xFE, 0x1F, 0xF0, 0x3E, 0x00, 0xF0, 0x3E, 0xF0, 0x7E, 0xF0, 0x7C,
  0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0,
  0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xF9, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0, 0x7E,
  0xF0, 0x3E, 0xF0, 0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xF7, 0x8E, 0xFF, 0x79, 0xEF, 0xF7, 0x9E, 0xFF,
  0x39, 0xEF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F, 0x8F,
  0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0, 0xF8, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xF0, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xF7, 0x9F, 0xF7, 0x9F, 0xF3,
  0xDF, 0xF3, 0xDF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0xBE,
  0x07, 0x9F, 0x87, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x3F, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0x3E, 0x0F, 0x9F, 0x87,
  0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x00, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC1, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x78, 0xF8,
  0xF1, 0xF1, 0xE1, 0xF3, 0xC3, 0xE7, 0x83, 0xEF, 0x07, 0xDE, 0x07, 0xFC,
  0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xCF,
  0x07, 0xFE, 0x0F, 0xBC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x7D,
  0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0x87,
  0xFE, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xF0,
  0x3E, 0x3C, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1F,
  0x07, 0x87, 0x81, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x00,
  0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x87, 0x87, 0xFE, 0x3F, 0x1F, 0x78, 0xFC, 0x7D, 0xE3, 0xF1,
  0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x7C, 0xFE, 0x79, 0xF7, 0xFB, 0xE3,
  0xDF, 0xEF, 0x0F, 0x7F, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF0, 0x3C, 0x00,
  0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xBE, 0x07, 0xDF, 0x07, 0xC7, 0x83, 0xE3, 0xE1, 0xE0, 0xF1, 0xF0, 0x78,
  0xF0, 0x3E, 0x78, 0x0F, 0x7C, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x77, 0x1E, 0xE3, 0x9E, 0x71,
  0xDE, 0x3B, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0F, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0x00,
  0x78, 0x03, 0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0xBE, 0x3D, 0xF1, 0xEF, 0x8F,
  0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0x1E, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF8, 0xFF, 0xE7, 0xFF, 0xBF,
  0xFD, 0xE1, 0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9E, 0xF8, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0xF7, 0x8F, 0xBF, 0xF9, 0xFF, 0xC7, 0xFC,
  0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE3, 0xCF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xF7, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE3, 0xCF, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x07, 0x81, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0x07, 0x8F, 0xCF,
  0xE7, 0xF3, 0xC1, 0xE0, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xBF, 0xFD, 0xFF,
  0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x40, 0xF3, 0xFF, 0x9F, 0xF8,
  0xFF, 0x81, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0x6F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x0F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x7F, 0xFF, 0xFF, 0xBE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x3F, 0xF1, 0xF7, 0x9F, 0x3C,
  0xF1, 0xEF, 0x8F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE,
  0x3C, 0xF1, 0xE7, 0xCF, 0x1E, 0x78, 0xFB, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7,
  0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF1, 0xF1, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x78, 0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F,
  0xC0, 0xF7, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F, 0x78, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFC, 0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x87,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x1F, 0x83, 0xFE, 0x7F, 0xF7, 0x9F, 0xF8, 0xFF, 0x80, 0x7E, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0xFF, 0xDF, 0x7F, 0xF3, 0xFE,
  0x1F, 0x80, 0x3E, 0x1F, 0x0F, 0x87, 0xCF, 0xFF, 0xFF, 0xFE, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xC7, 0xE3,
  0xF0, 0xF8, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x3C, 0xF0, 0x78, 0x7D, 0xE1, 0xE7, 0x87, 0x9F, 0x1E, 0x3C,
  0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0xF1, 0xE3,
  0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF9, 0xEF, 0x3F, 0x3C, 0xF7, 0xE7,
  0x9E, 0xFD, 0xE3, 0xDF, 0xBC, 0x7B, 0xFF, 0x87, 0xF7, 0xF0, 0xFC, 0xFE,
  0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF0,
  0x1E, 0x1E, 0x00, 0xF8, 0xFF, 0xC7, 0x9F, 0x7C, 0xFB, 0xC3, 0xFE, 0x1F,
  0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFE,
  0x3E, 0xF1, 0xE7, 0xDF, 0x1E, 0xF0, 0xF8, 0xF8, 0x7D, 0xE1, 0xF7, 0xC7,
  0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1F, 0xF0, 0x7F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x02, 0x0E, 0x1F, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF8, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1F, 0x0E, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xE0, 0xF0, 0x78, 0x78, 0x78, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1F, 0x0F, 0x1F, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0xF0, 0xE0, 0x40,
  0x3C, 0x1D, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFB, 0x87, 0xE0, 0x0F,
  0x00,
};

const GFXglyph RobotoCondensed_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 8, 2, -23 },
  { 16, 8, 9, 10, 1, -24 },
  { 25, 15, 23, 17, 1, -23 },
  { 69, 14, 29, 16, 1, -26 },
  { 120, 17, 23, 20, 2, -23 },
  { 169, 17, 23, 19, 1, -23 },
  { 218, 3, 9, 5, 1, -24 },
  { 222, 7, 32, 10, 2, -25 },
  { 250, 8, 32, 10, 1, -25 },
  { 282, 14, 14, 15, 0, -23 },
  { 307, 13, 16, 15, 1, -19 },
  { 333, 5, 10, 8, 1, -4 },
  { 340, 8, 4, 12, 2, -12 },
  { 344, 5, 5, 9, 2, -5 },
  { 348, 10, 25, 11, 0, -23 },
  { 380, 14, 23, 16, 1, -23 },
  { 421, 9, 23, 16, 2, -23 },
  { 447, 14, 23, 16, 1, -23 },
  { 488, 14, 23, 16, 1, -23 },
  { 529, 14, 23, 16, 1, -23 },
  { 570, 13, 23, 16, 2, -23 },
  { 608, 13, 23, 16, 2, -23 },
  { 646, 14, 23, 16, 1, -23 },
  { 687, 13, 23, 16, 2, -23 },
  { 725, 14, 23, 16, 1, -23 },
  { 766, 5, 18, 9, 2, -18 },
  { 778, 6, 24, 8, 1, -18 },
  { 796, 11, 15, 14, 1, -17 },
  { 817, 12, 11, 16, 2, -16 },
  { 834, 11, 15, 15, 2, -17 },
  { 855, 12, 23, 14, 1, -23 },
  { 890, 22, 29, 25, 1, -22 },
  { 970, 19, 23, 19, 0, -23 },
  { 1025, 14, 23, 18, 2, -23 },
  { 1066, 16, 23, 18, 1, -23 },
  { 1112, 15, 23, 18, 2, -23 },
  { 1156, 13, 23, 16, 2, -23 },
  { 1194, 12, 23, 15, 2, -23 },
  { 1229, 16, 23, 19, 1, -23 },
  { 1275, 16, 23, 20, 2, -23 },
  { 1321, 5, 23, 9, 2, -23 },
  { 1336, 13, 23, 16, 1, -23 },
  { 1374, 16, 23, 18, 2, -23 },
  { 1420, 12, 23, 15, 2, -23 },
  { 1455, 20, 23, 24, 2, -23 },
  { 1513, 16, 23, 20, 2, -23 },
  { 1559, 17, 23, 19, 1, -23 },
  { 1608, 15, 23, 18, 2, -23 },
  { 1652, 17, 27, 19, 1, -23 },
  { 1710, 15, 23, 18, 2, -23 },
  { 1754, 15, 23, 17, 1, -23 },
  { 1798, 16, 23, 17, 1, -23 },
  { 1844, 15, 23, 18, 2, -23 },
  { 1888, 18, 23, 18, 0, -23 },
  { 1940, 22, 23, 24, 1, -23 },
  { 2004, 16, 23, 18, 1, -23 },
  { 2050, 17, 23, 17, 0, -23 },
  { 2099, 15, 23, 17, 1, -23 },
  { 2143, 6, 31, 8, 2, -26 },
  { 2167, 13, 25, 12, 0, -23 },
  { 2208, 6, 31, 8, 1, -26 },
  { 2232, 11, 11, 13, 1, -23 },
  { 2248, 12, 4, 13, 0, 0 },
  { 2254, 8, 5, 11, 1, -24 },
  { 2259, 13, 17, 15, 1, -17 },
  { 2287, 13, 24, 16, 2, -24 },
  { 2326, 13, 17, 15, 1, -17 },
  { 2354, 13, 24, 16, 1, -24 },
  { 2393, 13, 17, 15, 1, -17 },
  { 2421, 9, 24, 10, 1, -24 },
  { 2448, 13, 24, 16, 1, -17 },
  { 2487, 12, 24, 16, 2, -24 },
  { 2523, 4, 24, 8, 2, -24 },
  { 2535, 7, 31, 8, -1, -24 },
  { 2563, 13, 24, 15, 2, -24 },
  { 2602, 4, 24, 8, 2, -24 },
  { 2614, 20, 17, 24, 2, -17 },
  { 2657, 12, 17, 16, 2, -17 },
  { 2683, 14, 17, 16, 1, -17 },
  { 2713, 13, 24, 16, 2, -17 },
  { 2752, 13, 24, 16, 1, -17 },
  { 2791, 8, 17, 11, 2, -17 },
  { 2808, 12, 17, 15, 1, -17 },
  { 2834, 9, 21, 10, 0, -21 },
  { 2858, 12, 17, 16, 2, -17 },
  { 2884, 14, 17, 14, 0, -17 },
  { 2914, 19, 17, 20, 1, -17 },
  { 2955, 13, 17, 14, 1, -17 },
  { 2983, 14, 24, 14, 0, -17 },
  { 3025, 12, 17, 14, 1, -17 },
  { 3051, 8, 31, 10, 1, -25 },
  { 3082, 2, 27, 8, 3, -23 },
  { 3089, 8, 31, 10, 1, -25 },
  { 3120, 14, 7, 18, 2, -13 },
};

const GFXfont RobotoCondensed_Bold32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_BOLD32PT7B_H_
