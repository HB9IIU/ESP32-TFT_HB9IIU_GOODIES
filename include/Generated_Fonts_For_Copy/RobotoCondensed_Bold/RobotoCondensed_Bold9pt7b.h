#ifndef _ROBOTOCONDENSED_BOLD9PT7B_H_
#define _ROBOTOCONDENSED_BOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB4, 0x35, 0x75, 0xF6, 0x60, 0x27, 0x54, 0x61, 0xD7, 0x20,
  0x65, 0x9C, 0x43, 0xAC, 0x60, 0x62, 0x9C, 0xCE, 0xE9, 0xE0, 0xC0, 0x6A,
  0xAA, 0x40, 0x95, 0x55, 0x80, 0x2D, 0x65, 0x22, 0xF2, 0x20, 0x58, 0xC0,
  0x80, 0x25, 0x24, 0xA4, 0x65, 0xDD, 0xD5, 0x60, 0x75, 0x54, 0x7D, 0x13,
  0x24, 0xF0, 0x6D, 0x12, 0x1D, 0x70, 0x33, 0x77, 0xF3, 0x30, 0x74, 0x71,
  0x1D, 0x60, 0x24, 0x7D, 0xD5, 0x70, 0xF1, 0x32, 0x26, 0x40, 0x75, 0x56,
  0x5D, 0x70, 0x65, 0xDD, 0x73, 0x60, 0x88, 0x40, 0x58, 0x3F, 0x90, 0xE3,
  0x80, 0x9F, 0xC0, 0x6F, 0x32, 0x40, 0x60, 0x38, 0x89, 0x6D, 0x5A, 0xB7,
  0x90, 0x1C, 0x21, 0x9C, 0xA5, 0xBF, 0x20, 0xEA, 0xAE, 0xBB, 0xE0, 0x72,
  0xF1, 0x8C, 0x2D, 0xC0, 0xEA, 0xBB, 0xBA, 0xE0, 0xF2, 0x79, 0x38, 0xF2,
  0x79, 0x20, 0x72, 0x71, 0xBC, 0xA5, 0xC0, 0x99, 0x9F, 0x99, 0x90, 0xFE,
  0x11, 0x11, 0x1D, 0x60, 0xBA, 0xCC, 0xEA, 0xB0, 0x92, 0x49, 0x38, 0x8E,
  0xF7, 0xBF, 0xD6, 0xA0, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0xF3, 0x9C, 0xAD,
  0xC0, 0xEB, 0xBB, 0xE8, 0x80, 0x72, 0xF3, 0x9C, 0xAD, 0xC1, 0xEB, 0xBE,
  0xAA, 0xB0, 0x76, 0x90, 0xE1, 0x69, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0xDE, 0xF7, 0xBD, 0xAD, 0xC0, 0xCE, 0xD4, 0xA5, 0x18, 0x80, 0xD5, 0xA9,
  0xD3, 0xE6, 0xCD, 0x9B, 0x00, 0xDA, 0x9C, 0x47, 0x2B, 0x60, 0xDA, 0x94,
  0xC2, 0x10, 0x80, 0xF1, 0x32, 0x64, 0xF0, 0xFF, 0xFF, 0x8C, 0x44, 0x62,
  0x22, 0xD5, 0x57, 0x4E, 0x80, 0xF0, 0x50, 0x6D, 0x7D, 0x70, 0xCC, 0xFD,
  0xDD, 0xF0, 0x6D, 0xCD, 0x60, 0x11, 0x7D, 0xDD, 0x70, 0x7D, 0xFC, 0x70,
  0x6B, 0xA4, 0x90, 0x7D, 0xDD, 0x71, 0x70, 0xCC, 0xFD, 0xDD, 0xD0, 0xC5,
  0x54, 0xC5, 0x55, 0x80, 0xCC, 0xFE, 0xEF, 0xD0, 0xFE, 0xFF, 0x5D, 0x75,
  0xD4, 0xFD, 0xDD, 0xD0, 0x7D, 0xDD, 0x70, 0xFD, 0xDD, 0xFC, 0xC0, 0x7D,
  0xDD, 0x71, 0x10, 0xFB, 0x6C, 0x6C, 0x69, 0x60, 0x5D, 0x24, 0xC0, 0xDD,
  0xDD, 0x70, 0xD7, 0x66, 0x60, 0xAB, 0xE7, 0x9E, 0x58, 0xF6, 0x66, 0xF0,
  0x9F, 0x66, 0x64, 0x40, 0xF2, 0x64, 0xF0, 0x55, 0x95, 0x40, 0xFF, 0x95,
  0x55, 0x80, 0x6D, 0x80,
};

const GFXglyph RobotoCondensed_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 3, 2, 3, 0, -7 },
  { 3, 4, 7, 5, 0, -7 },
  { 7, 4, 9, 5, 0, -8 },
  { 12, 5, 7, 6, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 1, 0, -7 },
  { 23, 2, 9, 3, 1, -7 },
  { 26, 2, 9, 3, 0, -7 },
  { 29, 4, 4, 4, 0, -7 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 2, 3, 2, 0, -1 },
  { 35, 2, 1, 3, 1, -3 },
  { 36, 1, 1, 3, 1, -1 },
  { 37, 3, 8, 3, 0, -7 },
  { 40, 4, 7, 5, 0, -7 },
  { 44, 2, 7, 5, 1, -7 },
  { 46, 4, 7, 5, 0, -7 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 4, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 0, -7 },
  { 66, 4, 7, 5, 0, -7 },
  { 70, 4, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 0, -7 },
  { 78, 1, 5, 2, 1, -5 },
  { 79, 2, 7, 2, 0, -5 },
  { 81, 3, 4, 4, 0, -5 },
  { 83, 3, 3, 5, 1, -4 },
  { 85, 3, 4, 4, 1, -5 },
  { 87, 4, 7, 4, 0, -7 },
  { 91, 7, 8, 7, 0, -6 },
  { 98, 5, 7, 5, 0, -7 },
  { 103, 4, 7, 5, 1, -7 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 4, 7, 5, 1, -7 },
  { 116, 3, 7, 4, 1, -7 },
  { 119, 3, 7, 4, 1, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 1, 7, 2, 1, -7 },
  { 132, 4, 7, 4, 0, -7 },
  { 136, 4, 7, 5, 1, -7 },
  { 140, 3, 7, 4, 1, -7 },
  { 143, 5, 7, 7, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 5, 7, 5, 0, -7 },
  { 157, 4, 7, 5, 1, -7 },
  { 161, 5, 8, 5, 0, -7 },
  { 166, 4, 7, 5, 1, -7 },
  { 170, 5, 7, 5, 0, -7 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 5, 7, 5, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 7, 7, 7, 0, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 4, 7, 5, 0, -7 },
  { 211, 2, 8, 2, 0, -7 },
  { 213, 4, 8, 3, 0, -7 },
  { 217, 2, 8, 2, 0, -7 },
  { 219, 3, 3, 4, 0, -7 },
  { 221, 4, 1, 4, 0, 0 },
  { 222, 2, 2, 3, 0, -7 },
  { 223, 4, 5, 4, 0, -5 },
  { 226, 4, 7, 4, 0, -7 },
  { 230, 4, 5, 4, 0, -5 },
  { 233, 4, 7, 4, 0, -7 },
  { 237, 4, 5, 4, 0, -5 },
  { 240, 3, 7, 3, 0, -7 },
  { 243, 4, 7, 5, 0, -5 },
  { 247, 4, 7, 4, 0, -7 },
  { 251, 2, 7, 2, 0, -7 },
  { 253, 2, 9, 2, 0, -7 },
  { 256, 4, 7, 4, 0, -7 },
  { 260, 1, 7, 2, 1, -7 },
  { 261, 6, 5, 7, 0, -5 },
  { 265, 4, 5, 4, 0, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 4, 7, 4, 0, -5 },
  { 275, 4, 7, 4, 0, -5 },
  { 279, 3, 5, 3, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 3, 6, 3, 0, -6 },
  { 287, 4, 5, 4, 0, -5 },
  { 290, 4, 5, 4, 0, -5 },
  { 293, 6, 5, 6, 0, -5 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 4, 7, 4, 0, -5 },
  { 304, 4, 5, 4, 0, -5 },
  { 307, 2, 9, 3, 0, -7 },
  { 310, 1, 8, 2, 1, -7 },
  { 311, 2, 9, 3, 0, -7 },
  { 314, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_Bold9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_BOLD9PT7B_H_
