#ifndef _ROBOTOCONDENSED_BOLD20PT7B_H_
#define _ROBOTOCONDENSED_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x60, 0x3E, 0xC0, 0xDE, 0xE7, 0x39, 0x00, 0x1B,
  0x0D, 0x84, 0x82, 0x4F, 0xFF, 0xFC, 0xD8, 0x6C, 0xFF, 0x7F, 0x9B, 0x0D,
  0x86, 0xC3, 0x60, 0x08, 0x08, 0x3C, 0x7E, 0x77, 0xE7, 0xE7, 0x70, 0x7C,
  0x1E, 0x07, 0xE7, 0xE7, 0xE7, 0x7F, 0x3C, 0x18, 0x18, 0x70, 0x1F, 0x03,
  0x66, 0x6C, 0x8D, 0xB1, 0xFC, 0x1D, 0x80, 0x6E, 0x0B, 0xE3, 0x4C, 0x49,
  0x99, 0x30, 0x3E, 0x03, 0x80, 0x3C, 0x1F, 0x87, 0x61, 0x98, 0x66, 0x1F,
  0x03, 0x81, 0xF6, 0xFD, 0xB3, 0xEE, 0x7B, 0x9C, 0xFF, 0x8F, 0x70, 0xFF,
  0x80, 0x08, 0xCC, 0xE6, 0x31, 0x9C, 0xE6, 0x31, 0xCE, 0x31, 0x8C, 0x71,
  0x86, 0x10, 0x8C, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x33, 0x36, 0x6C, 0xC8,
  0x0C, 0x06, 0x02, 0x1F, 0x73, 0xF0, 0xE0, 0xD8, 0xEE, 0x22, 0x00, 0x38,
  0x38, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x77, 0x76,
  0x64, 0xFF, 0xC0, 0x7D, 0x80, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x30,
  0xC6, 0x18, 0x63, 0x0C, 0x00, 0x3C, 0x7E, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0x1B, 0xFF, 0xF3, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0x3C, 0x7E, 0xE7, 0xE7, 0xC7, 0x07, 0x0E, 0x0E,
  0x1C, 0x38, 0x70, 0xF0, 0xFF, 0xFF, 0x3C, 0x7E, 0xE7, 0xE7, 0x07, 0x07,
  0x3E, 0x3E, 0x07, 0x07, 0xC7, 0xE7, 0xFE, 0x3C, 0x0E, 0x0E, 0x1E, 0x1E,
  0x3E, 0x3E, 0x6E, 0x6E, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E, 0x7F, 0x7F,
  0x60, 0x60, 0xE0, 0xFE, 0xFF, 0x67, 0x07, 0x07, 0xE7, 0xE7, 0x7E, 0x3C,
  0x0E, 0x3E, 0x78, 0x70, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0x77,
  0x7E, 0x3C, 0xFF, 0xFF, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x70, 0x70, 0x3C, 0x7E, 0xE7, 0xE7, 0xE7, 0x67, 0x7E, 0x7E,
  0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0x3C, 0x7E, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x7F, 0x3F, 0x07, 0x06, 0x1E, 0x3C, 0x38, 0x7D, 0x80, 0x00, 0x7D,
  0x80, 0xFF, 0x80, 0x00, 0x0D, 0xBF, 0xB0, 0x02, 0x1C, 0xFF, 0xCE, 0x1C,
  0x3E, 0x1F, 0x0E, 0x04, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC3,
  0xE1, 0xF0, 0xE1, 0xCF, 0xFC, 0xE1, 0x00, 0x3E, 0x7F, 0x77, 0x67, 0x07,
  0x0E, 0x0E, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x18, 0x07, 0xC0, 0x7F,
  0x83, 0x03, 0x18, 0x06, 0x63, 0x9B, 0x1F, 0x2C, 0xCC, 0xB3, 0x32, 0xCC,
  0xCF, 0x63, 0x2D, 0x88, 0xB7, 0x66, 0xCF, 0xF3, 0x3B, 0xC6, 0x00, 0x1C,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x06, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x81, 0xB8, 0x19, 0x83, 0x9C, 0x39, 0xC3, 0xFC, 0x7F, 0xE7, 0x0E, 0x70,
  0xEE, 0x07, 0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0xFD, 0xFE, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xF0, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1,
  0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x7E, 0x1D, 0xCE, 0x7F, 0x8F, 0x80,
  0xFC, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8,
  0xFC, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xE7, 0x3B,
  0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E, 0x1D, 0xCF, 0x7F,
  0xC7, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xF8, 0xEE, 0xE7, 0xF1, 0xF0, 0xE3, 0xF8, 0xEE, 0x73, 0x9C, 0xEE,
  0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xBF, 0xED, 0xBF, 0x7D, 0xFB, 0xEF, 0xCE, 0x7E, 0x73, 0xF3,
  0x9C, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xFF, 0x7E, 0xDF, 0xBF, 0xE7,
  0xF9, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x70, 0x1E, 0x1F, 0xE7, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x87,
  0x80, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0xFE,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1E, 0x1F, 0xE7, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x87,
  0xE0, 0x3C, 0x07, 0x00, 0x80, 0xFE, 0x3F, 0xCE, 0x7B, 0x8E, 0xE3, 0xB8,
  0xEE, 0x7B, 0xFC, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0xF0, 0x3E,
  0x3F, 0xBD, 0xFC, 0x7E, 0x07, 0x81, 0xF8, 0x3E, 0x07, 0xF1, 0xF8, 0xFE,
  0xF7, 0xF1, 0xF0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFE, 0x77, 0xF1, 0xF0, 0xE0,
  0xEE, 0x1D, 0xC3, 0xB8, 0xE3, 0x1C, 0x73, 0x8E, 0x61, 0xDC, 0x1B, 0x83,
  0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x63, 0x8C, 0xC7, 0x19, 0xCE,
  0x73, 0x9C, 0xE7, 0x7D, 0xCE, 0xFB, 0x8D, 0xB6, 0x1B, 0x6C, 0x3E, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x00, 0x71, 0xEE,
  0x38, 0xE7, 0x1D, 0xC1, 0xF8, 0x3E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x70,
  0xEE, 0x1C, 0xE7, 0x1C, 0xE3, 0xC0, 0xE1, 0xCE, 0x39, 0xC7, 0x19, 0xC3,
  0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x30, 0x38,
  0x38, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18,
  0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0xFF, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0xFF, 0x18, 0x70, 0xF1, 0xE6, 0xCC, 0xD9, 0x80,
  0xFF, 0xFF, 0xE3, 0x8C, 0x3C, 0xFE, 0xEE, 0x06, 0x7E, 0xFE, 0xE6, 0xC6,
  0xEE, 0xFE, 0x77, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE7, 0xE7, 0xFF, 0xFE, 0x3C, 0x7E, 0xE6, 0xE7, 0xC0, 0xC0,
  0xC0, 0xE7, 0xE6, 0x7E, 0x3C, 0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0xFF, 0x7F, 0x3C, 0x7E, 0xE7, 0xE7,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE2, 0x7F, 0x3E, 0x1C, 0xF3, 0x8C, 0xFF, 0xF3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7B, 0xFF, 0xE7, 0xE7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xE7, 0x7F, 0x7F, 0x07, 0x47, 0x7E, 0x7C, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x03, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xBC, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x77, 0x73, 0xB9, 0xF8, 0xF8, 0x7E, 0x3F, 0x1D, 0xCE, 0xE7, 0x3B, 0x9C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0xF7, 0xFF, 0xB9, 0xCF, 0xCE,
  0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCE,
  0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C,
  0x7E, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0x7E, 0x3C, 0xFE, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0xFF, 0x7F,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x7D,
  0xFF, 0xBF, 0x0F, 0x0F, 0x87, 0x83, 0xC7, 0xFD, 0xF0, 0x71, 0xCF, 0xFF,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0xE3, 0xB1, 0x9D, 0xCE, 0xE7, 0x61,
  0xB0, 0xD8, 0x7C, 0x1C, 0x0E, 0x07, 0x00, 0xE6, 0x36, 0x77, 0x67, 0x77,
  0x77, 0x7F, 0x67, 0xDE, 0x3D, 0xE3, 0xDE, 0x39, 0xE3, 0x9C, 0x38, 0xC0,
  0x73, 0x3B, 0x8F, 0x87, 0xC1, 0xC0, 0xE0, 0xF8, 0x7C, 0x37, 0x3B, 0x98,
  0xE0, 0xE3, 0xB1, 0x9D, 0xCE, 0xE7, 0x61, 0xB0, 0xF8, 0x7C, 0x1C, 0x0E,
  0x07, 0x03, 0x03, 0x83, 0xC1, 0xC0, 0xFF, 0xFC, 0x38, 0xE1, 0x87, 0x1C,
  0x38, 0xE1, 0xFF, 0xF8, 0x13, 0x76, 0x66, 0x66, 0x6C, 0xC6, 0x66, 0x66,
  0x67, 0x31, 0xFF, 0xFF, 0x80, 0x8C, 0xE6, 0x66, 0x66, 0x63, 0x36, 0x66,
  0x66, 0x6E, 0xC8, 0x71, 0xBE, 0xF3, 0xF8, 0xE0,
};

const GFXglyph RobotoCondensed_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 5, 5, 6, 1, -15 },
  { 11, 9, 14, 11, 1, -14 },
  { 27, 8, 18, 10, 1, -16 },
  { 45, 11, 14, 13, 1, -14 },
  { 65, 10, 14, 12, 1, -14 },
  { 83, 2, 5, 3, 1, -15 },
  { 85, 5, 20, 6, 1, -16 },
  { 98, 4, 20, 6, 1, -16 },
  { 108, 9, 9, 9, 0, -14 },
  { 119, 8, 11, 10, 1, -12 },
  { 130, 4, 6, 5, 0, -2 },
  { 133, 5, 2, 7, 1, -7 },
  { 135, 3, 3, 6, 1, -3 },
  { 137, 6, 15, 7, 0, -14 },
  { 149, 8, 14, 10, 1, -14 },
  { 163, 5, 14, 10, 2, -14 },
  { 172, 8, 14, 10, 1, -14 },
  { 186, 8, 14, 10, 1, -14 },
  { 200, 8, 14, 10, 1, -14 },
  { 214, 8, 14, 10, 1, -14 },
  { 228, 8, 14, 10, 1, -14 },
  { 242, 8, 14, 10, 1, -14 },
  { 256, 8, 14, 10, 1, -14 },
  { 270, 8, 14, 10, 1, -14 },
  { 284, 3, 11, 5, 1, -11 },
  { 289, 3, 15, 5, 1, -11 },
  { 295, 7, 10, 9, 1, -11 },
  { 304, 8, 6, 10, 1, -9 },
  { 310, 7, 10, 9, 1, -11 },
  { 319, 8, 14, 9, 0, -14 },
  { 333, 14, 18, 15, 1, -14 },
  { 365, 12, 14, 12, 0, -14 },
  { 386, 9, 14, 11, 1, -14 },
  { 402, 10, 14, 11, 1, -14 },
  { 420, 9, 14, 11, 1, -14 },
  { 436, 8, 14, 10, 1, -14 },
  { 450, 8, 14, 10, 1, -14 },
  { 464, 10, 14, 12, 1, -14 },
  { 482, 10, 14, 12, 1, -14 },
  { 500, 3, 14, 5, 1, -14 },
  { 506, 9, 14, 10, 0, -14 },
  { 522, 10, 14, 11, 1, -14 },
  { 540, 8, 14, 10, 1, -14 },
  { 554, 13, 14, 15, 1, -14 },
  { 577, 10, 14, 12, 1, -14 },
  { 595, 10, 14, 12, 1, -14 },
  { 613, 10, 14, 11, 1, -14 },
  { 631, 10, 17, 12, 1, -14 },
  { 653, 10, 14, 11, 1, -14 },
  { 671, 9, 14, 11, 1, -14 },
  { 687, 9, 14, 11, 1, -14 },
  { 703, 9, 14, 11, 1, -14 },
  { 719, 11, 14, 12, 0, -14 },
  { 739, 15, 14, 15, 0, -14 },
  { 766, 11, 14, 11, 0, -14 },
  { 786, 11, 14, 11, 0, -14 },
  { 806, 9, 14, 11, 1, -14 },
  { 822, 4, 20, 5, 1, -17 },
  { 832, 8, 15, 8, 0, -14 },
  { 847, 4, 20, 5, 0, -17 },
  { 857, 7, 7, 8, 0, -14 },
  { 864, 8, 2, 8, 0, 0 },
  { 866, 5, 3, 7, 1, -15 },
  { 868, 8, 11, 9, 1, -11 },
  { 879, 8, 15, 10, 1, -15 },
  { 894, 8, 11, 9, 1, -11 },
  { 905, 8, 15, 10, 1, -15 },
  { 920, 8, 11, 10, 1, -11 },
  { 931, 6, 15, 7, 0, -15 },
  { 943, 8, 15, 10, 1, -11 },
  { 958, 8, 15, 10, 1, -15 },
  { 973, 3, 15, 5, 1, -15 },
  { 979, 5, 19, 5, -1, -15 },
  { 991, 9, 15, 10, 1, -15 },
  { 1008, 3, 15, 5, 1, -15 },
  { 1014, 13, 11, 15, 1, -11 },
  { 1032, 8, 11, 10, 1, -11 },
  { 1043, 8, 11, 10, 1, -11 },
  { 1054, 8, 15, 10, 1, -11 },
  { 1069, 8, 15, 10, 1, -11 },
  { 1084, 5, 11, 7, 1, -11 },
  { 1091, 7, 11, 9, 1, -11 },
  { 1101, 6, 13, 6, 0, -13 },
  { 1111, 8, 11, 10, 1, -11 },
  { 1122, 9, 11, 9, 0, -11 },
  { 1135, 12, 11, 13, 0, -11 },
  { 1152, 9, 11, 9, 0, -11 },
  { 1165, 9, 15, 9, 0, -11 },
  { 1182, 7, 11, 9, 1, -11 },
  { 1192, 4, 20, 6, 1, -16 },
  { 1202, 1, 17, 5, 2, -14 },
  { 1205, 4, 20, 6, 1, -16 },
  { 1215, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Bold20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_BOLD20PT7B_H_
