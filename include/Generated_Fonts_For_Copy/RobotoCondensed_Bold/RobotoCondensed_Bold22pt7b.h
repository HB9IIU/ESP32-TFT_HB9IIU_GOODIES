#ifndef _ROBOTOCONDENSED_BOLD22PT7B_H_
#define _ROBOTOCONDENSED_BOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xE6, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xDE, 0xF7, 0xBD,
  0xCC, 0x19, 0x86, 0x41, 0xB0, 0x6C, 0xFF, 0xFF, 0xF1, 0x30, 0xCC, 0x32,
  0x0D, 0x8F, 0xFB, 0xFE, 0x36, 0x19, 0x86, 0x61, 0x90, 0x0C, 0x06, 0x07,
  0x8F, 0xE7, 0xFB, 0x9D, 0xCE, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3F,
  0x1F, 0x8F, 0xFF, 0x7F, 0x1F, 0x02, 0x01, 0x00, 0x78, 0x0F, 0xC0, 0xCC,
  0xCC, 0xC8, 0xCD, 0x8F, 0xF0, 0x7B, 0x00, 0x60, 0x06, 0x00, 0xDE, 0x0D,
  0xF1, 0xB3, 0x1B, 0x33, 0x33, 0x11, 0xF0, 0x1E, 0x1C, 0x07, 0xE1, 0xFC,
  0x39, 0x87, 0x30, 0xEE, 0x0F, 0x81, 0xE0, 0x7C, 0xFF, 0xDB, 0xBF, 0x73,
  0xEE, 0x3D, 0xFF, 0x9F, 0xF1, 0xE7, 0xFF, 0xF0, 0x08, 0x63, 0x8C, 0x71,
  0x86, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x61, 0xC3, 0x0E, 0x18,
  0x20, 0x86, 0x38, 0xC7, 0x18, 0xC7, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x33,
  0x99, 0xCC, 0x40, 0x0C, 0x03, 0x04, 0xC1, 0xFF, 0x3F, 0x87, 0x83, 0xF0,
  0xCC, 0x21, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x33, 0x37, 0x76, 0x40, 0xFF, 0xFF, 0xC0, 0x7F,
  0x60, 0x06, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x86,
  0x0C, 0x18, 0x70, 0xC0, 0x1E, 0x3F, 0x9F, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3B, 0xF9, 0xFC, 0x3C, 0x0C, 0xFF,
  0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3E, 0x3F,
  0xBF, 0xFC, 0x7E, 0x38, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07,
  0x87, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFC, 0x70, 0x38, 0x1C, 0x1C,
  0x3C, 0x1F, 0x01, 0xC0, 0xFC, 0x7E, 0x3F, 0xFD, 0xFC, 0x7C, 0x07, 0x07,
  0x83, 0xC3, 0xE1, 0xF1, 0xF8, 0xDC, 0xEE, 0x67, 0x73, 0xBF, 0xFF, 0xFF,
  0xF8, 0x38, 0x1C, 0x0E, 0x7F, 0xBF, 0xDF, 0xEE, 0x06, 0x03, 0xF3, 0xFD,
  0xCF, 0x03, 0x81, 0xC0, 0xFC, 0x7E, 0x3B, 0xFD, 0xFC, 0x3C, 0x0E, 0x0F,
  0x0F, 0x8E, 0x07, 0x07, 0x73, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3B, 0xFC, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x3E, 0x3F,
  0x9F, 0xDC, 0x7E, 0x3F, 0x1D, 0xFC, 0x7C, 0x7F, 0x79, 0xF8, 0xFC, 0x7E,
  0x3F, 0xFD, 0xFC, 0x7C, 0x1C, 0x3F, 0x9F, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xF7, 0xBF, 0xCE, 0xE0, 0x60, 0x71, 0xF0, 0xF0, 0x70, 0x7F, 0x60,
  0x00, 0x00, 0x07, 0xF6, 0xEF, 0x60, 0x00, 0x00, 0x06, 0x66, 0x6E, 0xCC,
  0x02, 0x0C, 0x7B, 0xFF, 0x9C, 0x3E, 0x3F, 0x1E, 0x0C, 0x08, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0x80, 0x3C, 0xFE, 0xFF, 0xE7, 0x07, 0x07,
  0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0xE0,
  0x1F, 0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x78, 0xF9, 0xF9, 0xE3,
  0x33, 0xCC, 0x67, 0x98, 0xCF, 0x33, 0x9E, 0x66, 0x3C, 0xCC, 0xD9, 0xFF,
  0xB1, 0xDE, 0x30, 0x00, 0x60, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0E, 0xE0, 0x77, 0x03,
  0xB8, 0x18, 0xE1, 0xC7, 0x0F, 0xF8, 0x7F, 0xE7, 0xFF, 0x38, 0x39, 0xC1,
  0xDE, 0x0F, 0xFF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0xFE,
  0xFF, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xFF, 0xFB, 0xFC, 0x1F, 0x07,
  0xF1, 0xFF, 0x78, 0xEE, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x7F, 0x1E, 0xFF, 0x8F, 0xF0, 0xF8, 0xFE, 0x3F, 0xCF, 0xFB,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFF, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD,
  0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x1F, 0x07, 0xF9, 0xFF, 0x78, 0xFE, 0x0F, 0xC0,
  0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x77, 0x0E, 0xFF, 0xCF,
  0xF0, 0xFC, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3D, 0xCF, 0x73,
  0x9F, 0xE3, 0xF0, 0x78, 0xE1, 0xFC, 0x3B, 0x8F, 0x73, 0xCE, 0x71, 0xDE,
  0x3B, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xDC, 0x73, 0xCE, 0x39, 0xC7, 0xB8,
  0x77, 0x0F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1, 0xBF, 0xC6, 0xFB, 0x3F, 0xEE, 0xFF,
  0xBB, 0x7E, 0x7D, 0xF9, 0xF7, 0xE7, 0x9F, 0x9E, 0x7E, 0x39, 0xF8, 0xE7,
  0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xEE,
  0xFC, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0x1F, 0x07,
  0xF9, 0xFF, 0x38, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x1E, 0xFF, 0x8F, 0xF0, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF,
  0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFE, 0xFF, 0x9F, 0xE3, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1E,
  0xFF, 0x8F, 0xF0, 0xFE, 0x01, 0xE0, 0x1C, 0x01, 0x00, 0xFF, 0x1F, 0xF3,
  0xFF, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0xFE, 0xFF, 0x9F, 0xE3, 0x9E,
  0x71, 0xCE, 0x39, 0xC7, 0xB8, 0x77, 0x0F, 0x1E, 0x1F, 0xEF, 0xFB, 0x8F,
  0xE1, 0xFC, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x87, 0xE1, 0xFF,
  0xF7, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xF1, 0xDF, 0xF7, 0xF8, 0x7C, 0xF0, 0x73, 0x83, 0x9C, 0x1C,
  0xE1, 0xE7, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xEE, 0x3B, 0xEE, 0x3B,
  0xEE, 0x3F, 0x6E, 0x3F, 0x6C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x70, 0xF7, 0x8E, 0x39, 0xE3, 0xDC, 0x1D,
  0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xDC, 0x39,
  0xC3, 0x9E, 0x70, 0xE7, 0x0F, 0xF0, 0xF7, 0x0E, 0x70, 0xE3, 0x9C, 0x39,
  0xC3, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF,
  0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0xFF, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xFC, 0x38, 0x71,
  0xE3, 0xE6, 0xDD, 0xB3, 0xE3, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x3E, 0x3F,
  0xBD, 0xDC, 0xE0, 0x71, 0xFB, 0xFD, 0xCE, 0xE7, 0x73, 0xBF, 0xCF, 0xF0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFE, 0xEE, 0x00, 0x3C, 0x3F, 0xBF, 0xDC,
  0xEE, 0x37, 0x03, 0x81, 0xC0, 0xE3, 0x7F, 0x9F, 0xC7, 0xC0, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x39, 0xDD, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0xFE, 0xFF, 0x3B, 0x80, 0x3E, 0x3F, 0xBF, 0xDC, 0x7E, 0x3F,
  0xFF, 0xFF, 0xC0, 0xE1, 0x7F, 0x9F, 0xE7, 0xC0, 0x0E, 0x3C, 0xF9, 0xC3,
  0x9F, 0xFF, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x3B,
  0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xE7,
  0x70, 0x3B, 0x3D, 0xFC, 0x7C, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73,
  0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0x80, 0xFD, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xCE, 0x03, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xE0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x39, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE,
  0x3B, 0xCE, 0x73, 0x9E, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xEE, 0x7B, 0xFF, 0xFF, 0xFF, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E,
  0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xEE, 0x7F,
  0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70,
  0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF,
  0xC7, 0xC0, 0xEE, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFF, 0xFF, 0xDD, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0x3B, 0xBF, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xE7, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x3C,
  0x7E, 0xE7, 0xE7, 0xF0, 0x7C, 0x3F, 0x0F, 0xE7, 0xE7, 0xFF, 0x3C, 0x38,
  0xEF, 0xFF, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0x70, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xE7, 0x70,
  0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x0F, 0xC3, 0xF0, 0xFC, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0xE3, 0x19, 0xCC, 0xE7, 0x7B, 0x9D, 0xEE, 0x77, 0xB9,
  0xDE, 0xC3, 0xFF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x06, 0x38,
  0x73, 0x9C, 0xE3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x0F,
  0xC7, 0x39, 0xCE, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x77, 0x0F, 0xC3, 0xF0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x1C, 0x1F, 0x07, 0x81, 0xC0, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xFF, 0xFF, 0xFF, 0x19,
  0xCC, 0xE7, 0x39, 0xCE, 0x77, 0x39, 0xC7, 0x39, 0xCE, 0x73, 0x9C, 0x71,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x86, 0x38, 0xC6, 0x31, 0x8C, 0x73,
  0x8E, 0x77, 0x39, 0x8C, 0x63, 0x39, 0x88, 0x00, 0x38, 0xDF, 0x3F, 0xFF,
  0x9E, 0xC3, 0x80,
};

const GFXglyph RobotoCondensed_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 5, 6, 7, 1, -17 },
  { 13, 10, 16, 12, 1, -16 },
  { 33, 9, 20, 11, 1, -18 },
  { 56, 12, 16, 14, 1, -16 },
  { 80, 11, 16, 13, 1, -16 },
  { 102, 2, 6, 4, 1, -17 },
  { 104, 6, 22, 7, 1, -17 },
  { 121, 5, 22, 7, 1, -17 },
  { 135, 10, 9, 10, 0, -16 },
  { 147, 9, 11, 10, 1, -13 },
  { 160, 4, 7, 5, 0, -3 },
  { 164, 6, 3, 8, 1, -8 },
  { 167, 4, 3, 6, 1, -3 },
  { 169, 7, 17, 7, 0, -16 },
  { 184, 9, 16, 11, 1, -16 },
  { 202, 6, 16, 11, 2, -16 },
  { 214, 9, 16, 11, 1, -16 },
  { 232, 9, 16, 11, 1, -16 },
  { 250, 9, 16, 11, 1, -16 },
  { 268, 9, 16, 11, 1, -16 },
  { 286, 9, 16, 11, 1, -16 },
  { 304, 9, 16, 11, 1, -16 },
  { 322, 9, 16, 11, 1, -16 },
  { 340, 9, 16, 11, 1, -16 },
  { 358, 4, 12, 6, 1, -12 },
  { 364, 4, 16, 6, 1, -12 },
  { 372, 7, 11, 10, 1, -12 },
  { 382, 9, 8, 11, 1, -11 },
  { 391, 8, 11, 10, 1, -12 },
  { 402, 8, 16, 10, 1, -16 },
  { 418, 15, 20, 17, 1, -15 },
  { 456, 13, 16, 13, 0, -16 },
  { 482, 10, 16, 12, 1, -16 },
  { 502, 11, 16, 13, 1, -16 },
  { 524, 10, 16, 12, 1, -16 },
  { 544, 9, 16, 11, 1, -16 },
  { 562, 9, 16, 10, 1, -16 },
  { 580, 11, 16, 13, 1, -16 },
  { 602, 11, 16, 14, 1, -16 },
  { 624, 4, 16, 6, 1, -16 },
  { 632, 10, 16, 11, 0, -16 },
  { 652, 11, 16, 12, 1, -16 },
  { 674, 9, 16, 11, 1, -16 },
  { 692, 14, 16, 17, 1, -16 },
  { 720, 11, 16, 13, 1, -16 },
  { 742, 11, 16, 13, 1, -16 },
  { 764, 11, 16, 13, 1, -16 },
  { 786, 11, 19, 13, 1, -16 },
  { 813, 11, 16, 12, 1, -16 },
  { 835, 10, 16, 12, 1, -16 },
  { 855, 10, 16, 12, 1, -16 },
  { 875, 10, 16, 13, 1, -16 },
  { 895, 13, 16, 13, 0, -16 },
  { 921, 16, 16, 16, 0, -16 },
  { 953, 12, 16, 12, 0, -16 },
  { 977, 12, 16, 12, 0, -16 },
  { 1001, 10, 16, 12, 1, -16 },
  { 1021, 4, 22, 6, 1, -18 },
  { 1032, 9, 17, 8, 0, -16 },
  { 1052, 5, 22, 6, 0, -18 },
  { 1066, 7, 8, 9, 1, -16 },
  { 1073, 9, 2, 9, 0, 0 },
  { 1076, 5, 3, 7, 1, -16 },
  { 1078, 9, 12, 10, 1, -12 },
  { 1092, 9, 17, 11, 1, -17 },
  { 1112, 9, 12, 10, 1, -12 },
  { 1126, 9, 17, 11, 1, -17 },
  { 1146, 9, 12, 11, 1, -12 },
  { 1160, 7, 17, 7, 0, -17 },
  { 1175, 9, 16, 11, 1, -12 },
  { 1193, 9, 17, 11, 1, -17 },
  { 1213, 3, 16, 6, 1, -16 },
  { 1219, 5, 20, 5, -1, -16 },
  { 1232, 10, 17, 11, 1, -17 },
  { 1254, 3, 17, 6, 1, -17 },
  { 1261, 14, 12, 16, 1, -12 },
  { 1282, 9, 12, 11, 1, -12 },
  { 1296, 9, 12, 11, 1, -12 },
  { 1310, 9, 16, 11, 1, -12 },
  { 1328, 9, 16, 11, 1, -12 },
  { 1346, 6, 12, 7, 1, -12 },
  { 1355, 8, 12, 10, 1, -12 },
  { 1367, 6, 14, 7, 0, -14 },
  { 1378, 9, 12, 11, 1, -12 },
  { 1392, 10, 12, 10, 0, -12 },
  { 1407, 14, 12, 14, 0, -12 },
  { 1428, 10, 12, 10, 0, -12 },
  { 1443, 10, 16, 10, 0, -12 },
  { 1463, 8, 12, 10, 1, -12 },
  { 1475, 5, 21, 7, 1, -17 },
  { 1489, 2, 19, 6, 2, -16 },
  { 1494, 5, 21, 7, 1, -17 },
  { 1508, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_Bold22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_BOLD22PT7B_H_
