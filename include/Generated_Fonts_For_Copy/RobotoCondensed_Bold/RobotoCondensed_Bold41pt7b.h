#ifndef _ROBOTOCONDENSED_BOLD41PT7B_H_
#define _ROBOTOCONDENSED_BOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x1C, 0x7D, 0xFF,
  0xFB, 0xE3, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x77, 0x8E, 0xF1, 0xDE, 0x3B, 0xC7, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x38, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F, 0x1C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0x71,
  0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0x9F, 0x87,
  0xEF, 0x83, 0xF7, 0xC1, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0xFD, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0xC7,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x60, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F,
  0x0F, 0x1E, 0x38, 0x3C, 0x79, 0xE0, 0xF1, 0xE7, 0x03, 0xC7, 0xBC, 0x0F,
  0xBC, 0xE0, 0x1F, 0xF7, 0x80, 0x3F, 0x9C, 0x00, 0x7C, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0xF7, 0xF8, 0x03, 0xBF, 0xE0, 0x1E, 0xFF,
  0xC0, 0x73, 0x8F, 0x03, 0xDE, 0x1C, 0x0E, 0x78, 0x70, 0x79, 0xE1, 0xC1,
  0xC7, 0x87, 0x0F, 0x0E, 0x3C, 0x18, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0x07, 0xFC, 0x3C,
  0x3F, 0xF9, 0xF1, 0xFB, 0xF7, 0xC7, 0xCF, 0xDF, 0x1F, 0x1F, 0xFC, 0xFC,
  0x3F, 0xF3, 0xF0, 0xFF, 0x87, 0xC1, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x07, 0xF1, 0xFC,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x80, 0x70, 0x3C, 0x1F,
  0x07, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x80, 0x40,
  0x18, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x01,
  0x80, 0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0x0E, 0x1B, 0xE7, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFE,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0xF8, 0xF0, 0x78,
  0x7C, 0x1C, 0x1C, 0x04, 0x04, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x79, 0xF3,
  0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x3C, 0x1F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F,
  0x87, 0xE7, 0xE1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBF, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x7E,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7B,
  0xF0, 0x3E, 0xFC, 0x0F, 0x3F, 0x07, 0xCF, 0xC1, 0xE3, 0xF0, 0xF8, 0xFC,
  0x3E, 0x3F, 0x1F, 0x0F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9,
  0xF9, 0xFC, 0x30, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x7F, 0x7F,
  0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0xFD, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x1F, 0x9F, 0x8F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xFC, 0x7E, 0x3F, 0x7E, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3E, 0xFC,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFE, 0xFE, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xF3,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x3E, 0x3E, 0x7F, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x30, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFE, 0x7F, 0xE0, 0xFF, 0x01, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x7C, 0x1E, 0x78, 0x1F, 0xE0, 0xE7, 0x83, 0xFF,
  0x0E, 0x70, 0x7F, 0xF0, 0xEF, 0x07, 0x8F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xE1, 0xE0,
  0xF0, 0xFE, 0x1E, 0x0F, 0x0F, 0xE1, 0xE0, 0xE0, 0xEE, 0x1E, 0x1E, 0x0E,
  0xE1, 0xE1, 0xE1, 0xEF, 0x1F, 0x1E, 0x1C, 0xF1, 0xFF, 0xF3, 0xCF, 0x0F,
  0xFF, 0xF8, 0xF0, 0x7E, 0x7F, 0x07, 0x83, 0xC3, 0xE0, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x20, 0x00, 0xFF, 0xBE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF7, 0xC0, 0x03,
  0xF7, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F,
  0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xF7, 0xE0, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03,
  0xF7, 0xF0, 0x3F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF,
  0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x81, 0xFC, 0xFE, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7F, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x7F, 0xFB, 0xE3, 0xEF,
  0xFF, 0x7C, 0x7D, 0xFF, 0xEF, 0x8F, 0xBF, 0xFD, 0xF9, 0xE7, 0xFF, 0x9F,
  0x7C, 0xFF, 0xF3, 0xEF, 0x9F, 0xFE, 0x7D, 0xE3, 0xFF, 0xC7, 0xFC, 0x7F,
  0xF8, 0xFF, 0x8F, 0xFF, 0x1F, 0xF1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F,
  0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF,
  0xC1, 0xF0, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xDF,
  0x1F, 0xFE, 0xFC, 0xFF, 0xF3, 0xE7, 0xFF, 0x9F, 0xBF, 0xFC, 0x7D, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x7E, 0x7C,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C,
  0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x81, 0xFF,
  0xE0, 0x7C, 0x0F, 0xFF, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xC1,
  0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8,
  0x7E, 0x7E, 0x3F, 0xC3, 0xE1, 0xF1, 0xFF, 0x1F, 0x0F, 0x8F, 0xF9, 0xF8,
  0x7C, 0x7F, 0xCF, 0xC3, 0xF3, 0xDE, 0x7E, 0x1F, 0xBE, 0xF3, 0xE0, 0x7D,
  0xF7, 0xDF, 0x03, 0xEF, 0xBE, 0xF8, 0x1F, 0x79, 0xF7, 0xC0, 0xFB, 0xC7,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8,
  0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F,
  0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0x07, 0xE3,
  0xF8, 0x3F, 0x9F, 0x81, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x9E, 0x1E, 0x78, 0x7B,
  0xE1, 0xFF, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xF7, 0xF3, 0xF1, 0xF9, 0xF0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7,
  0xF1, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFD, 0xF8, 0x7C, 0xFC, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xDF,
  0xE3, 0xE3, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF0, 0xF9, 0xF0, 0x7E, 0xF8, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0xF8,
  0x3F, 0x7E, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xE7, 0xC7,
  0xFB, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x7E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x0F, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x1F, 0x3E, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x0E, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xCF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0x87, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xEF, 0xC1, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x18, 0x1F, 0x87,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xEF, 0xF7, 0xF3, 0xE0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xEF, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x3E, 0x3F, 0xFF,
  0x3F, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE3, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x07,
  0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F,
  0x07, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC,
  0x3F, 0x07, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F,
  0xFC, 0x3F, 0x07, 0xFF, 0x0F, 0xC1, 0xF0, 0xF8, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0xF8, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xC7, 0xE7, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xCF, 0x8F,
  0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x1F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x3E, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0xFC, 0x1F, 0xFE, 0x0F, 0xBF, 0x0F, 0xDF,
  0x87, 0xE7, 0xC3, 0xF3, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E,
  0x1F, 0x3E, 0x0F, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFE,
  0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x7E, 0x3E, 0xFF, 0x7C, 0x3F, 0xFF,
  0x7C, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xE7,
  0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x1F,
  0xBF, 0x1F, 0x9F, 0x8F, 0xC7, 0xEF, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xBF,
  0x1F, 0x9F, 0x8F, 0xC7, 0xEF, 0xC3, 0xF7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF,
  0x83, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x80, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE0,
  0xFC, 0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x1C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x7C, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x1C, 0x04, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x3D, 0xFF,
  0x07, 0xBF, 0xF1, 0xFF, 0xFF, 0xFD, 0xF1, 0xFF, 0xBC, 0x1F, 0xE7, 0x83,
  0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 11, 11, 13, 1, -31 },
  { 43, 18, 29, 22, 2, -29 },
  { 109, 17, 37, 21, 2, -33 },
  { 188, 22, 29, 26, 2, -29 },
  { 268, 22, 29, 24, 1, -29 },
  { 348, 5, 11, 7, 1, -31 },
  { 355, 10, 41, 13, 2, -32 },
  { 407, 10, 41, 13, 1, -32 },
  { 459, 17, 18, 19, 1, -29 },
  { 498, 17, 21, 20, 1, -24 },
  { 543, 7, 12, 10, 1, -5 },
  { 554, 10, 5, 15, 2, -15 },
  { 561, 6, 6, 12, 3, -6 },
  { 566, 13, 32, 14, 0, -29 },
  { 618, 17, 29, 21, 2, -29 },
  { 680, 11, 29, 21, 3, -29 },
  { 720, 18, 29, 21, 1, -29 },
  { 786, 18, 29, 21, 1, -29 },
  { 852, 18, 29, 21, 1, -29 },
  { 918, 17, 29, 21, 2, -29 },
  { 980, 17, 29, 21, 2, -29 },
  { 1042, 18, 29, 21, 1, -29 },
  { 1108, 17, 29, 21, 2, -29 },
  { 1170, 17, 29, 21, 2, -29 },
  { 1232, 6, 22, 11, 3, -22 },
  { 1249, 8, 29, 10, 1, -22 },
  { 1278, 15, 19, 18, 1, -22 },
  { 1314, 15, 14, 21, 3, -20 },
  { 1341, 15, 19, 19, 2, -22 },
  { 1377, 16, 29, 18, 1, -29 },
  { 1435, 28, 37, 31, 2, -28 },
  { 1565, 24, 29, 24, 0, -29 },
  { 1652, 19, 29, 23, 2, -29 },
  { 1721, 20, 29, 23, 2, -29 },
  { 1794, 19, 29, 23, 2, -29 },
  { 1863, 17, 29, 20, 2, -29 },
  { 1925, 16, 29, 20, 2, -29 },
  { 1983, 20, 29, 24, 2, -29 },
  { 2056, 21, 29, 25, 2, -29 },
  { 2133, 5, 29, 11, 3, -29 },
  { 2152, 17, 29, 20, 1, -29 },
  { 2214, 21, 29, 23, 2, -29 },
  { 2291, 17, 29, 20, 2, -29 },
  { 2353, 27, 29, 31, 2, -29 },
  { 2451, 21, 29, 25, 2, -29 },
  { 2528, 21, 29, 25, 2, -29 },
  { 2605, 20, 29, 23, 2, -29 },
  { 2678, 21, 34, 25, 2, -29 },
  { 2768, 20, 29, 23, 2, -29 },
  { 2841, 20, 29, 22, 1, -29 },
  { 2914, 20, 29, 22, 1, -29 },
  { 2987, 19, 29, 23, 2, -29 },
  { 3056, 23, 29, 24, 0, -29 },
  { 3140, 29, 29, 31, 1, -29 },
  { 3246, 21, 29, 23, 1, -29 },
  { 3323, 22, 29, 22, 0, -29 },
  { 3403, 19, 29, 22, 1, -29 },
  { 3472, 8, 41, 11, 2, -34 },
  { 3513, 16, 32, 16, 0, -29 },
  { 3577, 7, 41, 11, 1, -34 },
  { 3613, 14, 15, 16, 1, -29 },
  { 3640, 16, 5, 16, 0, 0 },
  { 3650, 10, 6, 14, 1, -31 },
  { 3658, 17, 22, 19, 1, -22 },
  { 3705, 17, 31, 20, 2, -31 },
  { 3771, 17, 22, 19, 1, -22 },
  { 3818, 17, 31, 20, 1, -31 },
  { 3884, 16, 22, 20, 2, -22 },
  { 3928, 12, 31, 13, 1, -31 },
  { 3975, 18, 30, 21, 1, -22 },
  { 4043, 16, 31, 20, 2, -31 },
  { 4105, 6, 31, 10, 2, -31 },
  { 4129, 9, 39, 10, -1, -31 },
  { 4173, 18, 31, 20, 2, -31 },
  { 4243, 6, 31, 10, 2, -31 },
  { 4267, 26, 22, 30, 2, -22 },
  { 4339, 16, 22, 20, 2, -22 },
  { 4383, 18, 22, 20, 1, -22 },
  { 4433, 17, 30, 20, 2, -22 },
  { 4497, 17, 30, 20, 1, -22 },
  { 4561, 11, 22, 14, 2, -22 },
  { 4592, 16, 22, 19, 1, -22 },
  { 4636, 12, 27, 13, 0, -27 },
  { 4677, 16, 22, 20, 2, -22 },
  { 4721, 17, 22, 18, 1, -22 },
  { 4768, 24, 22, 26, 1, -22 },
  { 4834, 17, 22, 19, 1, -22 },
  { 4881, 18, 30, 18, 0, -22 },
  { 4949, 15, 22, 19, 2, -22 },
  { 4991, 10, 39, 12, 1, -32 },
  { 5040, 4, 34, 10, 3, -29 },
  { 5057, 10, 39, 12, 1, -32 },
  { 5106, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_Bold41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_BOLD41PT7B_H_
