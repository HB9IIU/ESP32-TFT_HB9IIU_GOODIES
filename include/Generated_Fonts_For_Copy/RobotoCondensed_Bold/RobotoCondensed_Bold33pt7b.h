#ifndef _ROBOTOCONDENSED_BOLD33PT7B_H_
#define _ROBOTOCONDENSED_BOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x79, 0xC0, 0x00,
  0x1D, 0xFF, 0xFD, 0xC0, 0xE7, 0xF3, 0xF9, 0xFC, 0xEE, 0x77, 0x3B, 0x9D,
  0xCE, 0xE7, 0x00, 0x03, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73,
  0x80, 0xE7, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0x8C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x01, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0x9F,
  0x1F, 0x7C, 0x7D, 0xF0, 0xF7, 0xC3, 0xCF, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x87, 0xDE, 0x0F, 0x78, 0x3D,
  0xF1, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0x9C, 0x30, 0xE7,
  0x1C, 0x39, 0xC6, 0x0E, 0x73, 0x83, 0x9D, 0xC0, 0xFF, 0x70, 0x1F, 0xB8,
  0x03, 0xCE, 0x00, 0x07, 0x00, 0x01, 0x9E, 0x00, 0xEF, 0xE0, 0x37, 0xF8,
  0x1D, 0xCE, 0x0E, 0x71, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x08,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x3C, 0x3F, 0xCF, 0x1F,
  0xFB, 0xC7, 0xBE, 0xF3, 0xE7, 0xFC, 0xF8, 0xFE, 0x3E, 0x3F, 0x8F, 0x87,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFC, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0x02, 0x06, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0x06, 0x02, 0x40,
  0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0x40, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x07, 0x38, 0xCF, 0xFF, 0x9F, 0xFF, 0x87, 0xF0, 0x07,
  0xC0, 0x1D, 0xC0, 0x7B, 0xC0, 0xE3, 0x81, 0x87, 0x81, 0x04, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x7B, 0xDE, 0xF7, 0xBD, 0xDE, 0xE3, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x01, 0xC0, 0x70, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07,
  0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F,
  0x78, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFE, 0x3C, 0xFF,
  0xE7, 0xFE, 0x1F, 0xF0, 0x3E, 0x00, 0x01, 0x87, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x07, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F, 0xE1, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0xFE,
  0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x1E, 0xF8, 0x3D,
  0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xF3, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0x1F, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFE, 0xF8, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7B, 0xE1, 0xEF,
  0x8F, 0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x8F, 0x7C, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xF3, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFF, 0x7C,
  0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0x1F, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7C,
  0xF9, 0xE1, 0xF7, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDF,
  0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xDE, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x07, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0x39, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x3C, 0xF3, 0x9E,
  0x79, 0xCF, 0x18, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xF7, 0xFC,
  0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF0, 0x1F,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8,
  0x0F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0xFF, 0x3F,
  0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFD, 0xFF, 0xEF, 0x8F, 0x7C, 0x7B, 0xC3, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x07, 0x80, 0xE0, 0x07,
  0x83, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x1C, 0x0F, 0x0E, 0x38, 0x7F, 0x8C,
  0xE1, 0xFF, 0x1D, 0xC3, 0x8E, 0x3B, 0x8F, 0x1C, 0x77, 0x1C, 0x78, 0xFE,
  0x38, 0xF1, 0xF8, 0xF1, 0xC3, 0xF1, 0xE3, 0x87, 0xE3, 0xC7, 0x0F, 0xC7,
  0x8E, 0x1B, 0x8F, 0x1C, 0x73, 0x9E, 0x78, 0xE7, 0x1F, 0xFF, 0x8E, 0x3F,
  0x7E, 0x1C, 0x3C, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x04, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x00, 0xF3,
  0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF8, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDE, 0x00, 0xF8, 0xFF, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1E, 0xF8,
  0x7D, 0xF1, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xBE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x07, 0x9F, 0x87, 0xC7, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF,
  0xCF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E,
  0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0,
  0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x7F, 0xBC, 0x7B, 0xFD, 0xE3, 0xDF, 0xEF,
  0x1E, 0xFF, 0x7D, 0xE7, 0xF9, 0xEF, 0x3F, 0xCF, 0x79, 0xFE, 0x7B, 0x8F,
  0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F,
  0x87, 0xF8, 0x7C, 0x3F, 0xC1, 0xC1, 0xE0, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x8F, 0xF7, 0x8F, 0xF7, 0xCF, 0xF3, 0xCF, 0xF3, 0xEF, 0xF1, 0xEF, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3,
  0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x87, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8,
  0x00, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0,
  0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x3F, 0xF0,
  0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x1F,
  0x87, 0x9E, 0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE, 0x7C, 0xF9, 0xFC,
  0xF0, 0xF7, 0xB9, 0xE1, 0xEF, 0x7B, 0xC3, 0xDE, 0xFF, 0x87, 0xBD, 0xFF,
  0x0F, 0xF3, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF8, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x0F, 0x3C,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF8, 0x77, 0x0E, 0xE3, 0xDE, 0x71, 0xCE, 0x3B, 0xC7,
  0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x78, 0xFB, 0xE3,
  0xE0, 0x0F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8,
  0xFB, 0xFF, 0xE7, 0xFF, 0x9F, 0xDE, 0x1E, 0x78, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xC7, 0xFF,
  0x3F, 0xFD, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xF7,
  0xC0, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0x8F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xF7, 0x87, 0xBF, 0xFC,
  0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x7C, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0x7C, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7B, 0xE1, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x11,
  0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x07, 0xE0, 0x07, 0x8F, 0xC7, 0xE7, 0xF3,
  0xE1, 0xE0, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xE7, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x0F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0x7D, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0x7C, 0x01, 0xF0, 0x07, 0xC4, 0x1F, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xC7, 0xFF, 0x3F, 0xFD,
  0xFF, 0xEF, 0x0F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF8, 0x67,
  0xBF, 0xE7, 0x00, 0x1E, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0x0C, 0x1E, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0xFB, 0xC7, 0xCF, 0x3F, 0x3C, 0xF8, 0xF7, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3C, 0xF8, 0xF3, 0xE3, 0xC7, 0xCF,
  0x1F, 0x3C, 0x3E, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xC3, 0xC7, 0xFF, 0x7F, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x8F, 0x8F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3,
  0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1,
  0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F,
  0xF0, 0xF0, 0xF8, 0xF3, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0x78,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x1F, 0x7C, 0x7D, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x0F,
  0xC0, 0xF3, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFC, 0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x3C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0xFC,
  0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xE1, 0xFF, 0x8F,
  0xFE, 0xFD, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0xE3, 0xF1, 0xF8, 0x7C, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3E, 0xF8,
  0x78, 0x7D, 0xE1, 0xF7, 0xC7, 0xDF, 0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xEF,
  0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7,
  0xC7, 0xF8, 0xF9, 0xF7, 0x9F, 0x3C, 0xF7, 0xE7, 0x9E, 0xFE, 0xF3, 0xDD,
  0xDE, 0x7B, 0xBB, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0xF8,
  0xFB, 0xE3, 0xE7, 0xDF, 0x1F, 0x78, 0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0xC7,
  0xDF, 0x3E, 0x3E, 0xF8, 0xF8, 0xF8, 0x3D, 0xE1, 0xF7, 0xC7, 0xDF, 0x1E,
  0x3C, 0x78, 0xF3, 0xE3, 0xEF, 0x8F, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x02, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF8, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1F, 0x0F, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0xE0,
  0xF0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x1F, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xE0, 0x40, 0x3C, 0x00, 0xFE, 0x3F, 0xFE, 0x7F,
  0xFF, 0xEE, 0x3F, 0xDC, 0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 9, 9, 11, 1, -25 },
  { 27, 15, 23, 17, 1, -23 },
  { 71, 14, 29, 17, 1, -26 },
  { 122, 18, 23, 21, 2, -23 },
  { 174, 18, 23, 19, 1, -23 },
  { 226, 3, 9, 5, 1, -25 },
  { 230, 8, 33, 11, 2, -26 },
  { 263, 8, 33, 11, 1, -26 },
  { 296, 15, 14, 15, 0, -23 },
  { 323, 14, 17, 16, 1, -19 },
  { 353, 5, 10, 8, 1, -4 },
  { 360, 8, 4, 12, 2, -12 },
  { 364, 5, 5, 10, 2, -5 },
  { 368, 10, 25, 11, 0, -23 },
  { 400, 13, 23, 17, 2, -23 },
  { 438, 9, 23, 17, 3, -23 },
  { 464, 14, 23, 17, 1, -23 },
  { 505, 14, 23, 17, 1, -23 },
  { 546, 15, 23, 17, 1, -23 },
  { 590, 13, 23, 17, 2, -23 },
  { 628, 14, 23, 17, 2, -23 },
  { 669, 14, 23, 17, 1, -23 },
  { 710, 13, 23, 17, 2, -23 },
  { 748, 14, 23, 17, 1, -23 },
  { 789, 5, 18, 9, 2, -18 },
  { 801, 6, 24, 8, 1, -18 },
  { 819, 12, 16, 15, 1, -18 },
  { 843, 12, 11, 17, 2, -16 },
  { 860, 12, 16, 15, 2, -18 },
  { 884, 13, 23, 15, 1, -23 },
  { 922, 23, 30, 25, 1, -23 },
  { 1009, 19, 23, 20, 0, -23 },
  { 1064, 15, 23, 19, 2, -23 },
  { 1108, 17, 23, 19, 1, -23 },
  { 1157, 15, 23, 19, 2, -23 },
  { 1201, 13, 23, 16, 2, -23 },
  { 1239, 13, 23, 16, 2, -23 },
  { 1277, 16, 23, 19, 2, -23 },
  { 1323, 16, 23, 20, 2, -23 },
  { 1369, 5, 23, 9, 2, -23 },
  { 1384, 13, 23, 16, 1, -23 },
  { 1422, 16, 23, 18, 2, -23 },
  { 1468, 13, 23, 16, 2, -23 },
  { 1506, 21, 23, 25, 2, -23 },
  { 1567, 16, 23, 20, 2, -23 },
  { 1613, 16, 23, 20, 2, -23 },
  { 1659, 16, 23, 19, 2, -23 },
  { 1705, 17, 27, 20, 1, -23 },
  { 1763, 16, 23, 18, 2, -23 },
  { 1809, 16, 23, 18, 1, -23 },
  { 1855, 16, 23, 18, 1, -23 },
  { 1901, 15, 23, 19, 2, -23 },
  { 1945, 19, 23, 19, 0, -23 },
  { 2000, 23, 23, 25, 1, -23 },
  { 2067, 17, 23, 18, 1, -23 },
  { 2116, 18, 23, 18, 0, -23 },
  { 2168, 15, 23, 18, 1, -23 },
  { 2212, 6, 32, 9, 2, -27 },
  { 2236, 13, 25, 13, 0, -23 },
  { 2277, 6, 32, 9, 1, -27 },
  { 2301, 11, 12, 13, 1, -23 },
  { 2318, 13, 4, 13, 0, 0 },
  { 2325, 8, 5, 11, 1, -25 },
  { 2330, 14, 17, 16, 1, -17 },
  { 2360, 13, 25, 16, 2, -25 },
  { 2401, 13, 17, 15, 1, -17 },
  { 2429, 14, 25, 16, 1, -25 },
  { 2473, 14, 17, 16, 1, -17 },
  { 2503, 9, 25, 11, 1, -25 },
  { 2532, 14, 24, 17, 1, -17 },
  { 2574, 13, 25, 16, 2, -25 },
  { 2615, 5, 24, 8, 2, -24 },
  { 2630, 8, 31, 8, -1, -24 },
  { 2661, 14, 25, 16, 2, -25 },
  { 2705, 4, 25, 8, 2, -25 },
  { 2718, 21, 17, 24, 2, -17 },
  { 2763, 13, 17, 16, 2, -17 },
  { 2791, 14, 17, 16, 1, -17 },
  { 2821, 13, 24, 16, 2, -17 },
  { 2860, 14, 24, 16, 1, -17 },
  { 2902, 8, 17, 11, 2, -17 },
  { 2919, 13, 17, 15, 1, -17 },
  { 2947, 9, 22, 10, 0, -22 },
  { 2972, 13, 17, 16, 2, -17 },
  { 3000, 14, 17, 15, 0, -17 },
  { 3030, 19, 17, 21, 1, -17 },
  { 3071, 14, 17, 15, 1, -17 },
  { 3101, 14, 24, 15, 0, -17 },
  { 3143, 13, 17, 15, 1, -17 },
  { 3171, 8, 32, 10, 1, -26 },
  { 3203, 3, 27, 8, 3, -23 },
  { 3214, 8, 32, 10, 1, -26 },
  { 3246, 15, 7, 18, 2, -13 },
};

const GFXfont RobotoCondensed_Bold33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_BOLD33PT7B_H_
