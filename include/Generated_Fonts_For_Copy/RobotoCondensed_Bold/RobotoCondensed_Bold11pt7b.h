#ifndef _ROBOTOCONDENSED_BOLD11PT7B_H_
#define _ROBOTOCONDENSED_BOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xB6, 0x80, 0x29, 0x5E, 0x63, 0x7D, 0x4A, 0x23, 0x96, 0x96,
  0x1D, 0x2B, 0x71, 0x00, 0xC3, 0x4D, 0x38, 0x39, 0x55, 0x46, 0x31, 0x65,
  0x1C, 0x7F, 0x7D, 0x9F, 0xE0, 0x5A, 0xAA, 0x94, 0x89, 0x32, 0x4B, 0x4A,
  0x00, 0x25, 0x5C, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x58, 0xC0, 0xC0,
  0x24, 0xB4, 0x94, 0x80, 0xEB, 0x99, 0x99, 0xBE, 0x7D, 0xB6, 0xDB, 0x72,
  0xF6, 0x33, 0x11, 0x8F, 0x76, 0xC6, 0x33, 0x0F, 0x6E, 0x19, 0xCE, 0xB5,
  0xFC, 0x63, 0xF8, 0x8E, 0xB1, 0xBE, 0x6C, 0x8F, 0xB9, 0xB6, 0xF8, 0xC6,
  0x23, 0x10, 0x8C, 0xEB, 0xBB, 0xEB, 0xBE, 0x72, 0xF6, 0xB7, 0x8C, 0x4C,
  0xCC, 0x50, 0x17, 0x17, 0xC7, 0x10, 0xF0, 0xF0, 0x8E, 0x3E, 0x80, 0x76,
  0x84, 0x62, 0x10, 0x84, 0x1C, 0x22, 0x5D, 0x55, 0xD5, 0xB5, 0x75, 0x5E,
  0x40, 0x3C, 0x30, 0xC3, 0x9A, 0x69, 0xF4, 0xF1, 0xF4, 0xA7, 0x2F, 0x4E,
  0x7E, 0x39, 0xB4, 0xF0, 0xC1, 0x36, 0xCE, 0xE4, 0xA7, 0x39, 0xCE, 0x5C,
  0xF8, 0x88, 0xF8, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x76, 0xE7, 0x0B, 0xCF,
  0x6E, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0xFF, 0x18, 0xC6, 0x31, 0x8F, 0x6E,
  0x9D, 0xA9, 0xCE, 0x5A, 0x53, 0x88, 0x88, 0x88, 0x8F, 0xC7, 0x9F, 0x3F,
  0x7B, 0xF6, 0xED, 0xDB, 0x8E, 0x73, 0xDA, 0xDE, 0x73, 0x39, 0xB4, 0xF1,
  0xC5, 0x16, 0xCE, 0xF4, 0xE7, 0x3F, 0x42, 0x10, 0x39, 0xB4, 0xF1, 0xC5,
  0x36, 0xCE, 0x04, 0xF4, 0xE7, 0x2F, 0x5A, 0x53, 0x79, 0x24, 0x1C, 0x1B,
  0x24, 0x9E, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x9C, 0xE7, 0x39, 0xCE,
  0x7E, 0xCD, 0x34, 0xDA, 0x78, 0xE3, 0x0C, 0xDB, 0x5B, 0x5B, 0x5A, 0x5E,
  0x76, 0x76, 0x26, 0xCD, 0xA7, 0x8C, 0x31, 0xE6, 0xB3, 0xCD, 0x27, 0x8C,
  0x30, 0xC3, 0x0C, 0xF8, 0x46, 0x62, 0x31, 0x1F, 0xEA, 0xAA, 0xAC, 0xC4,
  0x46, 0x62, 0x33, 0x10, 0xD5, 0x55, 0x5C, 0x66, 0x7D, 0xF0, 0x4C, 0x72,
  0xDF, 0xBD, 0xBC, 0x88, 0x8E, 0xB9, 0x9B, 0xE0, 0x72, 0xF1, 0x85, 0xB8,
  0x18, 0xC6, 0xF5, 0xEF, 0x6B, 0x78, 0x72, 0xFF, 0x84, 0x38, 0x6D, 0x74,
  0x92, 0x40, 0x6A, 0xF7, 0xB5, 0xBD, 0x6E, 0x88, 0x8E, 0xBB, 0xBB, 0xB0,
  0xDF, 0x80, 0x51, 0x55, 0x5C, 0x88, 0x8B, 0xEC, 0xEA, 0xB0, 0xFF, 0x80,
  0xED, 0x6E, 0xDD, 0xBB, 0x76, 0xC0, 0xEB, 0xBB, 0xBB, 0x72, 0xF3, 0x95,
  0xB8, 0xEB, 0x99, 0xBE, 0x88, 0x7E, 0xF7, 0xB5, 0xBC, 0x63, 0xFA, 0xA0,
  0x76, 0xD8, 0x6D, 0xB8, 0x5D, 0x24, 0x98, 0xBB, 0xBB, 0xBF, 0xDA, 0x94,
  0xA7, 0x10, 0xD7, 0xA9, 0xF3, 0x66, 0xCD, 0x80, 0xDB, 0x9C, 0xE5, 0x6C,
  0xDA, 0x94, 0xE6, 0x11, 0x88, 0xF8, 0x8C, 0xC4, 0x7C, 0x2D, 0x25, 0x92,
  0x4C, 0x80, 0xFF, 0x80, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xDD, 0x80,
};

const GFXglyph RobotoCondensed_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 0, -8 },
  { 4, 5, 8, 6, 0, -8 },
  { 9, 5, 10, 6, 0, -9 },
  { 16, 6, 8, 7, 1, -8 },
  { 22, 6, 8, 6, 0, -8 },
  { 28, 1, 3, 2, 0, -8 },
  { 29, 2, 11, 4, 1, -9 },
  { 32, 3, 11, 4, 0, -9 },
  { 37, 5, 5, 5, 0, -8 },
  { 41, 5, 5, 5, 0, -6 },
  { 45, 2, 3, 3, 0, -1 },
  { 46, 2, 1, 4, 1, -4 },
  { 47, 1, 2, 3, 1, -2 },
  { 48, 3, 9, 4, 0, -8 },
  { 52, 4, 8, 6, 1, -8 },
  { 56, 3, 8, 6, 1, -8 },
  { 59, 5, 8, 6, 0, -8 },
  { 64, 5, 8, 6, 0, -8 },
  { 69, 5, 8, 6, 0, -8 },
  { 74, 4, 8, 6, 1, -8 },
  { 78, 4, 8, 6, 1, -8 },
  { 82, 5, 8, 6, 0, -8 },
  { 87, 4, 8, 6, 1, -8 },
  { 91, 5, 8, 6, 0, -8 },
  { 96, 1, 6, 3, 1, -6 },
  { 97, 2, 8, 3, 0, -6 },
  { 99, 4, 5, 5, 0, -6 },
  { 102, 4, 3, 6, 1, -5 },
  { 104, 4, 5, 5, 1, -6 },
  { 107, 5, 8, 5, 0, -8 },
  { 112, 8, 10, 8, 0, -8 },
  { 122, 6, 8, 7, 0, -8 },
  { 128, 5, 8, 6, 1, -8 },
  { 133, 6, 8, 6, 0, -8 },
  { 139, 5, 8, 6, 1, -8 },
  { 144, 4, 8, 5, 1, -8 },
  { 148, 4, 8, 5, 1, -8 },
  { 152, 5, 8, 6, 1, -8 },
  { 157, 5, 8, 7, 1, -8 },
  { 162, 1, 8, 3, 1, -8 },
  { 163, 5, 8, 5, 0, -8 },
  { 168, 5, 8, 6, 1, -8 },
  { 173, 4, 8, 5, 1, -8 },
  { 177, 7, 8, 8, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 6, 8, 7, 0, -8 },
  { 195, 5, 8, 6, 1, -8 },
  { 200, 6, 9, 7, 0, -8 },
  { 207, 5, 8, 6, 1, -8 },
  { 212, 6, 8, 6, 0, -8 },
  { 218, 6, 8, 6, 0, -8 },
  { 224, 5, 8, 6, 1, -8 },
  { 229, 6, 8, 6, 0, -8 },
  { 235, 8, 8, 8, 0, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 5, 8, 6, 0, -8 },
  { 260, 2, 11, 3, 1, -9 },
  { 263, 4, 9, 4, 0, -8 },
  { 268, 2, 11, 3, 0, -9 },
  { 271, 4, 4, 4, 0, -8 },
  { 273, 4, 1, 4, 0, 0 },
  { 274, 3, 2, 4, 0, -9 },
  { 275, 5, 6, 5, 0, -6 },
  { 279, 4, 9, 5, 1, -9 },
  { 284, 5, 6, 5, 0, -6 },
  { 288, 5, 9, 5, 0, -9 },
  { 294, 5, 6, 5, 0, -6 },
  { 298, 3, 9, 4, 0, -9 },
  { 302, 5, 8, 6, 0, -6 },
  { 307, 4, 9, 5, 1, -9 },
  { 312, 1, 9, 3, 1, -9 },
  { 314, 2, 11, 3, 0, -9 },
  { 317, 4, 9, 5, 1, -9 },
  { 322, 1, 9, 3, 1, -9 },
  { 324, 7, 6, 8, 1, -6 },
  { 330, 4, 6, 5, 1, -6 },
  { 333, 5, 6, 5, 0, -6 },
  { 337, 4, 8, 5, 1, -6 },
  { 341, 5, 8, 5, 0, -6 },
  { 346, 2, 6, 4, 1, -6 },
  { 348, 5, 6, 5, 0, -6 },
  { 352, 3, 7, 3, 0, -7 },
  { 355, 4, 6, 5, 1, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 7, 6, 7, 0, -6 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 5, 8, 5, 0, -6 },
  { 377, 5, 6, 5, 0, -6 },
  { 381, 3, 11, 3, 0, -9 },
  { 386, 1, 9, 3, 1, -8 },
  { 388, 3, 11, 3, 0, -9 },
  { 393, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Bold11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_BOLD11PT7B_H_
