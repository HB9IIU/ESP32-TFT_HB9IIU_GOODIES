#ifndef _ROBOTOCONDENSED_BOLD44PT7B_H_
#define _ROBOTOCONDENSED_BOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7,
  0x80, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0x01, 0xE7, 0x80, 0x1C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7,
  0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80,
  0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xF1, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF7, 0xF1, 0xFD, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xF0, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF1, 0xC0, 0xF0, 0xF3, 0xC0, 0xF0, 0xF3,
  0x80, 0xF9, 0xF7, 0x80, 0x7F, 0xEF, 0x00, 0x7F, 0xEF, 0x00, 0x3F, 0xDE,
  0x00, 0x1F, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x7B,
  0xFC, 0x00, 0x73, 0xFE, 0x00, 0xF7, 0xFF, 0x00, 0xE7, 0x8F, 0x01, 0xEF,
  0x8F, 0x03, 0xCF, 0x0F, 0x03, 0xCF, 0x0F, 0x07, 0x8F, 0x0F, 0x07, 0x8F,
  0x8F, 0x0F, 0x07, 0x8F, 0x02, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xF3, 0xE7, 0xE7,
  0xEF, 0xCF, 0xCF, 0xFF, 0x1F, 0x8F, 0xFE, 0x3F, 0x0F, 0xFC, 0x7E, 0x0F,
  0xF0, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0x81, 0xFC, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xE0, 0x00, 0x80, 0x60, 0x3C, 0x1F, 0x0F,
  0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x06, 0x00, 0x80, 0x40, 0x0C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0xC0, 0x30, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xC3, 0xC1, 0xBE, 0x78, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x1E, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x03, 0x81, 0xC0,
  0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0x83, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x31, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1,
  0xF9, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0x9F, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x8F, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01, 0xFB, 0xF0,
  0x3F, 0x7E, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF8,
  0x0F, 0x9F, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3E, 0x1F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xEF,
  0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xF0, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0xC7, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xF0,
  0x3E, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0xFE,
  0xFE, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xE3, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xF9, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF, 0x83,
  0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xF1, 0xF9, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xC7,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xCF, 0xE7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x7F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x07, 0xCF, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x31, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0xEF, 0xFF, 0xFF, 0xFE, 0x78, 0x0C, 0x3F, 0x3F, 0x7F,
  0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0x78, 0x10, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7F, 0xF0, 0xFF, 0x81, 0xFC,
  0x03, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x0F, 0x81, 0xE3, 0xC0, 0xFF, 0x87, 0x9F, 0x07, 0xFF, 0x0E, 0x78, 0x3F,
  0xFC, 0x3D, 0xE0, 0xF0, 0xF0, 0xFF, 0x87, 0xC7, 0xC3, 0xFC, 0x1E, 0x1F,
  0x0F, 0xF0, 0xF8, 0x78, 0x3F, 0xC3, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0x83,
  0xFC, 0x3C, 0x1E, 0x0F, 0xF0, 0xF0, 0x78, 0x3F, 0xC3, 0xC1, 0xE0, 0xFF,
  0x0F, 0x07, 0x83, 0xBC, 0x3C, 0x1E, 0x1E, 0xF0, 0xF0, 0xF8, 0x7B, 0xC3,
  0xE7, 0xE3, 0xCF, 0x0F, 0xFF, 0xDF, 0x3C, 0x1F, 0xFF, 0xF8, 0xF8, 0x7F,
  0x3F, 0xC1, 0xE0, 0x78, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x06, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFC,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xEF, 0xC1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0,
  0x3F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7F, 0x03, 0xF9, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC7, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC3,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x1F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0xFC, 0xFF,
  0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xCF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0xFC, 0x07, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0x03, 0xF8, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F,
  0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0x80, 0xFE, 0x7F, 0x03, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x8F,
  0xC0, 0xFE, 0x3F, 0x03, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0,
  0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFB, 0xE0, 0xFB, 0xFF, 0xBE, 0x0F, 0xBF, 0xFB, 0xF0, 0xFB,
  0xFF, 0x9F, 0x1F, 0x3F, 0xF9, 0xF1, 0xF3, 0xFF, 0x9F, 0x9F, 0x3F, 0xFD,
  0xFB, 0xF3, 0xFF, 0xCF, 0xBE, 0x3F, 0xFC, 0xFB, 0xE3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xFC, 0x7F, 0xC3, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x7F, 0xC3, 0xFF,
  0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xF7, 0xE7,
  0xFF, 0xBF, 0x3F, 0xFC, 0xFD, 0xFF, 0xE7, 0xEF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF9, 0xFF,
  0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80,
  0x3F, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF9, 0xFF,
  0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80,
  0x3F, 0x3F, 0x00, 0xFE, 0x7F, 0x03, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF1, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E,
  0x03, 0xF3, 0xFC, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x01,
  0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8,
  0x0F, 0x80, 0xFF, 0xF8, 0x3F, 0x83, 0xFB, 0xF0, 0x7F, 0x07, 0xE7, 0xE0,
  0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x0F,
  0xF8, 0x7E, 0x3F, 0x1F, 0xF0, 0xFC, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0x7F,
  0xC7, 0xE1, 0xF8, 0xFF, 0x8F, 0xC3, 0xF1, 0xFF, 0x9F, 0x87, 0xE7, 0xDF,
  0x3F, 0x07, 0xCF, 0xBE, 0x7C, 0x0F, 0xDF, 0x7D, 0xF8, 0x1F, 0xBE, 0xFB,
  0xF0, 0x3F, 0x7C, 0xF7, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0xFE,
  0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0,
  0x7E, 0x07, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80,
  0x7F, 0x80, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x1E, 0xF8, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3,
  0xE7, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x83, 0xFF, 0xC7, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF9, 0xFE, 0xFC, 0x3E, 0x7E, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xCF, 0xC3, 0xF7, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xF7, 0xF8, 0xFC, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x3F,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8, 0xFF,
  0x7E, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xFD,
  0xF8, 0x3F, 0xBF, 0x8F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xBF, 0x07, 0xC7, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x02, 0x3F, 0xC1, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC3, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE7, 0xE1, 0xFE, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xEF, 0xC1, 0xF9, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE1, 0x01, 0xFC, 0x70, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x1F, 0xBF, 0xCF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x7D, 0xFF, 0xFF, 0xF7, 0xC7, 0x00,
  0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x0F, 0x87,
  0xE1, 0xFC, 0x7F, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0x7E, 0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0xFE, 0x3F,
  0x1F, 0x87, 0xE7, 0xF0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xCF, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF9, 0xF8,
  0x3F, 0x3F, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7C,
  0x1F, 0x8F, 0xDF, 0xE3, 0xFC, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x7C, 0x7E, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x03, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0xFC, 0xFC, 0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0x7F, 0x8F, 0xCF, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xDF, 0x83, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xBF, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xE0,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFB, 0xF0, 0xF8, 0xFC, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7E, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x1E, 0x0F, 0xFF,
  0x0F, 0x83, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F,
  0x9F, 0x1F, 0xC7, 0xE7, 0xE7, 0xF9, 0xF9, 0xF9, 0xFE, 0x7E, 0x3E, 0x7F,
  0x9F, 0x0F, 0xBF, 0xE7, 0xC3, 0xEF, 0xFD, 0xF0, 0xFB, 0xDF, 0xFC, 0x3F,
  0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0xFE,
  0x1F, 0xDF, 0x87, 0xE7, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0xBF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF1, 0xFC, 0xFE, 0x7E, 0x1F, 0xBF, 0x87,
  0xFF, 0xC0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x01, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x0E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3E, 0x0F, 0xC3,
  0xF8, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC0,
  0x70, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF,
  0x1F, 0x7F, 0xF9, 0xF7, 0xCF, 0xFF, 0xF8, 0x7F, 0xEF, 0x83, 0xFE, 0xF8,
  0x1F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 31, 11, 3, -31 },
  { 25, 12, 12, 14, 1, -33 },
  { 43, 20, 31, 23, 2, -31 },
  { 121, 18, 40, 22, 2, -36 },
  { 211, 24, 31, 28, 2, -31 },
  { 304, 23, 31, 25, 2, -31 },
  { 394, 5, 12, 7, 1, -33 },
  { 402, 10, 45, 14, 3, -35 },
  { 459, 11, 45, 14, 1, -35 },
  { 521, 19, 19, 20, 1, -31 },
  { 567, 18, 23, 21, 1, -26 },
  { 619, 7, 13, 11, 1, -5 },
  { 631, 10, 5, 16, 3, -16 },
  { 638, 7, 7, 13, 3, -7 },
  { 645, 14, 34, 15, 0, -31 },
  { 705, 18, 31, 22, 2, -31 },
  { 775, 12, 31, 22, 3, -31 },
  { 822, 18, 31, 22, 2, -31 },
  { 892, 19, 31, 22, 1, -31 },
  { 966, 20, 31, 22, 1, -31 },
  { 1044, 18, 31, 22, 2, -31 },
  { 1114, 19, 31, 22, 2, -31 },
  { 1188, 19, 31, 22, 1, -31 },
  { 1262, 18, 31, 22, 2, -31 },
  { 1332, 18, 31, 22, 2, -31 },
  { 1402, 7, 25, 12, 3, -25 },
  { 1424, 8, 33, 11, 1, -25 },
  { 1457, 16, 21, 20, 1, -24 },
  { 1499, 16, 14, 22, 3, -21 },
  { 1527, 15, 21, 20, 3, -24 },
  { 1567, 17, 31, 20, 1, -31 },
  { 1633, 30, 40, 34, 2, -30 },
  { 1783, 26, 31, 26, 0, -31 },
  { 1884, 20, 31, 25, 3, -31 },
  { 1962, 22, 31, 25, 2, -31 },
  { 2048, 20, 31, 25, 3, -31 },
  { 2126, 17, 31, 22, 3, -31 },
  { 2192, 17, 31, 21, 3, -31 },
  { 2258, 22, 31, 26, 2, -31 },
  { 2344, 21, 31, 27, 3, -31 },
  { 2426, 6, 31, 12, 3, -31 },
  { 2450, 18, 31, 22, 1, -31 },
  { 2520, 22, 31, 24, 3, -31 },
  { 2606, 17, 31, 21, 3, -31 },
  { 2672, 28, 31, 33, 3, -31 },
  { 2781, 21, 31, 27, 3, -31 },
  { 2863, 23, 31, 27, 2, -31 },
  { 2953, 20, 31, 25, 3, -31 },
  { 3031, 23, 37, 27, 2, -31 },
  { 3138, 20, 31, 24, 3, -31 },
  { 3216, 20, 31, 24, 2, -31 },
  { 3294, 22, 31, 24, 1, -31 },
  { 3380, 21, 31, 25, 2, -31 },
  { 3462, 25, 31, 25, 0, -31 },
  { 3559, 31, 31, 33, 1, -31 },
  { 3680, 23, 31, 25, 1, -31 },
  { 3770, 24, 31, 24, 0, -31 },
  { 3863, 20, 31, 23, 2, -31 },
  { 3941, 9, 43, 12, 2, -36 },
  { 3990, 17, 34, 17, 0, -31 },
  { 4063, 8, 43, 12, 1, -36 },
  { 4106, 15, 16, 17, 1, -31 },
  { 4136, 17, 5, 18, 0, 0 },
  { 4147, 11, 7, 15, 1, -33 },
  { 4157, 17, 23, 21, 2, -23 },
  { 4206, 18, 33, 22, 2, -33 },
  { 4281, 17, 23, 20, 2, -23 },
  { 4330, 19, 33, 22, 1, -33 },
  { 4409, 18, 23, 21, 2, -23 },
  { 4461, 13, 33, 14, 1, -33 },
  { 4515, 19, 32, 22, 1, -23 },
  { 4591, 17, 33, 22, 2, -33 },
  { 4662, 7, 32, 11, 2, -32 },
  { 4690, 10, 41, 11, -1, -32 },
  { 4742, 19, 33, 21, 2, -33 },
  { 4821, 6, 33, 11, 3, -33 },
  { 4846, 28, 23, 33, 2, -23 },
  { 4927, 17, 23, 22, 2, -23 },
  { 4976, 18, 23, 22, 2, -23 },
  { 5028, 18, 32, 22, 2, -23 },
  { 5100, 19, 32, 22, 1, -23 },
  { 5176, 12, 23, 15, 2, -23 },
  { 5211, 17, 23, 20, 1, -23 },
  { 5260, 12, 29, 14, 1, -29 },
  { 5304, 18, 23, 22, 2, -23 },
  { 5356, 18, 23, 20, 1, -23 },
  { 5408, 26, 23, 28, 1, -23 },
  { 5483, 18, 23, 20, 1, -23 },
  { 5535, 19, 32, 20, 0, -23 },
  { 5611, 16, 23, 20, 2, -23 },
  { 5657, 11, 42, 13, 1, -34 },
  { 5715, 3, 37, 11, 4, -31 },
  { 5729, 11, 42, 13, 1, -34 },
  { 5787, 20, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_Bold44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_BOLD44PT7B_H_
