#ifndef _ROBOTOCONDENSED_BOLD63PT7B_H_
#define _ROBOTOCONDENSED_BOLD63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xF0, 0x40, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7C, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03,
  0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFE, 0x1F, 0xF8,
  0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F, 0xF7, 0xFC, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x20,
  0x0F, 0xE3, 0xF0, 0x0C, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xF0, 0x7E,
  0x1F, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xE3, 0xE0, 0x0F, 0xC1,
  0xF9, 0xF8, 0x03, 0xF8, 0xFC, 0x7C, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x1F,
  0xFF, 0xCF, 0x80, 0x03, 0xFF, 0xE7, 0xE0, 0x00, 0x7F, 0xF1, 0xF0, 0x00,
  0x0F, 0xF8, 0xFC, 0x00, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x0F,
  0x8F, 0xFF, 0x80, 0x07, 0xE7, 0xFF, 0xE0, 0x01, 0xF3, 0xFF, 0xFC, 0x00,
  0xFC, 0xFC, 0x3F, 0x00, 0x3E, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0x81, 0xF0,
  0x07, 0xC3, 0xE0, 0x7C, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x07,
  0xC0, 0x7E, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x1F, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x38, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xFF,
  0xFE, 0x3F, 0xC3, 0xFD, 0xFF, 0x9F, 0xE3, 0xFE, 0x7F, 0xEF, 0xF1, 0xFE,
  0x1F, 0xF7, 0xF1, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xC0, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0x0F,
  0xF8, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x04, 0x40, 0x00,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0xF8,
  0x06, 0x7C, 0x1F, 0x03, 0xCF, 0xE3, 0xE3, 0xFB, 0xFF, 0xFD, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x70,
  0x07, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x07, 0x80, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F,
  0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFD, 0xFF, 0x00, 0x1F, 0xDF, 0xF0, 0x01,
  0xF9, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x03, 0xF9, 0xFF, 0x00, 0x7F, 0x1F,
  0xF0, 0x07, 0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x81,
  0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0xBF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xF8, 0x1F, 0xF8, 0x1C, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x9F, 0xF8, 0x0F, 0xF7, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFC, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xDF,
  0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x0F, 0xFC, 0x7F, 0xC3, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0,
  0xFF, 0x9F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F,
  0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xCF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFB,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xE7, 0xFE,
  0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x87, 0xFF, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0x7F, 0x81, 0xFF, 0x9F, 0xE0, 0x0F, 0x87, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x1F,
  0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF7,
  0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE3,
  0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x1E, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xFC,
  0x07, 0xC1, 0xF8, 0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x07,
  0xE1, 0xF0, 0x0F, 0xFF, 0xF0, 0x3E, 0x3F, 0x01, 0xFF, 0x7F, 0x03, 0xE3,
  0xF0, 0x1F, 0xC3, 0xF0, 0x3E, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xE7, 0xE0,
  0x3F, 0x03, 0xF0, 0x3E, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x03,
  0xE0, 0x3F, 0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xF7, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x7C, 0x0F, 0xC0, 0x7E, 0x03, 0xF7, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x7C, 0x0F, 0xC0, 0x7E, 0x03, 0xEF, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x7C,
  0x0F, 0xC0, 0x7E, 0x03, 0xE7, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x0F,
  0xC0, 0x7E, 0x07, 0xE7, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x7E, 0x0F, 0xE0,
  0xFE, 0x07, 0xC7, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x7E, 0x0F, 0xF1, 0xFE,
  0x0F, 0x87, 0xE0, 0x7F, 0xFF, 0xF3, 0xF8, 0x7E, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x3F, 0xFB, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0x1F, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0x80, 0x78, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F,
  0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xC7, 0xFC,
  0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xF3, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC,
  0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFE,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFC, 0x7F, 0xC7, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F,
  0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x7F, 0xCF, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF,
  0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFB, 0xFE, 0x00, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x07, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0xFF, 0x7F, 0x81, 0xFC, 0xFF, 0xFF, 0x7F, 0x81, 0xFC, 0xFF,
  0xFF, 0x7F, 0x81, 0xFC, 0xFF, 0xFF, 0x3F, 0x83, 0xFC, 0xFF, 0xFF, 0x3F,
  0xC3, 0xF8, 0xFF, 0xFF, 0x3F, 0xC3, 0xF8, 0xFF, 0xFF, 0x1F, 0xC7, 0xF8,
  0xFF, 0xFF, 0x1F, 0xE7, 0xF0, 0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFF, 0xFF,
  0x1F, 0xE7, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFD, 0xFE,
  0x0F, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0x0F, 0xF3,
  0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFC, 0x1F, 0xEF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xFE, 0xFF, 0x80, 0x3F, 0xF7,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xE0, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xF3, 0xFE, 0x00, 0xFF,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0,
  0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07,
  0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFF,
  0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xDF, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xFF, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xFF, 0x1F,
  0xF0, 0x1F, 0xE3, 0xFB, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xDF, 0xC7, 0xF8,
  0x07, 0xFC, 0xFE, 0xFE, 0x3F, 0xC0, 0x3F, 0xE7, 0xF3, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0x9F, 0xDF, 0xF0, 0x07, 0xFB, 0xF8, 0xFE, 0xFF, 0x80, 0x3F,
  0xDF, 0xC7, 0xF7, 0xF8, 0x01, 0xFE, 0xFE, 0x3F, 0xBF, 0xC0, 0x0F, 0xF7,
  0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE,
  0x3F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x9F, 0x81, 0xFD,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF,
  0xCF, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xC3, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F,
  0xEF, 0xF8, 0x1F, 0xF9, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0x81,
  0xFF, 0x1F, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x40, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xFE, 0x3F, 0xCF, 0xFF, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xE0,
  0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xFD, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFC, 0x07, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7,
  0xFC, 0x07, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0xC1, 0xFF,
  0xCF, 0xF0, 0x3F, 0xE3, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x02, 0x1F, 0xF8, 0x01, 0x83, 0xFF, 0x01, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFB, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xE3, 0xFC, 0x1F, 0xFE, 0x7F, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x81, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xE0,
  0x3F, 0xC7, 0xFC, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x08, 0x00, 0xFF, 0x81, 0x80, 0x1F, 0xF0, 0x7C, 0x0F, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC1, 0xFF, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFE, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF9, 0xFE,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE0,
  0x01, 0xF0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF7, 0xFC,
  0x0F, 0xFC, 0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF8, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x80, 0x01, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x3F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x80, 0x7F, 0x87, 0xF8, 0x3F, 0xCF, 0xFF, 0x1F, 0xEF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF,
  0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xCF,
  0xF8, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x3F, 0xC7, 0xFC, 0x0F, 0xF3, 0xFF, 0xC3, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC,
  0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFC, 0x3F, 0xE7, 0xFC,
  0x0F, 0xF8, 0x10, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0x7F, 0xF3, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x02, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x02, 0x7F, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFD, 0xFE, 0x3F,
  0xFC, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0xC0,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE7, 0xF8, 0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC, 0x3F,
  0xC3, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xF8,
  0xFF, 0x0F, 0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0x9F, 0xE0, 0x7F,
  0x9F, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0xF9, 0xFE, 0x07, 0xFB, 0xFF, 0xF7,
  0xF8, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x3F, 0x7F, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x60, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE,
  0x01, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xC7, 0xFF, 0x80, 0x7E, 0x3F, 0xFE, 0x07, 0xF3, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0x9F, 0xCF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0x3F, 0x80, 0xFF, 0xF1, 0xFC,
  0x03, 0xFF, 0x8F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_Bold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 46, 16, 4, -45 },
  { 53, 16, 17, 20, 2, -47 },
  { 87, 29, 45, 33, 2, -45 },
  { 251, 26, 59, 32, 3, -52 },
  { 443, 34, 47, 40, 3, -46 },
  { 643, 33, 47, 36, 2, -46 },
  { 837, 6, 17, 10, 2, -47 },
  { 850, 15, 64, 20, 4, -50 },
  { 970, 15, 64, 20, 2, -50 },
  { 1090, 27, 27, 29, 1, -45 },
  { 1182, 26, 33, 30, 2, -37 },
  { 1290, 11, 19, 15, 1, -8 },
  { 1317, 15, 7, 23, 4, -23 },
  { 1331, 10, 10, 18, 4, -9 },
  { 1344, 20, 49, 21, 0, -45 },
  { 1467, 26, 47, 32, 3, -46 },
  { 1620, 17, 45, 32, 5, -45 },
  { 1716, 27, 46, 32, 2, -46 },
  { 1872, 27, 47, 32, 2, -46 },
  { 2031, 28, 45, 32, 2, -45 },
  { 2189, 26, 46, 32, 3, -45 },
  { 2339, 27, 46, 32, 3, -45 },
  { 2495, 27, 45, 32, 2, -45 },
  { 2647, 26, 47, 32, 3, -46 },
  { 2800, 26, 46, 32, 3, -46 },
  { 2950, 10, 35, 17, 4, -34 },
  { 2994, 11, 45, 16, 2, -34 },
  { 3056, 22, 30, 28, 2, -34 },
  { 3139, 24, 20, 32, 4, -30 },
  { 3199, 22, 30, 29, 4, -34 },
  { 3282, 24, 47, 28, 2, -46 },
  { 3423, 44, 58, 48, 2, -44 },
  { 3742, 36, 45, 38, 1, -45 },
  { 3945, 28, 45, 35, 4, -45 },
  { 4103, 31, 47, 36, 3, -46 },
  { 4286, 29, 45, 36, 4, -45 },
  { 4450, 25, 45, 31, 4, -45 },
  { 4591, 24, 45, 30, 4, -45 },
  { 4726, 31, 47, 37, 3, -46 },
  { 4909, 31, 45, 39, 4, -45 },
  { 5084, 9, 45, 17, 4, -45 },
  { 5135, 26, 46, 31, 1, -45 },
  { 5285, 31, 45, 35, 4, -45 },
  { 5460, 24, 45, 30, 4, -45 },
  { 5595, 40, 45, 48, 4, -45 },
  { 5820, 31, 45, 39, 4, -45 },
  { 5995, 32, 47, 38, 3, -46 },
  { 6183, 29, 45, 36, 4, -45 },
  { 6347, 32, 54, 38, 3, -46 },
  { 6563, 30, 45, 35, 4, -45 },
  { 6732, 30, 47, 34, 2, -46 },
  { 6909, 31, 45, 34, 2, -45 },
  { 7084, 30, 46, 36, 3, -45 },
  { 7257, 35, 45, 36, 1, -45 },
  { 7454, 45, 45, 47, 1, -45 },
  { 7708, 33, 45, 35, 1, -45 },
  { 7894, 34, 45, 34, 0, -45 },
  { 8086, 29, 45, 33, 2, -45 },
  { 8250, 12, 62, 17, 3, -52 },
  { 8343, 25, 49, 24, 0, -45 },
  { 8497, 12, 62, 17, 1, -52 },
  { 8590, 21, 22, 25, 2, -45 },
  { 8648, 24, 7, 25, 1, 0 },
  { 8669, 15, 10, 21, 2, -48 },
  { 8688, 26, 35, 30, 2, -34 },
  { 8802, 26, 48, 31, 3, -47 },
  { 8958, 25, 35, 29, 2, -34 },
  { 9068, 26, 48, 31, 2, -47 },
  { 9224, 26, 35, 30, 2, -34 },
  { 9338, 19, 48, 21, 1, -48 },
  { 9452, 27, 47, 32, 2, -34 },
  { 9611, 25, 47, 31, 3, -47 },
  { 9758, 10, 46, 16, 3, -46 },
  { 9816, 14, 59, 15, -2, -46 },
  { 9920, 27, 47, 30, 3, -47 },
  { 10079, 8, 47, 16, 4, -47 },
  { 10126, 40, 34, 47, 3, -34 },
  { 10296, 25, 34, 31, 3, -34 },
  { 10403, 27, 35, 31, 2, -34 },
  { 10522, 26, 47, 31, 3, -34 },
  { 10675, 26, 47, 31, 2, -34 },
  { 10828, 17, 34, 21, 3, -34 },
  { 10901, 24, 35, 29, 2, -34 },
  { 11006, 17, 43, 19, 1, -42 },
  { 11098, 25, 34, 31, 3, -33 },
  { 11205, 26, 33, 28, 1, -33 },
  { 11313, 38, 33, 40, 1, -33 },
  { 11470, 27, 33, 28, 1, -33 },
  { 11582, 27, 46, 28, 1, -33 },
  { 11738, 24, 33, 28, 2, -33 },
  { 11837, 15, 60, 19, 2, -49 },
  { 11950, 6, 53, 16, 5, -45 },
  { 11990, 15, 60, 19, 2, -49 },
  { 12103, 29, 14, 35, 3, -26 },
};

const GFXfont RobotoCondensed_Bold63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_BOLD63PT7B_H_
