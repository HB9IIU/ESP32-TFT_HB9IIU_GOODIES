#ifndef _ROBOTOCONDENSED_BOLD64PT7B_H_
#define _ROBOTOCONDENSED_BOLD64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x70, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3E, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xDF,
  0xF0, 0x1F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0xFE, 0x01, 0x00, 0x3F, 0x8F, 0xE0, 0x38, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x7C,
  0x01, 0xF8, 0x3F, 0x1F, 0x80, 0x3F, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xFC,
  0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F, 0xFF, 0xE7, 0xE0, 0x00, 0xFF,
  0xF8, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7C, 0x7F, 0xF0, 0x00,
  0x1F, 0x9F, 0xFF, 0x00, 0x03, 0xE7, 0xFF, 0xF0, 0x00, 0xF8, 0xFF, 0xFE,
  0x00, 0x1F, 0x1F, 0x8F, 0xE0, 0x07, 0xC7, 0xE0, 0xFC, 0x01, 0xF8, 0xFC,
  0x1F, 0x80, 0x3E, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x7E, 0x01, 0xF0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xF0, 0xFC, 0x03, 0x80, 0x7F, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0x81, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0xF8,
  0xFE, 0x1F, 0xF3, 0xFF, 0x3F, 0x87, 0xFC, 0xFF, 0xDF, 0xE1, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0x0F, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFC, 0x00, 0x08, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x08, 0x40, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x01, 0xF8, 0x00, 0x78, 0x1F, 0x01,
  0xC7, 0xF1, 0xF0, 0x7C, 0x7F, 0xDF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x78, 0x03, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3,
  0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x07, 0x80, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x83,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD,
  0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE7, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xDF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x3F,
  0x9F, 0xF0, 0x03, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF1, 0xFF,
  0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F,
  0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F,
  0xFC, 0x07, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFB, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x9F, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC7, 0xE0, 0x0F, 0xF3, 0xFF, 0x01, 0xFE, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0,
  0x07, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F,
  0xE7, 0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0xCF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x7F, 0xC0,
  0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x83,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xE1, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xF8, 0x03, 0xF1, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xF8, 0x38, 0x0F, 0x81, 0xFC,
  0x3F, 0xE3, 0xFE, 0x7F, 0xF7, 0xFF, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0,
  0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0xF0, 0x1F,
  0x83, 0xF0, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x83, 0xE0,
  0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0x8F, 0xC0, 0x3F, 0xFF, 0xE0, 0xFC, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x1F, 0x01,
  0xFC, 0x1F, 0x80, 0xF9, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xCF, 0xC0, 0xFE,
  0x07, 0xE0, 0x3E, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF3, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x9F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0xFC, 0x1F, 0xC0, 0x7E,
  0x03, 0xE7, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x3F, 0x07, 0xF0, 0x1F, 0x80,
  0xF9, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0xE0, 0x3E,
  0x7C, 0x0F, 0xE0, 0x7E, 0x01, 0xF3, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x9F,
  0x83, 0xF8, 0x1F, 0x80, 0xF8, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xC7, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE1, 0xF8, 0x1F,
  0xC7, 0xFC, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xF3, 0xF0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xE7,
  0xFF, 0x80, 0x7E, 0x01, 0xFE, 0x1F, 0xF8, 0x01, 0xF8, 0x03, 0xC0, 0x3E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xF7, 0xFC, 0x01, 0xFF,
  0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0,
  0x1F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xE0,
  0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xBF, 0xFF, 0xEF, 0xF0, 0x1F,
  0xDF, 0xFF, 0xF7, 0xF8, 0x1F, 0xEF, 0xFF, 0xFB, 0xFC, 0x0F, 0xF7, 0xFF,
  0xFC, 0xFF, 0x07, 0xF3, 0xFF, 0xFE, 0x7F, 0x83, 0xF9, 0xFF, 0xFF, 0x3F,
  0xC3, 0xFC, 0xFF, 0xFF, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xC7, 0xF8, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFC, 0xFF, 0x1F, 0xFF, 0xF0, 0xFE, 0x7F, 0x8F, 0xFF,
  0xF8, 0x7F, 0xBF, 0x87, 0xFF, 0xFE, 0x3F, 0xDF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x7F, 0x81, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF,
  0x3F, 0xE1, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF,
  0x07, 0xFD, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFB, 0xFE,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x7F, 0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x80, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0xFF,
  0xDF, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFD, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF9, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xE7, 0xFB, 0xF9, 0xFF, 0x00, 0xFF,
  0x9F, 0xCF, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0x3F, 0x9F, 0xE0, 0x07, 0xF9,
  0xFC, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF3, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0xC7, 0xF7, 0xF8, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8,
  0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE3, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F,
  0xEF, 0xF8, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xDF, 0xF0, 0x7F, 0xC7, 0xFC, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0x80, 0x3F, 0xE7, 0xFE, 0x07,
  0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0xBF,
  0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xF8,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0x07,
  0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF,
  0x9F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFF,
  0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1E,
  0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0xFE, 0xFF, 0x0F, 0xFF, 0xBF, 0xC7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xDF, 0xF8, 0x3F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFF,
  0x01, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xF0, 0x7F, 0xFB,
  0xFC, 0x0F, 0xF8, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F,
  0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x0C, 0x1F, 0xF8, 0x07, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xE3, 0xFC, 0x1F, 0xFF, 0x7F, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0,
  0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF,
  0x00, 0xFF, 0xBF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF7, 0xFC, 0x0F, 0xFC, 0xFF, 0x80, 0x3C, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC1, 0x00, 0x1F, 0xF8, 0x38, 0x03, 0xFE, 0x0F, 0xC1,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1E, 0x03, 0xFE, 0x7F, 0xE1,
  0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE9, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x1F, 0xFC, 0xFF, 0x81, 0xFF, 0x8F, 0xF8,
  0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC,
  0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFC, 0x3F, 0xEF, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xCF, 0xFF, 0x1F, 0xEF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xE3,
  0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xE3,
  0xFF, 0x03, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0x7F, 0xC3, 0xE0, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC7, 0xF0, 0xFF, 0xFB, 0xFC, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xF0,
  0x0F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xEF, 0xF0, 0x3F, 0xE3, 0xFC, 0x01, 0xE0, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0x7F, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x1F, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F,
  0x83, 0xFE, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xF7,
  0xF8, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFE,
  0x07, 0xF9, 0xFE, 0x07, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF0, 0xFF, 0xC1, 0xFE, 0x3F, 0xC3, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0x1F,
  0xE7, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0xFC,
  0xFE, 0x07, 0xFB, 0xFB, 0xF7, 0xF8, 0x1F, 0xEF, 0xEF, 0xDF, 0xE0, 0x3F,
  0xBF, 0x3F, 0xFF, 0x80, 0xFE, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xF1, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xEF,
  0xF8, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x60, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC,
  0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xF1, 0xFF, 0xE0, 0x1F, 0xC7, 0xFF, 0xC0, 0x7E, 0x3F, 0xFF,
  0x81, 0xF8, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xEF, 0xFF,
  0xFE, 0x7F, 0x0F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFE,
  0x3F, 0x80, 0x7F, 0xF0, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Bold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 47, 17, 4, -46 },
  { 54, 16, 17, 21, 2, -48 },
  { 88, 30, 46, 34, 2, -46 },
  { 261, 26, 61, 32, 3, -54 },
  { 460, 35, 48, 41, 3, -47 },
  { 670, 34, 48, 37, 2, -47 },
  { 874, 7, 17, 10, 2, -48 },
  { 889, 15, 65, 21, 4, -51 },
  { 1011, 15, 65, 21, 2, -51 },
  { 1133, 28, 28, 29, 1, -46 },
  { 1231, 26, 33, 30, 2, -37 },
  { 1339, 11, 19, 16, 1, -8 },
  { 1366, 15, 7, 23, 4, -23 },
  { 1380, 10, 10, 19, 4, -9 },
  { 1393, 20, 50, 21, 0, -46 },
  { 1518, 26, 48, 32, 3, -47 },
  { 1674, 17, 46, 32, 5, -46 },
  { 1772, 28, 47, 32, 2, -47 },
  { 1937, 27, 48, 32, 2, -47 },
  { 2099, 28, 46, 32, 2, -46 },
  { 2260, 27, 47, 32, 3, -46 },
  { 2419, 27, 47, 32, 3, -46 },
  { 2578, 28, 46, 32, 2, -46 },
  { 2739, 26, 48, 32, 3, -47 },
  { 2895, 26, 47, 32, 3, -47 },
  { 3048, 10, 36, 17, 4, -35 },
  { 3093, 12, 46, 16, 2, -35 },
  { 3162, 23, 30, 29, 2, -34 },
  { 3249, 24, 20, 32, 4, -30 },
  { 3309, 23, 30, 29, 4, -34 },
  { 3396, 24, 48, 29, 2, -47 },
  { 3540, 45, 58, 49, 2, -44 },
  { 3867, 37, 46, 38, 1, -46 },
  { 4080, 29, 46, 36, 4, -46 },
  { 4247, 32, 48, 36, 3, -47 },
  { 4439, 29, 46, 36, 4, -46 },
  { 4606, 26, 46, 31, 4, -46 },
  { 4756, 25, 46, 30, 4, -46 },
  { 4900, 32, 48, 37, 3, -47 },
  { 5092, 32, 46, 39, 4, -46 },
  { 5276, 9, 46, 17, 4, -46 },
  { 5328, 27, 47, 31, 1, -46 },
  { 5487, 32, 46, 35, 4, -46 },
  { 5671, 25, 46, 31, 4, -46 },
  { 5815, 41, 46, 49, 4, -46 },
  { 6051, 32, 46, 39, 4, -46 },
  { 6235, 33, 48, 39, 3, -47 },
  { 6433, 30, 46, 36, 4, -46 },
  { 6606, 33, 55, 39, 3, -47 },
  { 6833, 30, 46, 35, 4, -46 },
  { 7006, 30, 48, 35, 2, -47 },
  { 7186, 31, 46, 35, 2, -46 },
  { 7365, 30, 47, 37, 3, -46 },
  { 7542, 35, 46, 37, 1, -46 },
  { 7744, 46, 46, 48, 1, -46 },
  { 8009, 34, 46, 36, 1, -46 },
  { 8205, 34, 46, 35, 0, -46 },
  { 8401, 30, 46, 34, 2, -46 },
  { 8574, 13, 64, 17, 3, -53 },
  { 8678, 25, 50, 24, 0, -46 },
  { 8835, 12, 64, 17, 1, -53 },
  { 8931, 22, 23, 25, 2, -46 },
  { 8995, 24, 7, 26, 1, 0 },
  { 9016, 16, 10, 21, 2, -48 },
  { 9036, 26, 36, 30, 2, -35 },
  { 9153, 27, 49, 32, 3, -48 },
  { 9319, 26, 36, 29, 2, -35 },
  { 9436, 26, 49, 32, 2, -48 },
  { 9596, 27, 36, 31, 2, -35 },
  { 9718, 19, 49, 21, 1, -49 },
  { 9835, 27, 48, 32, 2, -35 },
  { 9997, 25, 48, 32, 3, -48 },
  { 10147, 10, 47, 16, 3, -47 },
  { 10206, 15, 60, 16, -2, -47 },
  { 10319, 28, 48, 31, 3, -48 },
  { 10487, 8, 48, 16, 4, -48 },
  { 10535, 41, 35, 47, 3, -35 },
  { 10715, 25, 35, 32, 3, -35 },
  { 10825, 28, 36, 32, 2, -35 },
  { 10951, 27, 48, 32, 3, -35 },
  { 11113, 26, 48, 32, 2, -35 },
  { 11269, 17, 35, 21, 3, -35 },
  { 11344, 25, 36, 29, 2, -35 },
  { 11457, 17, 43, 20, 1, -42 },
  { 11549, 25, 35, 31, 3, -34 },
  { 11659, 27, 34, 29, 1, -34 },
  { 11774, 38, 34, 41, 1, -34 },
  { 11936, 27, 34, 29, 1, -34 },
  { 12051, 27, 47, 29, 1, -34 },
  { 12210, 24, 34, 29, 2, -34 },
  { 12312, 15, 61, 19, 2, -50 },
  { 12427, 6, 54, 16, 5, -46 },
  { 12468, 15, 61, 19, 2, -50 },
  { 12583, 30, 14, 36, 3, -26 },
};

const GFXfont RobotoCondensed_Bold64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_BOLD64PT7B_H_
