#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_Bold
// Headers: 67

#include "RobotoCondensed_Bold6pt7b.h"
#include "RobotoCondensed_Bold7pt7b.h"
#include "RobotoCondensed_Bold8pt7b.h"
#include "RobotoCondensed_Bold9pt7b.h"
#include "RobotoCondensed_Bold10pt7b.h"
#include "RobotoCondensed_Bold11pt7b.h"
#include "RobotoCondensed_Bold12pt7b.h"
#include "RobotoCondensed_Bold13pt7b.h"
#include "RobotoCondensed_Bold14pt7b.h"
#include "RobotoCondensed_Bold15pt7b.h"
#include "RobotoCondensed_Bold16pt7b.h"
#include "RobotoCondensed_Bold17pt7b.h"
#include "RobotoCondensed_Bold18pt7b.h"
#include "RobotoCondensed_Bold19pt7b.h"
#include "RobotoCondensed_Bold20pt7b.h"
#include "RobotoCondensed_Bold21pt7b.h"
#include "RobotoCondensed_Bold22pt7b.h"
#include "RobotoCondensed_Bold23pt7b.h"
#include "RobotoCondensed_Bold24pt7b.h"
#include "RobotoCondensed_Bold25pt7b.h"
#include "RobotoCondensed_Bold26pt7b.h"
#include "RobotoCondensed_Bold27pt7b.h"
#include "RobotoCondensed_Bold28pt7b.h"
#include "RobotoCondensed_Bold29pt7b.h"
#include "RobotoCondensed_Bold30pt7b.h"
#include "RobotoCondensed_Bold31pt7b.h"
#include "RobotoCondensed_Bold32pt7b.h"
#include "RobotoCondensed_Bold33pt7b.h"
#include "RobotoCondensed_Bold34pt7b.h"
#include "RobotoCondensed_Bold35pt7b.h"
#include "RobotoCondensed_Bold36pt7b.h"
#include "RobotoCondensed_Bold37pt7b.h"
#include "RobotoCondensed_Bold38pt7b.h"
#include "RobotoCondensed_Bold39pt7b.h"
#include "RobotoCondensed_Bold40pt7b.h"
#include "RobotoCondensed_Bold41pt7b.h"
#include "RobotoCondensed_Bold42pt7b.h"
#include "RobotoCondensed_Bold43pt7b.h"
#include "RobotoCondensed_Bold44pt7b.h"
#include "RobotoCondensed_Bold45pt7b.h"
#include "RobotoCondensed_Bold46pt7b.h"
#include "RobotoCondensed_Bold47pt7b.h"
#include "RobotoCondensed_Bold48pt7b.h"
#include "RobotoCondensed_Bold49pt7b.h"
#include "RobotoCondensed_Bold50pt7b.h"
#include "RobotoCondensed_Bold51pt7b.h"
#include "RobotoCondensed_Bold52pt7b.h"
#include "RobotoCondensed_Bold53pt7b.h"
#include "RobotoCondensed_Bold54pt7b.h"
#include "RobotoCondensed_Bold55pt7b.h"
#include "RobotoCondensed_Bold56pt7b.h"
#include "RobotoCondensed_Bold57pt7b.h"
#include "RobotoCondensed_Bold58pt7b.h"
#include "RobotoCondensed_Bold59pt7b.h"
#include "RobotoCondensed_Bold60pt7b.h"
#include "RobotoCondensed_Bold61pt7b.h"
#include "RobotoCondensed_Bold62pt7b.h"
#include "RobotoCondensed_Bold63pt7b.h"
#include "RobotoCondensed_Bold64pt7b.h"
#include "RobotoCondensed_Bold65pt7b.h"
#include "RobotoCondensed_Bold66pt7b.h"
#include "RobotoCondensed_Bold67pt7b.h"
#include "RobotoCondensed_Bold68pt7b.h"
#include "RobotoCondensed_Bold69pt7b.h"
#include "RobotoCondensed_Bold70pt7b.h"
#include "RobotoCondensed_Bold71pt7b.h"
#include "RobotoCondensed_Bold72pt7b.h"
