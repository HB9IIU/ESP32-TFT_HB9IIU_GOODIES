#ifndef _ROBOTOCONDENSED_BOLD66PT7B_H_
#define _ROBOTOCONDENSED_BOLD66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xF0,
  0x70, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xEF, 0xC1, 0xF7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0x87,
  0xFE, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x07,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x04, 0x00, 0x7E, 0x1F, 0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xC1, 0xF0, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F,
  0xC0, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0xC7, 0xC0, 0x0F, 0xE1, 0xF8, 0xFC,
  0x00, 0x7F, 0x3F, 0x8F, 0x80, 0x07, 0xFF, 0xF9, 0xF8, 0x00, 0x3F, 0xFF,
  0x1F, 0x00, 0x03, 0xFF, 0xE3, 0xF0, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x00,
  0x7F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE3, 0xFF, 0x80,
  0x00, 0x7C, 0x7F, 0xFC, 0x00, 0x0F, 0xCF, 0xFF, 0xE0, 0x00, 0xF8, 0xFF,
  0xFE, 0x00, 0x1F, 0x9F, 0xC7, 0xF0, 0x01, 0xF1, 0xF8, 0x3F, 0x00, 0x3F,
  0x1F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x83, 0xF0,
  0x07, 0xC1, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF0,
  0x1F, 0xC3, 0xF0, 0x06, 0x01, 0xFF, 0xFE, 0x00, 0x20, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xFF, 0x87,
  0xF0, 0x7F, 0xDF, 0xF9, 0xFE, 0x1F, 0xF3, 0xFF, 0xBF, 0xC3, 0xFE, 0x3F,
  0xF7, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xE3, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xE1,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x04, 0x40,
  0x00, 0x70, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x70, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x04, 0x01, 0xF0, 0x04, 0x78, 0x0F, 0x80, 0xE3, 0xF8, 0x7C,
  0x3F, 0x1F, 0xF3, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x01, 0xF0, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC,
  0x7F, 0x1F, 0xC0, 0xF0, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x0F,
  0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x81, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xBF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xE7,
  0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF,
  0x7F, 0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xE7,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8,
  0x03, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x1F, 0xFC, 0x0F,
  0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x07, 0xFC,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9,
  0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x01,
  0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xBF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0x7F, 0xF1, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0x80, 0xFF, 0xCF, 0xF0, 0x07, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xF1, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0xC7, 0xFD, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0xFE, 0x07, 0x00, 0x0F, 0xC1, 0xFE, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x1F, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE3, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x03, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0x1F, 0xC0, 0x1F, 0xFF, 0x01, 0xF8,
  0x7E, 0x00, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x8F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0xF8, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xDF, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFD, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xDF, 0x81, 0xFC,
  0x07, 0xE0, 0x3F, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFD, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xDF, 0x83, 0xF8, 0x0F,
  0xE0, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0x80, 0xF9, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xE7, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0x9F, 0x83, 0xF8, 0x0F, 0xC0,
  0x7E, 0x7E, 0x0F, 0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x3F, 0xC0, 0xFC, 0x07,
  0xC7, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC,
  0x7E, 0x07, 0xF8, 0xFF, 0x87, 0xE1, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0x87,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xF3, 0xFF, 0xE0, 0x3F,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x01, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8,
  0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x3F,
  0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xBF, 0xE0,
  0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xC7, 0xFC,
  0x01, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF8, 0x03,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xFB,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF,
  0xF7, 0xF8, 0x07, 0xFB, 0xFF, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x3F, 0xDF, 0xFF, 0xFB, 0xFC, 0x0F,
  0xE7, 0xFF, 0xFE, 0xFF, 0x03, 0xF9, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F,
  0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xFF, 0xF9, 0xFE, 0x1F, 0xC7, 0xFF, 0xFE,
  0x3F, 0xCF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC,
  0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF,
  0x8F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF,
  0xF0, 0x7F, 0xDF, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80,
  0x3F, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xDF, 0xF0, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0,
  0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00,
  0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0xF0, 0xFF,
  0x80, 0xFF, 0x8F, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0x1F, 0xDF, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xBF, 0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0x3F, 0x9F, 0xF0,
  0x07, 0xFD, 0xFE, 0x7F, 0x3F, 0xE0, 0x0F, 0xFB, 0xFC, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xF1, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xE3, 0xFD, 0xFE, 0x00,
  0x3F, 0xDF, 0xC3, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0x7E, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFD, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xF8, 0x07,
  0xFC, 0x7F, 0xE0, 0xFF, 0xBF, 0xFE, 0x1F, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF8, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFD, 0xFF, 0xF8, 0xFF, 0x9F, 0xFE, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9,
  0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFD, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1E, 0x0F, 0xF8, 0x1F, 0xF9,
  0xFF, 0x07, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F,
  0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE,
  0xFF, 0x07, 0xFF, 0x9F, 0xE0, 0x7F, 0xE3, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xFB, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x08, 0x3F, 0xE0, 0x03, 0x87, 0xFF,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x07, 0xFF, 0xDF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0x3C, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x60, 0x03, 0xFE, 0x07, 0x00, 0x7F,
  0xE0, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x3E, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x9F, 0xFE,
  0x3F, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0C, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x87,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xC0, 0x00, 0x60, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0xE7, 0xFC, 0x0F, 0xFE, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x07, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x01,
  0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x7F, 0xF8,
  0x7F, 0xF8, 0x7F, 0xDF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x01, 0xE0, 0x3F, 0xE3, 0xFF, 0x0F, 0xF9, 0xFF, 0xE3, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB,
  0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0xE3, 0xFE, 0xFF, 0xF8, 0x7F, 0xC7,
  0xFC, 0x0F, 0xF8, 0x3E, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xE3, 0xFC, 0x1F, 0xFE, 0x7F, 0x87, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF0, 0x7F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8,
  0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFF, 0x07, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0x81, 0xFF, 0x9F, 0xF0,
  0x07, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xBF, 0xE3,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x2F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFD, 0xFF, 0x87, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xCF, 0xF0,
  0x7F, 0xE3, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x7F, 0xC1,
  0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83,
  0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F,
  0xC3, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0xFF,
  0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0xE7, 0xF8,
  0x1F, 0xE7, 0xFF, 0xEF, 0xF0, 0x0F, 0xE7, 0xEF, 0xEF, 0xF0, 0x0F, 0xFF,
  0xE7, 0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFD, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00,
  0xFF, 0x9F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x3F,
  0xF8, 0x03, 0xF8, 0xFF, 0xF8, 0x07, 0xE3, 0xFF, 0xF8, 0x1F, 0xC7, 0xFF,
  0xF8, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0x0F,
  0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xC7, 0xF0, 0x0F,
  0xFF, 0x8F, 0xE0, 0x0F, 0xFE, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00,
};

const GFXglyph RobotoCondensed_Bold66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 48, 17, 4, -47 },
  { 61, 17, 18, 21, 2, -50 },
  { 100, 31, 47, 35, 2, -47 },
  { 283, 27, 62, 33, 3, -55 },
  { 493, 36, 49, 42, 3, -48 },
  { 714, 35, 49, 38, 2, -48 },
  { 929, 7, 18, 11, 2, -50 },
  { 945, 16, 67, 21, 4, -52 },
  { 1079, 16, 67, 21, 2, -52 },
  { 1213, 29, 28, 30, 1, -47 },
  { 1315, 27, 34, 31, 2, -39 },
  { 1430, 11, 20, 16, 1, -8 },
  { 1458, 16, 8, 24, 4, -24 },
  { 1474, 11, 10, 19, 4, -9 },
  { 1488, 21, 51, 22, 0, -47 },
  { 1622, 27, 49, 33, 3, -48 },
  { 1788, 18, 47, 33, 5, -47 },
  { 1894, 29, 48, 33, 2, -48 },
  { 2068, 28, 49, 33, 2, -48 },
  { 2240, 29, 47, 33, 2, -47 },
  { 2411, 28, 48, 33, 3, -47 },
  { 2579, 28, 48, 33, 3, -47 },
  { 2747, 29, 47, 33, 2, -47 },
  { 2918, 27, 49, 33, 3, -48 },
  { 3084, 27, 48, 33, 3, -48 },
  { 3246, 11, 36, 18, 4, -35 },
  { 3296, 12, 47, 17, 2, -35 },
  { 3367, 23, 32, 29, 2, -36 },
  { 3459, 25, 22, 33, 4, -32 },
  { 3528, 24, 32, 30, 4, -36 },
  { 3624, 25, 49, 30, 2, -48 },
  { 3778, 46, 61, 51, 2, -46 },
  { 4129, 38, 47, 39, 1, -47 },
  { 4353, 30, 47, 37, 4, -47 },
  { 4530, 33, 49, 38, 3, -48 },
  { 4733, 30, 47, 37, 4, -47 },
  { 4910, 27, 47, 32, 4, -47 },
  { 5069, 26, 47, 31, 4, -47 },
  { 5222, 33, 49, 39, 3, -48 },
  { 5425, 33, 47, 41, 4, -47 },
  { 5619, 10, 47, 18, 4, -47 },
  { 5678, 28, 48, 32, 1, -47 },
  { 5846, 33, 47, 37, 4, -47 },
  { 6040, 26, 47, 32, 4, -47 },
  { 6193, 42, 47, 50, 4, -47 },
  { 6440, 33, 47, 40, 4, -47 },
  { 6634, 34, 49, 40, 3, -48 },
  { 6843, 31, 47, 38, 4, -47 },
  { 7026, 34, 56, 40, 3, -48 },
  { 7264, 31, 47, 37, 4, -47 },
  { 7447, 31, 49, 36, 2, -48 },
  { 7637, 32, 47, 36, 2, -47 },
  { 7825, 31, 48, 38, 3, -47 },
  { 8011, 36, 47, 38, 1, -47 },
  { 8223, 47, 47, 49, 1, -47 },
  { 8500, 35, 47, 37, 1, -47 },
  { 8706, 34, 47, 36, 1, -47 },
  { 8906, 31, 47, 35, 2, -47 },
  { 9089, 12, 66, 17, 4, -55 },
  { 9188, 26, 51, 25, 0, -47 },
  { 9354, 13, 66, 17, 1, -55 },
  { 9462, 22, 23, 26, 2, -47 },
  { 9526, 25, 7, 26, 1, 0 },
  { 9548, 16, 10, 22, 2, -50 },
  { 9568, 27, 37, 31, 2, -36 },
  { 9693, 27, 51, 33, 3, -50 },
  { 9866, 27, 37, 30, 2, -36 },
  { 9991, 27, 51, 33, 2, -50 },
  { 10164, 27, 37, 32, 3, -36 },
  { 10289, 20, 51, 22, 1, -51 },
  { 10417, 28, 49, 33, 2, -36 },
  { 10589, 26, 50, 32, 3, -50 },
  { 10752, 10, 49, 17, 3, -49 },
  { 10814, 15, 62, 16, -2, -49 },
  { 10931, 29, 50, 32, 3, -50 },
  { 11113, 9, 50, 17, 4, -50 },
  { 11170, 43, 36, 49, 3, -36 },
  { 11364, 26, 36, 32, 3, -36 },
  { 11481, 29, 37, 33, 2, -36 },
  { 11616, 27, 49, 33, 3, -36 },
  { 11782, 27, 49, 33, 2, -36 },
  { 11948, 18, 36, 22, 3, -36 },
  { 12029, 26, 37, 30, 2, -36 },
  { 12150, 18, 44, 20, 1, -43 },
  { 12249, 26, 36, 32, 3, -35 },
  { 12366, 28, 35, 30, 1, -35 },
  { 12489, 40, 35, 42, 1, -35 },
  { 12664, 28, 35, 30, 1, -35 },
  { 12787, 28, 48, 29, 1, -35 },
  { 12955, 24, 35, 30, 3, -35 },
  { 13060, 16, 63, 20, 2, -51 },
  { 13186, 5, 56, 17, 6, -47 },
  { 13221, 16, 63, 20, 2, -51 },
  { 13347, 31, 15, 37, 3, -27 },
};

const GFXfont RobotoCondensed_Bold66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_BOLD66PT7B_H_
