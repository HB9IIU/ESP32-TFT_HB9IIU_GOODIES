#ifndef _ROBOTOCONDENSED_BOLD31PT7B_H_
#define _ROBOTOCONDENSED_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC6, 0x07, 0x30, 0x1C, 0xC0,
  0x73, 0x01, 0x9C, 0x06, 0x70, 0x39, 0xC7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC,
  0x31, 0x80, 0xCE, 0x03, 0x38, 0x1C, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x19, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F,
  0x78, 0x7B, 0xC3, 0xDF, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBF, 0xFC, 0xFF,
  0xC3, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x1F, 0xC2, 0x0C, 0x71, 0x8E, 0x39, 0xC7, 0x1C, 0xC1, 0x8E, 0xE0,
  0xFE, 0x60, 0x7F, 0x70, 0x1F, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1D,
  0xE0, 0x1D, 0xFC, 0x0D, 0xFE, 0x0E, 0xE7, 0x06, 0x71, 0x87, 0x38, 0xC3,
  0x1C, 0x61, 0x87, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x3C, 0xF0, 0x3D, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0x8E, 0x7F, 0xCE, 0x7B, 0xDE,
  0xFB, 0xFE, 0xF1, 0xFE, 0xF0, 0xFC, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFE, 0x0F, 0x9F, 0xFF, 0xFF, 0xFF, 0x02, 0x1C, 0x38, 0xE3, 0xC7,
  0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x8F, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0xE1, 0xC0, 0x80, 0x81,
  0xC3, 0x83, 0x87, 0x87, 0x0F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x71, 0xE3, 0x8E,
  0x1C, 0x20, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x10, 0xC0, 0x73, 0x39,
  0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x0F, 0xC0, 0x7B, 0x81, 0xCF, 0x0E, 0x1C,
  0x08, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x7B, 0xDE, 0xF7, 0xBB, 0xDC, 0x40, 0xFF, 0xFF,
  0xFF, 0xF0, 0x67, 0xFF, 0xF7, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80,
  0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xBC, 0x3D, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xC0,
  0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xBE, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x3F, 0xC1,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x3C, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFC, 0xFF, 0xE3, 0xFE, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x07, 0xFC, 0x1D, 0xF0, 0xF7, 0xC3, 0x9F, 0x1E, 0x7C, 0x79, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x7F, 0xE3, 0xFF, 0x9F, 0x7E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F,
  0xE1, 0xFE, 0x07, 0xC0, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0xF0, 0xFF, 0xE7, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF,
  0x0F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0x9F, 0xFC, 0xFF,
  0xC3, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F,
  0xBC, 0x3D, 0xE1, 0xEF, 0x1F, 0x3F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0xE7,
  0xCF, 0x3C, 0x3D, 0xE1, 0xFF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F,
  0xE3, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0x8F,
  0x3C, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xDE, 0x1E, 0xFB, 0xF7,
  0xFF, 0x9F, 0xFC, 0x3D, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x87, 0xF8, 0x3F,
  0x81, 0xF8, 0x0F, 0x00, 0x67, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0x70, 0x31, 0xE7, 0xDE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0xF1, 0x80, 0x00, 0x20, 0x1C, 0x0F,
  0x87, 0xF3, 0xFF, 0xFE, 0x3F, 0x07, 0x80, 0xFC, 0x1F, 0xE0, 0xFF, 0x87,
  0xF0, 0x3E, 0x01, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x1C,
  0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC1, 0xF8, 0x0F, 0x07, 0xE7, 0xFF,
  0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x87, 0xFC, 0x7F, 0xEF,
  0xFE, 0xF1, 0xFF, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xC0, 0x78, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x83, 0xC3, 0x8E,
  0x3F, 0xCE, 0x70, 0xFF, 0x19, 0xC7, 0x1C, 0x67, 0x1C, 0x71, 0xB8, 0xE1,
  0xC6, 0xE3, 0x8E, 0x1B, 0x8E, 0x38, 0x6E, 0x38, 0xE1, 0xB8, 0xE3, 0x86,
  0xE3, 0x8E, 0x3B, 0x8E, 0x38, 0xEE, 0x3F, 0xFF, 0x1C, 0x7D, 0xF8, 0x70,
  0xE3, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x02,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0x03, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07, 0xFE, 0x01, 0xF0, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xFC,
  0x1E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1E,
  0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x78,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFC, 0x07, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF0, 0x7F, 0xE0, 0xFB, 0xC3, 0xF7, 0x87,
  0xCF, 0x1F, 0x1E, 0x3E, 0x3C, 0xF8, 0x7B, 0xE0, 0xF7, 0xC1, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0xF8, 0x78, 0xF8, 0xF1,
  0xF1, 0xE1, 0xF3, 0xC3, 0xE7, 0x83, 0xEF, 0x07, 0xDE, 0x07, 0xC0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0xFF, 0xF1, 0xEF, 0xF7, 0x1E, 0xFF,
  0x79, 0xCF, 0xF7, 0xBD, 0xFF, 0x7B, 0xDF, 0xF3, 0xFD, 0xFF, 0x3F, 0x9F,
  0xF3, 0xF9, 0xFF, 0x1F, 0x9F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF0, 0xF1,
  0xFF, 0x0F, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0x3F, 0xDE, 0x7F,
  0x9E, 0xFF, 0x3D, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04,
  0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x07, 0xDE, 0x0F, 0xBC,
  0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE,
  0x1F, 0xFC, 0x3C, 0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xF3, 0xC3, 0xE7,
  0x83, 0xEF, 0x07, 0xDE, 0x07, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x3E, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x7C, 0x1F,
  0xF8, 0x3F, 0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0x9E,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x78, 0x7B, 0xC1, 0xE1, 0xEF, 0x0F, 0x87, 0xBE, 0x3E, 0x1E, 0x78, 0xF8,
  0x79, 0xE3, 0xF3, 0xE7, 0x8F, 0xCF, 0x1E, 0x7F, 0x3C, 0x79, 0xFC, 0xF1,
  0xF7, 0xF3, 0xC3, 0xDD, 0xCF, 0x0F, 0x77, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF,
  0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x01, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x1F, 0x00,
  0x7C, 0x0F, 0x3E, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF8, 0x1F, 0x7C,
  0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8,
  0x0F, 0x3E, 0x0F, 0x9F, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF,
  0xC0, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xFF, 0xFF, 0xE0, 0x1E, 0x07, 0x81,
  0xE0, 0xFC, 0x3F, 0x0E, 0xE7, 0x39, 0xCE, 0x73, 0xFC, 0x7E, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x81, 0xFF,
  0x1F, 0xF8, 0xFB, 0xEF, 0x8F, 0x00, 0x78, 0x03, 0xC3, 0xFE, 0x3F, 0xF3,
  0xFF, 0xBE, 0x3D, 0xE1, 0xEF, 0x0F, 0x7D, 0xF9, 0xFF, 0xCF, 0xFE, 0x1E,
  0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x8F,
  0xFE, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xF7, 0x80,
  0x0F, 0x83, 0xFE, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xF8, 0xF7, 0xFF, 0x7F, 0xE3, 0xFE,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x7B, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3E, 0xFF, 0xF7, 0xFF,
  0x9F, 0xBC, 0x79, 0xE0, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F,
  0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07,
  0x82, 0x3F, 0xF8, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0x0F, 0x8F, 0xCF, 0xE7,
  0xF3, 0xC1, 0xE3, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x1F, 0x79,
  0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF,
  0x1F, 0x78, 0x03, 0xC8, 0x3E, 0x7B, 0xF7, 0xFF, 0x1F, 0xF0, 0x7E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x1F,
  0xFC, 0xFF, 0xF7, 0xFF, 0xBE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x08, 0x3C, 0xF8, 0xF1, 0xC0, 0x00, 0x0F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3F, 0xFF, 0xEF, 0xDE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC7, 0xDE, 0x7C, 0xF3, 0xE7, 0xBE, 0x3D, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xBE, 0x3C, 0xF9,
  0xE7, 0xCF, 0x1F, 0x78, 0xFB, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0x87, 0x9F, 0xFD, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F,
  0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF,
  0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xE0,
  0xF3, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xF8, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7,
  0x8F, 0xBF, 0xF8, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0xF7, 0x8F, 0xFE, 0xFF,
  0xEF, 0xFF, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xF7, 0x8F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x79, 0xFB, 0xDF, 0xFE,
  0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF, 0x1E, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x80, 0x7C,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F,
  0xE3, 0xFE, 0x1F, 0x80, 0x3E, 0x1F, 0x0F, 0x9F, 0xFF, 0xFF, 0xFC, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x8F,
  0xC7, 0xE1, 0xF0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF7, 0x8F,
  0xBF, 0xFD, 0xFF, 0xE7, 0xEF, 0x1E, 0x78, 0x78, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0xF1,
  0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xCF, 0x9E, 0xF3, 0xE7, 0x9C, 0xFD,
  0xE7, 0xBF, 0x79, 0xEF, 0xDE, 0x7F, 0xF7, 0x1F, 0xDF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x00, 0x78, 0x79, 0xF3, 0xE3, 0xCF, 0x0F, 0xBC, 0x1F, 0xE0, 0x7F,
  0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0xC3, 0xCF, 0x1F, 0x3E, 0x78, 0x78, 0xF8, 0x79, 0xE1, 0xE7,
  0x87, 0x9F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x1C, 0x78, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE7, 0x9F, 0x38, 0x7C, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x38, 0x78, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC1, 0xC3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xE3, 0xC3,
  0xC3, 0x8F, 0x3C, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC7,
  0x0C, 0x00, 0x3C, 0x1D, 0xF8, 0x7F, 0xF3, 0xFF, 0xFE, 0xE3, 0xFB, 0x8F,
  0xC0, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 10, 1, -23 },
  { 20, 14, 22, 16, 1, -22 },
  { 59, 13, 28, 16, 1, -25 },
  { 105, 17, 22, 20, 1, -22 },
  { 152, 16, 22, 18, 1, -22 },
  { 196, 3, 8, 5, 1, -23 },
  { 199, 7, 31, 10, 2, -24 },
  { 227, 7, 31, 10, 1, -24 },
  { 255, 14, 13, 14, 0, -22 },
  { 278, 13, 16, 15, 1, -18 },
  { 304, 5, 9, 8, 1, -4 },
  { 310, 7, 4, 11, 2, -12 },
  { 314, 5, 5, 9, 2, -5 },
  { 318, 10, 24, 10, 0, -22 },
  { 348, 13, 22, 16, 1, -22 },
  { 384, 9, 22, 16, 2, -22 },
  { 409, 13, 22, 16, 1, -22 },
  { 445, 13, 22, 16, 1, -22 },
  { 481, 14, 22, 16, 1, -22 },
  { 520, 13, 22, 16, 1, -22 },
  { 556, 13, 22, 16, 2, -22 },
  { 592, 13, 22, 16, 1, -22 },
  { 628, 13, 22, 16, 1, -22 },
  { 664, 13, 22, 16, 1, -22 },
  { 700, 5, 17, 8, 2, -17 },
  { 711, 6, 22, 8, 1, -17 },
  { 728, 11, 15, 14, 1, -17 },
  { 749, 12, 11, 16, 2, -15 },
  { 766, 11, 15, 14, 2, -17 },
  { 787, 12, 22, 14, 1, -22 },
  { 820, 22, 28, 24, 1, -21 },
  { 897, 18, 22, 19, 0, -22 },
  { 947, 14, 22, 17, 2, -22 },
  { 986, 16, 22, 18, 1, -22 },
  { 1030, 14, 22, 18, 2, -22 },
  { 1069, 12, 22, 15, 2, -22 },
  { 1102, 12, 22, 15, 2, -22 },
  { 1135, 16, 22, 18, 1, -22 },
  { 1179, 15, 22, 19, 2, -22 },
  { 1221, 4, 22, 8, 2, -22 },
  { 1232, 12, 22, 15, 1, -22 },
  { 1265, 15, 22, 17, 2, -22 },
  { 1307, 12, 22, 15, 2, -22 },
  { 1340, 20, 22, 24, 2, -22 },
  { 1395, 15, 22, 19, 2, -22 },
  { 1437, 16, 22, 19, 1, -22 },
  { 1481, 14, 22, 18, 2, -22 },
  { 1520, 16, 26, 19, 1, -22 },
  { 1572, 15, 22, 17, 2, -22 },
  { 1614, 15, 22, 17, 1, -22 },
  { 1656, 15, 22, 17, 1, -22 },
  { 1698, 14, 22, 18, 2, -22 },
  { 1737, 18, 22, 18, 0, -22 },
  { 1787, 22, 22, 23, 1, -22 },
  { 1848, 17, 22, 17, 0, -22 },
  { 1895, 17, 22, 17, 0, -22 },
  { 1942, 14, 22, 16, 1, -22 },
  { 1981, 6, 31, 8, 2, -26 },
  { 2005, 12, 24, 12, 0, -22 },
  { 2041, 5, 31, 8, 1, -26 },
  { 2061, 10, 11, 12, 1, -22 },
  { 2075, 12, 3, 12, 0, 0 },
  { 2080, 8, 5, 10, 1, -24 },
  { 2085, 13, 17, 15, 1, -17 },
  { 2113, 12, 23, 15, 2, -23 },
  { 2148, 12, 17, 14, 1, -17 },
  { 2174, 13, 23, 15, 1, -23 },
  { 2212, 13, 17, 15, 1, -17 },
  { 2240, 9, 23, 10, 1, -23 },
  { 2266, 13, 23, 16, 1, -17 },
  { 2304, 13, 23, 15, 1, -23 },
  { 2342, 4, 24, 8, 2, -24 },
  { 2354, 7, 30, 8, -1, -24 },
  { 2381, 13, 23, 15, 2, -23 },
  { 2419, 4, 23, 8, 2, -23 },
  { 2431, 19, 17, 23, 2, -17 },
  { 2472, 13, 17, 15, 1, -17 },
  { 2500, 13, 17, 15, 1, -17 },
  { 2528, 12, 23, 15, 2, -17 },
  { 2563, 13, 23, 15, 1, -17 },
  { 2601, 8, 17, 10, 2, -17 },
  { 2618, 12, 17, 14, 1, -17 },
  { 2644, 9, 20, 10, 0, -20 },
  { 2667, 13, 17, 15, 1, -17 },
  { 2695, 13, 17, 14, 0, -17 },
  { 2723, 18, 17, 20, 1, -17 },
  { 2762, 14, 17, 14, 0, -17 },
  { 2792, 14, 23, 14, 0, -17 },
  { 2833, 12, 17, 14, 1, -17 },
  { 2859, 7, 29, 9, 1, -24 },
  { 2885, 2, 26, 8, 3, -22 },
  { 2892, 7, 29, 9, 1, -24 },
  { 2918, 14, 7, 17, 2, -13 },
};

const GFXfont RobotoCondensed_Bold31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_BOLD31PT7B_H_
