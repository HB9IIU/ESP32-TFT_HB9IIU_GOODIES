#ifndef _ROBOTOCONDENSED_BOLD28PT7B_H_
#define _ROBOTOCONDENSED_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x00, 0xEF, 0xFE, 0xEF,
  0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0x06, 0x60, 0x73, 0x03, 0xB8, 0x1D,
  0xC0, 0xCE, 0x06, 0x61, 0xFF, 0xEF, 0xFF, 0x1C, 0xC0, 0xEE, 0x06, 0x70,
  0x33, 0x8F, 0xFF, 0x7F, 0xF8, 0x66, 0x07, 0x30, 0x3B, 0x81, 0x9C, 0x0C,
  0xE0, 0x66, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF8, 0x3F, 0xC3, 0xFE,
  0x79, 0xE7, 0x8F, 0x78, 0xF7, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0x9F, 0x7F, 0xE3, 0xFC,
  0x0F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0x7E, 0x00, 0x67, 0x10,
  0xE7, 0x38, 0xE7, 0x30, 0xE7, 0x70, 0x67, 0x60, 0x7E, 0xE0, 0x3C, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x06, 0xE6, 0x0E, 0xE7,
  0x0C, 0xE7, 0x1C, 0xE7, 0x18, 0xE6, 0x00, 0x7E, 0x00, 0x3C, 0x0F, 0x00,
  0x3F, 0x80, 0xFF, 0x01, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x0E, 0x70, 0x1F,
  0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0xF3, 0xFD, 0xEF, 0x7B, 0x9E, 0x7F,
  0x3C, 0x7E, 0x78, 0xFC, 0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xF9, 0xE0,
  0xFF, 0xFF, 0xF6, 0x04, 0x31, 0xCE, 0x39, 0xC7, 0x3C, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x0E, 0x38, 0x70, 0xC1,
  0x81, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xE3,
  0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x71, 0xC3, 0x04,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x27, 0xFF, 0x7F, 0xF8, 0x3E,
  0x01, 0xF0, 0x1D, 0x81, 0xCE, 0x0E, 0x38, 0x20, 0x80, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x39, 0xCE, 0x73, 0xBD, 0xCC, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0xFC, 0x3F, 0xE7, 0x9E, 0x78,
  0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x8E, 0x79, 0xE3, 0xFE, 0x3F, 0xC0, 0xF0, 0x03,
  0x0F, 0x7F, 0xFF, 0xFF, 0xCF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x83, 0xFC, 0x7F, 0xE7,
  0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xE0, 0x0F, 0x00, 0xE0,
  0x1E, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x1D, 0xE1, 0xDE, 0x39, 0xE3, 0x9E, 0x79, 0xE7,
  0x1E, 0xF1, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xF8, 0x7F, 0xC7, 0xFE, 0x31, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0xFF,
  0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8, 0x03, 0xC0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x78, 0xFF, 0xEF, 0xFE, 0xF9, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0x8F, 0x79, 0xF3, 0xFE, 0x1F, 0xC0,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7,
  0x9E, 0x78, 0xE7, 0x8E, 0x79, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x3F, 0xE7,
  0x9E, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC0,
  0xF8, 0x0F, 0x03, 0xFC, 0x7F, 0xC7, 0x9E, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xF3, 0xFF, 0x1E, 0xE0, 0x0E, 0x01, 0xE0,
  0x3C, 0x0F, 0xC1, 0xF8, 0x1F, 0x01, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x60, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBD,
  0xEE, 0x73, 0xB8, 0x80, 0x00, 0x40, 0x70, 0x7C, 0x7F, 0x7F, 0x3F, 0x0F,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7C, 0x07, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x83, 0xF8,
  0x7F, 0x83, 0xF0, 0x3C, 0x3F, 0x7F, 0xBF, 0x8F, 0x83, 0x80, 0x80, 0x00,
  0x1F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0x70, 0x3C, 0x0F, 0x07, 0x83,
  0xE0, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x3C, 0x0E, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x01, 0x9C, 0x1E, 0x3B, 0x8F, 0xE3, 0x61, 0xDC, 0x7C, 0x73,
  0x8F, 0x8E, 0x71, 0xF3, 0x8E, 0x3E, 0x71, 0xC7, 0xCE, 0x38, 0xF9, 0xC7,
  0x1F, 0x38, 0xE7, 0xE7, 0xFD, 0xCC, 0x7F, 0xF1, 0x87, 0x3C, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xEF, 0x00, 0x7F, 0xE0, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x78, 0x1E, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0xEF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xF7,
  0x03, 0xDE, 0x0F, 0x7C, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0xE7, 0xCF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x0E, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF3, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x3D,
  0xE0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x0F, 0x7E, 0x7C, 0xFF, 0xF1, 0xFF,
  0x81, 0xF8, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFC, 0x7F, 0x8F, 0xFB, 0xFF, 0xF9,
  0xFE, 0x0F, 0x80, 0xF0, 0xFB, 0xC3, 0xEF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3,
  0xDF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC3, 0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F,
  0xBC, 0x1E, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF,
  0xEE, 0x3B, 0xFB, 0x8E, 0xFE, 0xF3, 0xBF, 0x9D, 0xEF, 0xE7, 0x73, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x8F, 0x8F, 0xE3, 0xE3, 0xF8, 0xF8, 0xFE, 0x1E,
  0x3F, 0x87, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xEF, 0x3F, 0xBC, 0xFE, 0x7B, 0xF9, 0xEF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07,
  0xF8, 0x1F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF,
  0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x7E, 0xFC, 0x7F, 0xF0,
  0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xCF,
  0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x07,
  0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x7E, 0xFC, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0xFF, 0x87,
  0xFF, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x8F, 0xBF, 0xF9, 0xFF, 0x8F, 0xFC, 0x79, 0xE3, 0xCF, 0x9E, 0x3C,
  0xF1, 0xE7, 0x87, 0xBC, 0x3D, 0xE1, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xFB, 0xEF, 0x87, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x7C, 0xFB, 0xFF,
  0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xDE, 0x1E, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF,
  0x03, 0xF0, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC7,
  0xC7, 0xF8, 0xF8, 0xFF, 0x1F, 0x1E, 0xE3, 0xE3, 0x9E, 0x7C, 0xF3, 0xDF,
  0xDE, 0x7B, 0xBB, 0xCF, 0x77, 0x79, 0xEE, 0xEF, 0x1D, 0xDD, 0xC3, 0xBB,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0xF8, 0x78, 0xF0, 0xF1,
  0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xBE, 0x0F, 0x3C,
  0x3C, 0x7C, 0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xF0, 0xF8, 0x3E, 0xF0, 0x79,
  0xE0, 0xF1, 0xE3, 0xE3, 0xC7, 0x83, 0x8F, 0x07, 0xBC, 0x0F, 0x78, 0x0E,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF,
  0xF0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0xFF, 0xFF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x1C, 0x0E, 0x0F, 0x87, 0xC3, 0x63, 0xB9,
  0xDC, 0xC6, 0xE3, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF0,
  0xF0, 0xE0, 0x1F, 0x07, 0xF9, 0xFF, 0x78, 0xFF, 0x1E, 0x03, 0xC7, 0xFB,
  0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFE, 0xFF, 0xCF, 0x78, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x8F, 0xFE, 0xFF,
  0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFE, 0xF7, 0x80, 0x1F, 0x07, 0xF9, 0xFF, 0x7C,
  0xFF, 0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xFC, 0xF7,
  0xFC, 0x7F, 0x87, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC7, 0xBB, 0xFF, 0x7F, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFF, 0x3D, 0xFF, 0xBF, 0xF1, 0xEE, 0x1F, 0x83, 0xFC,
  0x7F, 0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x07, 0x8E, 0x7F, 0xE3, 0xFE, 0x0F, 0x80, 0x0F, 0x3F, 0x3F, 0x7C,
  0x78, 0x78, 0xFE, 0xFE, 0xFE, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F,
  0xF3, 0xFF, 0x1E, 0xF0, 0x0F, 0x00, 0xF3, 0x1E, 0x7F, 0xE7, 0xFC, 0x1F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE,
  0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0x77, 0xFE, 0xE0, 0x01, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x1C, 0x78, 0xF0, 0xE0,
  0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x1E, 0xFD, 0xF3, 0xC0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF, 0x7C, 0xF7,
  0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xF3, 0xCF, 0x3E, 0xF1,
  0xEF, 0x1F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF7, 0x8F, 0x3F, 0xF7, 0xEF, 0xFF, 0xFF, 0xE7, 0xCF, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0xF7, 0x9F,
  0xFB, 0xFF, 0xFC, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x38, 0x1F, 0x83, 0xFC, 0x7F, 0xE7,
  0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7,
  0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xF7, 0x8F, 0xFE, 0xFF, 0xEF, 0x9F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E,
  0xFF, 0xEF, 0xFE, 0xF7, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0xEF, 0xFD, 0xFF, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0xF7, 0xFE, 0xFF, 0xC7, 0xB8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x0F,
  0xF1, 0xFF, 0x78, 0xFF, 0x1F, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F,
  0x87, 0xF8, 0xFF, 0xFC, 0xFF, 0x87, 0xC0, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF,
  0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xFD, 0xF7, 0xFE, 0xFF, 0xCF, 0x38, 0x70, 0xF7,
  0x8F, 0x78, 0xE7, 0x9E, 0x39, 0xE3, 0x9E, 0x3D, 0xC3, 0xDC, 0x1F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x71, 0xC7, 0xB8,
  0xF3, 0xDE, 0x79, 0xEF, 0x3C, 0xF7, 0xBE, 0x71, 0xDF, 0xB8, 0xEF, 0xFC,
  0x77, 0xFE, 0x3F, 0x7E, 0x1F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3,
  0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x78, 0xF7, 0x9E, 0x3D, 0xE3, 0xDC, 0x1F,
  0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0xDE, 0x3D,
  0xE7, 0x8F, 0x78, 0xF0, 0xF0, 0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0x39, 0xE3,
  0xDE, 0x3D, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x38, 0x00,
  0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x38, 0x71,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xCF, 0x1C, 0x3C, 0x3C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xE3, 0xCF, 0x9C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x00, 0x3C, 0x3B, 0xF1, 0xDF, 0xCF, 0xEF,
  0xFE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 20, 7, 2, -20 },
  { 11, 7, 8, 9, 1, -21 },
  { 18, 13, 20, 15, 1, -20 },
  { 51, 12, 26, 14, 1, -23 },
  { 90, 16, 20, 18, 1, -20 },
  { 130, 15, 20, 16, 1, -20 },
  { 168, 3, 8, 5, 1, -21 },
  { 171, 6, 28, 9, 2, -22 },
  { 192, 7, 28, 9, 1, -22 },
  { 217, 13, 12, 13, 0, -20 },
  { 237, 11, 15, 13, 1, -17 },
  { 258, 5, 8, 7, 0, -3 },
  { 263, 6, 3, 10, 2, -10 },
  { 266, 4, 4, 8, 2, -4 },
  { 268, 9, 22, 9, 0, -20 },
  { 293, 12, 20, 14, 1, -20 },
  { 323, 8, 20, 14, 2, -20 },
  { 343, 12, 20, 14, 1, -20 },
  { 373, 12, 20, 14, 1, -20 },
  { 403, 12, 20, 14, 1, -20 },
  { 433, 12, 20, 14, 1, -20 },
  { 463, 12, 20, 14, 1, -20 },
  { 493, 12, 20, 14, 1, -20 },
  { 523, 12, 20, 14, 1, -20 },
  { 553, 12, 20, 14, 1, -20 },
  { 583, 4, 15, 8, 2, -15 },
  { 591, 5, 20, 7, 1, -15 },
  { 604, 10, 13, 13, 1, -15 },
  { 621, 10, 8, 14, 2, -13 },
  { 631, 10, 13, 13, 2, -15 },
  { 648, 10, 20, 13, 1, -20 },
  { 673, 19, 25, 21, 1, -19 },
  { 733, 16, 20, 17, 0, -20 },
  { 773, 12, 20, 16, 2, -20 },
  { 803, 14, 20, 16, 1, -20 },
  { 838, 13, 20, 16, 2, -20 },
  { 871, 11, 20, 14, 2, -20 },
  { 899, 11, 20, 13, 2, -20 },
  { 927, 14, 20, 16, 1, -20 },
  { 962, 14, 20, 17, 2, -20 },
  { 997, 4, 20, 8, 2, -20 },
  { 1007, 11, 20, 14, 1, -20 },
  { 1035, 14, 20, 15, 2, -20 },
  { 1070, 11, 20, 13, 2, -20 },
  { 1098, 18, 20, 21, 2, -20 },
  { 1143, 14, 20, 17, 2, -20 },
  { 1178, 15, 20, 17, 1, -20 },
  { 1216, 13, 20, 16, 2, -20 },
  { 1249, 15, 24, 17, 1, -20 },
  { 1294, 13, 20, 15, 2, -20 },
  { 1327, 13, 20, 15, 1, -20 },
  { 1360, 14, 20, 15, 1, -20 },
  { 1395, 14, 20, 16, 1, -20 },
  { 1430, 16, 20, 16, 0, -20 },
  { 1470, 19, 20, 21, 1, -20 },
  { 1518, 15, 20, 16, 0, -20 },
  { 1556, 15, 20, 15, 0, -20 },
  { 1594, 13, 20, 15, 1, -20 },
  { 1627, 5, 28, 7, 2, -23 },
  { 1645, 11, 22, 11, 0, -20 },
  { 1676, 6, 28, 7, 0, -23 },
  { 1697, 9, 10, 11, 1, -20 },
  { 1709, 11, 3, 11, 0, 0 },
  { 1714, 7, 4, 9, 1, -21 },
  { 1718, 11, 15, 13, 1, -15 },
  { 1739, 12, 21, 14, 1, -21 },
  { 1771, 11, 15, 13, 1, -15 },
  { 1792, 11, 21, 14, 1, -21 },
  { 1821, 12, 15, 13, 1, -15 },
  { 1844, 8, 21, 9, 1, -21 },
  { 1865, 12, 21, 14, 1, -15 },
  { 1897, 11, 21, 14, 1, -21 },
  { 1926, 5, 21, 7, 1, -21 },
  { 1940, 7, 27, 7, -1, -21 },
  { 1964, 12, 21, 13, 1, -21 },
  { 1996, 3, 21, 7, 2, -21 },
  { 2004, 18, 15, 21, 1, -15 },
  { 2038, 11, 15, 14, 1, -15 },
  { 2059, 12, 15, 14, 1, -15 },
  { 2082, 12, 21, 14, 1, -15 },
  { 2114, 11, 21, 14, 1, -15 },
  { 2143, 8, 15, 9, 1, -15 },
  { 2158, 11, 15, 13, 1, -15 },
  { 2179, 8, 18, 9, 0, -18 },
  { 2197, 11, 15, 14, 1, -15 },
  { 2218, 12, 15, 13, 0, -15 },
  { 2241, 17, 15, 18, 0, -15 },
  { 2273, 12, 15, 13, 0, -15 },
  { 2296, 12, 21, 12, 0, -15 },
  { 2328, 11, 15, 13, 1, -15 },
  { 2349, 7, 27, 8, 1, -22 },
  { 2373, 3, 24, 7, 2, -20 },
  { 2382, 7, 27, 8, 1, -22 },
  { 2406, 13, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_Bold28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_BOLD28PT7B_H_
