#ifndef _ROBOTOCONDENSED_BOLD39PT7B_H_
#define _ROBOTOCONDENSED_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x80, 0x00, 0x03, 0x9F, 0xFF, 0xF7, 0xDE, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xF0, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x0F,
  0x3C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xE7, 0x82,
  0x0F, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x87, 0x1C, 0x1C, 0x39, 0xE0, 0xF1,
  0xCE, 0x07, 0x9E, 0xF0, 0x1F, 0xE7, 0x00, 0xFF, 0x78, 0x01, 0xE3, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0xEF, 0xF0, 0x0E,
  0x7F, 0x80, 0xF7, 0x9E, 0x07, 0x38, 0xF0, 0x79, 0xC3, 0x83, 0x8E, 0x1C,
  0x3C, 0x70, 0xE1, 0xC3, 0xC7, 0x0E, 0x1E, 0x78, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3,
  0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0x87, 0xFE, 0x3C, 0x7F, 0xF9,
  0xE3, 0xE7, 0xDF, 0x1F, 0x3F, 0xF9, 0xF8, 0xFF, 0xCF, 0xC3, 0xFC, 0x7E,
  0x1F, 0xE1, 0xF0, 0x7E, 0x0F, 0xEF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFE, 0xFC, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x80, 0x60, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0,
  0x18, 0x02, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78,
  0x3C, 0x06, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xF3, 0xC7, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x3C, 0x38, 0x38,
  0x08, 0x10, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF,
  0x7B, 0xEF, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xFB, 0xFF, 0xF7,
  0xC7, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x07,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xFC,
  0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x60, 0x7C, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF7, 0xF3, 0xF1, 0xF9, 0xF0,
  0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xF3, 0xF1, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7C, 0xFE,
  0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE,
  0xFC, 0x7E, 0x08, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7D, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7E,
  0xFC, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xFC, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x0F, 0xBE,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0x38, 0xFB, 0xFF, 0xF7, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xF7,
  0xC7, 0x00, 0x1C, 0x7D, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C,
  0xF9, 0xE7, 0x83, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07,
  0xFC, 0x7F, 0xE7, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x03, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xC7, 0xFF, 0x7F, 0xF3, 0xFF, 0x0F,
  0xF0, 0x3F, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x1C, 0x07, 0xC1, 0xC7, 0x83, 0xFC, 0x3C, 0xF0, 0xFF,
  0xC7, 0x9C, 0x1F, 0x78, 0x77, 0x87, 0x8F, 0x0E, 0xF0, 0xF1, 0xE1, 0xDE,
  0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x87, 0x70, 0xF0, 0xF0, 0xEE, 0x1E, 0x1E,
  0x1D, 0xC3, 0xC3, 0x83, 0xB8, 0xF8, 0x70, 0x77, 0x1F, 0x0E, 0x0E, 0xE1,
  0xE3, 0xC3, 0x9C, 0x3C, 0x78, 0x73, 0x87, 0xDF, 0x9E, 0x78, 0xFF, 0xFF,
  0x8F, 0x0F, 0xCF, 0xE1, 0xE0, 0xF0, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xF1, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x3E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07,
  0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0xFB,
  0xF0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC,
  0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x83, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x07, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC,
  0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0xBE, 0x1E,
  0xFF, 0xDF, 0x1F, 0x7F, 0xE7, 0x8F, 0xBF, 0xFB, 0xE7, 0x9F, 0xFD, 0xF3,
  0xCF, 0xFE, 0x7B, 0xE7, 0xFF, 0x3F, 0xF3, 0xFF, 0x9F, 0xF1, 0xFF, 0xCF,
  0xF8, 0xFF, 0xE3, 0xFC, 0x7F, 0xF1, 0xFC, 0x3F, 0xF8, 0xFE, 0x1F, 0xFC,
  0x3F, 0x0F, 0xFE, 0x1F, 0x87, 0xFF, 0x0F, 0x83, 0xFF, 0x83, 0xC1, 0xF0,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0xFC,
  0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xE0,
  0xFE, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E,
  0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x01,
  0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xEF, 0xC0, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xE0, 0xFE, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xE0, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7E, 0xF8,
  0x0F, 0x9F, 0x83, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xC0, 0xFC,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x83,
  0xE0, 0x7F, 0xF0, 0x7C, 0x0F, 0xFE, 0x0F, 0xC3, 0xF7, 0xC3, 0xF8, 0x7E,
  0xF8, 0x7F, 0x0F, 0x9F, 0x0F, 0xE1, 0xF3, 0xF1, 0xFC, 0x3E, 0x7E, 0x3F,
  0xC7, 0xC7, 0xC7, 0xF9, 0xF8, 0xF9, 0xFF, 0x3F, 0x1F, 0x3F, 0xE7, 0xC3,
  0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9F, 0x0F, 0xDE, 0xFB, 0xE0, 0xFF, 0xDF,
  0x7C, 0x1F, 0xF9, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x9F, 0x81,
  0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFB, 0xF0, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0xFE,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x03, 0xF1,
  0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x77, 0x87, 0xBC, 0x3C, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1, 0xFF, 0x87, 0xF8,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x00, 0x3E, 0x07, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0x7E, 0x7E, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0x9F, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xF0, 0x07, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C, 0x3F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7F, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F,
  0x9F, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xF3,
  0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x0C, 0x7F,
  0xBE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xE1,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x07, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x3F,
  0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7D, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x20, 0x3E, 0x1C, 0x7F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x33,
  0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0F,
  0x87, 0xE3, 0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x7F,
  0xBF, 0xDF, 0xCF, 0xE7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7F,
  0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x9F, 0x87, 0xDF, 0x83, 0xEF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xEF, 0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3F,
  0x3E, 0x1F, 0x9F, 0x07, 0xEF, 0x83, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xF0, 0x7C, 0x7D, 0xFC, 0xFF, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xEF, 0xFB, 0xFF, 0xE3, 0xF8, 0xFF,
  0xE0, 0xF8, 0x7F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF8, 0xF9,
  0xF1, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7,
  0xF7, 0xF3, 0xF0, 0xF9, 0xF0, 0x7E, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC,
  0x3E, 0x7F, 0x7F, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00,
  0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x8F,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF9, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xDF, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF,
  0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xC7, 0xF8, 0x7F,
  0x0F, 0xE0, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xF9, 0xFD, 0xF1, 0xF3, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3E, 0xFC, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x78, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF1, 0xFF, 0xC3, 0xE3,
  0xE7, 0xCF, 0xC7, 0xCF, 0x9F, 0xCF, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F, 0x3C,
  0x7D, 0xFE, 0x78, 0x7B, 0xFD, 0xF0, 0xF7, 0xBF, 0xE1, 0xFF, 0x7F, 0xC3,
  0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFC,
  0x7E, 0x7C, 0x7C, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x1F, 0xBE, 0x0F,
  0xDF, 0x87, 0xCF, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7E,
  0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0xFC, 0x3E, 0x0F, 0x83, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0E, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0x1C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0xC3, 0xF0, 0x7C, 0x3F, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xC0,
  0x40, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x1F, 0xFF,
  0xFF, 0xBC, 0x7F, 0xEF, 0x0F, 0xF3, 0xC1, 0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 10, 10, 13, 1, -29 },
  { 35, 18, 28, 21, 1, -28 },
  { 98, 16, 36, 20, 2, -32 },
  { 170, 21, 28, 25, 2, -28 },
  { 244, 21, 28, 23, 1, -28 },
  { 318, 4, 11, 6, 1, -29 },
  { 324, 10, 40, 13, 2, -31 },
  { 374, 10, 40, 13, 1, -31 },
  { 424, 16, 17, 18, 1, -28 },
  { 458, 16, 20, 19, 1, -23 },
  { 498, 6, 12, 10, 1, -5 },
  { 507, 10, 4, 14, 2, -14 },
  { 512, 7, 6, 11, 2, -6 },
  { 518, 12, 30, 13, 0, -28 },
  { 563, 16, 28, 20, 2, -28 },
  { 619, 11, 28, 20, 3, -28 },
  { 658, 17, 28, 20, 1, -28 },
  { 718, 17, 28, 20, 1, -28 },
  { 778, 17, 28, 20, 1, -28 },
  { 838, 16, 28, 20, 2, -28 },
  { 894, 16, 28, 20, 2, -28 },
  { 950, 17, 28, 20, 1, -28 },
  { 1010, 16, 28, 20, 2, -28 },
  { 1066, 16, 28, 20, 2, -28 },
  { 1122, 7, 22, 11, 2, -22 },
  { 1142, 7, 29, 10, 1, -22 },
  { 1168, 14, 18, 17, 1, -21 },
  { 1200, 14, 13, 20, 3, -18 },
  { 1223, 14, 18, 18, 2, -21 },
  { 1255, 15, 28, 17, 1, -28 },
  { 1308, 27, 36, 30, 1, -27 },
  { 1430, 23, 28, 23, 0, -28 },
  { 1511, 18, 28, 22, 2, -28 },
  { 1574, 19, 28, 22, 2, -28 },
  { 1641, 18, 28, 22, 2, -28 },
  { 1704, 16, 28, 19, 2, -28 },
  { 1760, 16, 28, 19, 2, -28 },
  { 1816, 19, 28, 23, 2, -28 },
  { 1883, 20, 28, 24, 2, -28 },
  { 1953, 6, 28, 11, 2, -28 },
  { 1974, 16, 28, 19, 1, -28 },
  { 2030, 20, 28, 22, 2, -28 },
  { 2100, 16, 28, 19, 2, -28 },
  { 2156, 25, 28, 30, 2, -28 },
  { 2244, 20, 28, 24, 2, -28 },
  { 2314, 20, 28, 24, 2, -28 },
  { 2384, 19, 28, 22, 2, -28 },
  { 2451, 20, 33, 24, 2, -28 },
  { 2534, 19, 28, 22, 2, -28 },
  { 2601, 19, 28, 21, 1, -28 },
  { 2668, 19, 28, 21, 1, -28 },
  { 2735, 18, 28, 22, 2, -28 },
  { 2798, 22, 28, 23, 0, -28 },
  { 2875, 27, 28, 29, 1, -28 },
  { 2970, 20, 28, 22, 1, -28 },
  { 3040, 21, 28, 21, 0, -28 },
  { 3114, 18, 28, 21, 1, -28 },
  { 3177, 7, 38, 10, 2, -32 },
  { 3211, 15, 30, 15, 0, -28 },
  { 3268, 7, 38, 10, 1, -32 },
  { 3302, 13, 14, 15, 1, -28 },
  { 3325, 15, 4, 16, 0, 0 },
  { 3333, 10, 6, 13, 1, -29 },
  { 3341, 16, 21, 18, 1, -21 },
  { 3383, 16, 29, 19, 2, -29 },
  { 3441, 16, 21, 18, 1, -21 },
  { 3483, 16, 29, 19, 1, -29 },
  { 3541, 17, 21, 19, 1, -21 },
  { 3586, 11, 29, 13, 1, -29 },
  { 3626, 17, 29, 20, 1, -21 },
  { 3688, 15, 29, 19, 2, -29 },
  { 3743, 6, 30, 10, 2, -30 },
  { 3766, 9, 38, 10, -1, -30 },
  { 3809, 17, 29, 19, 2, -29 },
  { 3871, 6, 29, 10, 2, -29 },
  { 3893, 25, 21, 29, 2, -21 },
  { 3959, 15, 21, 19, 2, -21 },
  { 3999, 17, 21, 19, 1, -21 },
  { 4044, 16, 29, 19, 2, -21 },
  { 4102, 16, 29, 19, 1, -21 },
  { 4160, 10, 21, 13, 2, -21 },
  { 4187, 15, 21, 18, 1, -21 },
  { 4227, 11, 26, 12, 0, -26 },
  { 4263, 15, 21, 19, 2, -21 },
  { 4303, 16, 21, 18, 1, -21 },
  { 4345, 23, 21, 25, 1, -21 },
  { 4406, 16, 21, 18, 1, -21 },
  { 4448, 17, 29, 17, 0, -21 },
  { 4510, 14, 21, 18, 2, -21 },
  { 4547, 10, 37, 12, 1, -30 },
  { 4594, 4, 33, 10, 3, -28 },
  { 4611, 10, 37, 12, 1, -30 },
  { 4658, 18, 9, 22, 2, -16 },
};

const GFXfont RobotoCondensed_Bold39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_BOLD39PT7B_H_
