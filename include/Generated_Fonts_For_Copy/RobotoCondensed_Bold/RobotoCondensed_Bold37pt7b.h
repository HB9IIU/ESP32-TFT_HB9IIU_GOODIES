#ifndef _ROBOTOCONDENSED_BOLD37PT7B_H_
#define _ROBOTOCONDENSED_BOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xBC, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xE0, 0x03, 0xCE,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x1E,
  0x70, 0x0F, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xE7, 0x00,
  0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC1, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7C, 0xF8,
  0xFD, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0x80, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x38, 0x20, 0xE3, 0xC7, 0x0E, 0x3C,
  0xF0, 0xE3, 0xCE, 0x0E, 0x3D, 0xE0, 0xF3, 0x9C, 0x0F, 0xFB, 0x80, 0x7F,
  0x38, 0x03, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE7, 0x80,
  0x1D, 0xFE, 0x03, 0xDF, 0xE0, 0x3B, 0xCF, 0x07, 0x3C, 0x70, 0x73, 0x87,
  0x0E, 0x38, 0x70, 0xE3, 0xC7, 0x1C, 0x3C, 0xF0, 0x41, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E,
  0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x3C, 0x3F, 0xE3, 0xC7, 0xDF, 0x3C, 0x7D, 0xFB, 0xCF, 0x8F, 0xFC,
  0xF8, 0x7F, 0xCF, 0xC7, 0xF8, 0xFC, 0x3F, 0x87, 0xE7, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0x01, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x10, 0x40, 0x70, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x04,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x06, 0x1C, 0x13,
  0xCE, 0x79, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0xEF, 0x01, 0xE3, 0x80, 0xF1, 0xE0, 0x70, 0x70, 0x00, 0x20, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0xF3, 0xCF, 0x7D, 0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x31, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xCF, 0xDF, 0x8F, 0xBE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC7, 0xCF, 0x9F, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F,
  0x80, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7C, 0x3E, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x78, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF7, 0xC1, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0xDF, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x00,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xF3, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF,
  0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xF7, 0xC3, 0xEF, 0xCF, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xEF, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7C, 0xF8, 0xF9, 0xFB,
  0xF1, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3E, 0x3E, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x9F, 0x9F, 0xFF, 0x3F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF,
  0xC7, 0xEF, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F,
  0xFC, 0x1E, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x81, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x31, 0xFF, 0xFF, 0x7D, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xDF, 0x78, 0x18, 0x79,
  0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF3, 0xC1, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x8F, 0xFD, 0xFF, 0x1F, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFF,
  0xC3, 0xFC, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x3C, 0x0F, 0x83, 0x8E,
  0x07, 0xF0, 0xE3, 0x83, 0xFE, 0x39, 0xE1, 0xF7, 0x87, 0x70, 0xF1, 0xE1,
  0xDC, 0x3C, 0x78, 0x77, 0x0E, 0x1E, 0x1D, 0xC7, 0x87, 0x87, 0x71, 0xE1,
  0xE1, 0xFC, 0x78, 0x70, 0x7F, 0x1E, 0x1C, 0x1F, 0xC7, 0x87, 0x0E, 0x71,
  0xE1, 0xC3, 0x9C, 0x78, 0xF0, 0xE7, 0x1F, 0x7E, 0x71, 0xC3, 0xFF, 0xFC,
  0x78, 0xFE, 0xFE, 0x1E, 0x0E, 0x1E, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x0C, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x3C,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xFC, 0x0F, 0x9F, 0xCF, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x8F, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81,
  0xF7, 0xC7, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xBF, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0xE7, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC7, 0xFF, 0xDF, 0x9F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xDF, 0x03, 0xFB, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0x87, 0xF1,
  0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03,
  0xEF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0x9F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x0F, 0xDF,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xDF,
  0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE7, 0xDF, 0xFB, 0xE7, 0x9F,
  0xF9, 0xE7, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F,
  0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xEF, 0x1F, 0xFD,
  0xF3, 0xFF, 0x9E, 0x7F, 0xF3, 0xEF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB, 0xF8, 0xF8,
  0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x03, 0xE7, 0xC0,
  0xFC, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F,
  0xBE, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB, 0xF8,
  0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x03, 0xE7,
  0xC0, 0xFC, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x40, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8,
  0x7F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07,
  0xEF, 0x81, 0xFB, 0xE1, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8,
  0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F,
  0x9F, 0x07, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0x9F, 0xCF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xFB, 0xFD, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7C, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE7,
  0xC7, 0xF0, 0xF9, 0xF1, 0xFE, 0x3E, 0x7C, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7,
  0xC3, 0xE7, 0xF9, 0xF0, 0xFB, 0xFE, 0x7C, 0x3E, 0xFF, 0x9F, 0x0F, 0xBC,
  0xF7, 0xC3, 0xEF, 0x3D, 0xE0, 0x7B, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xFF, 0x81, 0xF9, 0xF8, 0x3F,
  0x3F, 0x07, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x07, 0xEF, 0xC0, 0x7D, 0xF0,
  0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7E, 0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xF0, 0x7C, 0x3F, 0x1F, 0x83, 0xE3,
  0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80, 0xFC, 0x7C, 0x03, 0xF7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xF7, 0x07, 0xBC, 0x79, 0xE3, 0xC7, 0x1E,
  0x3D, 0xE1, 0xEF, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0xFE,
  0x3F, 0xFD, 0xFF, 0xFB, 0xF3, 0xF7, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x7F, 0xFE, 0xFF, 0xFC, 0xFE, 0xF8, 0x79, 0xF0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF9, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7,
  0xCF, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7, 0xCF,
  0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x07, 0xDF, 0x0F, 0xBF, 0x3F, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xBE, 0x3F, 0xFC, 0xFF,
  0xFB, 0xFF, 0xF7, 0xE7, 0xEF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDF, 0x0F, 0xBF,
  0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0x78, 0x7C, 0xF0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x1E, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x04, 0x7E, 0x1C, 0x3F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x03,
  0xF0, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xF3, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x9F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x7F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F,
  0x10, 0x3F, 0x18, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF9, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0x7F, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8,
  0xFC, 0xF8, 0xFC, 0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xF9,
  0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xFF, 0xFB,
  0xFC, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0xFF, 0x3E, 0xF8, 0x7C,
  0x3E, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C,
  0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C,
  0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C,
  0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF9, 0xF3, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F,
  0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF9, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x1F, 0xFE, 0x3E, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xCF, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x0F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xE7,
  0xEF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xDF, 0x0F, 0xBF, 0x3F, 0x7F, 0xFE, 0x7F,
  0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7D, 0xE1, 0xF7, 0xC0, 0x1F, 0x80, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF,
  0x1F, 0x7F, 0xFD, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x8F, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF,
  0xF7, 0xFB, 0xC7, 0xCF, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x78, 0x7F, 0xE1,
  0xE1, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0x78, 0xFC, 0xF9, 0xE3, 0xF3,
  0xE7, 0xDF, 0xCF, 0x1F, 0x7F, 0x3C, 0x7D, 0xFC, 0xF0, 0xF7, 0x7F, 0xC3,
  0xFD, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x81, 0xF8,
  0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0xF8, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xF7, 0xC3, 0xEF,
  0x87, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x7E, 0xF8, 0xF8,
  0xFB, 0xF1, 0xF7, 0xC1, 0xF0, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x03, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0xFC, 0x7C, 0x3E, 0x1F, 0x87, 0xC1,
  0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0xC1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F,
  0x87, 0xC3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x08, 0x00, 0x1E, 0x00,
  0x1F, 0x83, 0xDF, 0xE1, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7, 0x8F, 0xFB, 0xC3,
  0xF8, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 10, 10, 12, 1, -28 },
  { 34, 17, 26, 20, 1, -26 },
  { 90, 15, 34, 19, 2, -30 },
  { 154, 20, 26, 24, 2, -26 },
  { 219, 20, 26, 21, 1, -26 },
  { 284, 4, 10, 6, 1, -28 },
  { 289, 9, 37, 12, 2, -29 },
  { 331, 9, 37, 12, 1, -29 },
  { 373, 17, 16, 17, 0, -26 },
  { 407, 15, 19, 18, 1, -22 },
  { 443, 6, 11, 9, 1, -4 },
  { 452, 9, 4, 13, 2, -13 },
  { 457, 6, 6, 11, 2, -6 },
  { 462, 12, 28, 12, 0, -26 },
  { 504, 15, 26, 19, 2, -26 },
  { 553, 10, 26, 19, 3, -26 },
  { 586, 16, 26, 19, 1, -26 },
  { 638, 16, 26, 19, 1, -26 },
  { 690, 16, 26, 19, 1, -26 },
  { 742, 15, 26, 19, 2, -26 },
  { 791, 15, 26, 19, 2, -26 },
  { 840, 16, 26, 19, 1, -26 },
  { 892, 15, 26, 19, 2, -26 },
  { 941, 15, 26, 19, 2, -26 },
  { 990, 6, 21, 10, 2, -21 },
  { 1006, 7, 28, 9, 1, -21 },
  { 1031, 13, 18, 17, 1, -20 },
  { 1061, 14, 12, 19, 2, -18 },
  { 1082, 14, 17, 17, 2, -20 },
  { 1112, 14, 26, 17, 1, -26 },
  { 1158, 26, 34, 28, 1, -26 },
  { 1269, 22, 26, 22, 0, -26 },
  { 1341, 17, 26, 21, 2, -26 },
  { 1397, 18, 26, 21, 2, -26 },
  { 1456, 17, 26, 21, 2, -26 },
  { 1512, 15, 26, 18, 2, -26 },
  { 1561, 15, 26, 18, 2, -26 },
  { 1610, 18, 26, 22, 2, -26 },
  { 1669, 19, 26, 23, 2, -26 },
  { 1731, 6, 26, 10, 2, -26 },
  { 1751, 15, 26, 18, 1, -26 },
  { 1800, 19, 26, 20, 2, -26 },
  { 1862, 15, 26, 18, 2, -26 },
  { 1911, 24, 26, 28, 2, -26 },
  { 1989, 19, 26, 23, 2, -26 },
  { 2051, 19, 26, 22, 2, -26 },
  { 2113, 18, 26, 21, 2, -26 },
  { 2172, 19, 31, 22, 2, -26 },
  { 2246, 18, 26, 20, 2, -26 },
  { 2305, 18, 26, 20, 1, -26 },
  { 2364, 18, 26, 20, 1, -26 },
  { 2423, 17, 26, 21, 2, -26 },
  { 2479, 21, 26, 21, 0, -26 },
  { 2548, 26, 26, 28, 1, -26 },
  { 2633, 19, 26, 21, 1, -26 },
  { 2695, 20, 26, 20, 0, -26 },
  { 2760, 17, 26, 20, 1, -26 },
  { 2816, 7, 37, 10, 2, -31 },
  { 2849, 15, 28, 14, 0, -26 },
  { 2902, 7, 37, 10, 1, -31 },
  { 2935, 13, 13, 14, 1, -26 },
  { 2957, 14, 4, 15, 0, 0 },
  { 2964, 9, 6, 12, 1, -28 },
  { 2971, 15, 20, 17, 1, -20 },
  { 3009, 15, 28, 18, 2, -28 },
  { 3062, 15, 20, 17, 1, -20 },
  { 3100, 15, 28, 18, 1, -28 },
  { 3153, 16, 20, 18, 1, -20 },
  { 3193, 11, 28, 12, 1, -28 },
  { 3232, 16, 28, 19, 1, -20 },
  { 3288, 14, 28, 18, 2, -28 },
  { 3337, 5, 27, 9, 2, -27 },
  { 3354, 8, 35, 9, -1, -27 },
  { 3389, 16, 28, 18, 2, -28 },
  { 3445, 5, 28, 9, 2, -28 },
  { 3463, 24, 20, 27, 2, -20 },
  { 3523, 14, 20, 18, 2, -20 },
  { 3558, 16, 20, 18, 1, -20 },
  { 3598, 15, 28, 18, 2, -20 },
  { 3651, 15, 28, 18, 1, -20 },
  { 3704, 10, 20, 12, 2, -20 },
  { 3729, 14, 20, 17, 1, -20 },
  { 3764, 11, 24, 11, 0, -24 },
  { 3797, 14, 20, 18, 2, -20 },
  { 3832, 16, 20, 17, 0, -20 },
  { 3872, 22, 20, 23, 1, -20 },
  { 3927, 15, 20, 17, 1, -20 },
  { 3965, 16, 28, 16, 0, -20 },
  { 4021, 14, 20, 17, 1, -20 },
  { 4056, 9, 36, 11, 1, -29 },
  { 4097, 3, 31, 9, 3, -26 },
  { 4109, 9, 36, 11, 1, -29 },
  { 4150, 17, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_Bold37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_BOLD37PT7B_H_
