#ifndef _ROBOTOCONDENSED_BOLD67PT7B_H_
#define _ROBOTOCONDENSED_BOLD67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9,
  0xFC, 0x0C, 0x00, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8,
  0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x3F, 0xE0,
  0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x01,
  0xC0, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x83, 0xE0,
  0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xE1, 0xF0, 0x03, 0xF8, 0x3F,
  0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0xF8, 0x00, 0x7F, 0x3F, 0x8F, 0xC0, 0x03,
  0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0xFF, 0xC7, 0xE0, 0x00, 0x3F, 0xFE, 0x3E,
  0x00, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x03, 0xF1, 0xFF, 0xC0,
  0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x0F, 0xCF,
  0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0xFE,
  0x03, 0xE0, 0x3F, 0x87, 0xE0, 0x06, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0x80, 0xFF,
  0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0x83, 0xFE, 0xFF, 0xC7, 0xF8,
  0x3F, 0xEF, 0xFE, 0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xF8, 0x7F, 0xC3, 0xFF,
  0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x00, 0x04,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x04, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78,
  0x0F, 0x80, 0x63, 0xF0, 0x7C, 0x1F, 0x9F, 0xF3, 0xE3, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x3E, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0x81, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF,
  0x80, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00,
  0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF,
  0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x83,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0xC0, 0x07,
  0xFB, 0xFF, 0x00, 0x1F, 0xCF, 0xFC, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xF8,
  0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0x00, 0x7F, 0x0F, 0xFC, 0x03, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0x01, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x03, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xE0, 0x08,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x07, 0xFC,
  0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF0, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF,
  0x3F, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03,
  0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF9, 0xFF, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x3F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFD, 0xFF, 0x1F, 0xC0, 0xE0, 0x0F, 0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF,
  0x0F, 0xE0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0xFF,
  0x01, 0xF0, 0xFC, 0x01, 0xFF, 0xFE, 0x07, 0xE3, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0x9F, 0xC0, 0x3F, 0xFF, 0xE0, 0x7E, 0x7E, 0x01, 0xFE, 0x1F, 0x80,
  0xF9, 0xF8, 0x0F, 0xF0, 0x7E, 0x03, 0xE7, 0xE0, 0x3F, 0x81, 0xF8, 0x0F,
  0x9F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xBF, 0x03,
  0xF8, 0x0F, 0xC0, 0x3E, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFB, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xEF, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xBF, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF3, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x3F, 0x03, 0xFC, 0x3F,
  0xC1, 0xF8, 0xFC, 0x0F, 0xF9, 0xFF, 0x07, 0xE3, 0xF8, 0x1F, 0xFF, 0xFF,
  0x7F, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0xFF, 0xF7, 0xFF,
  0xE0, 0x7E, 0x01, 0xFF, 0x8F, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xF0,
  0x03, 0xF0, 0x03, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F,
  0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFE,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE,
  0x3F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF,
  0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x0F,
  0xFE, 0x7F, 0xC0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0xE0, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F,
  0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F,
  0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xCF,
  0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xCF, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFE,
  0x3F, 0xE0, 0x07, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF,
  0xF7, 0xFC, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xFF,
  0xEF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFD, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x9F,
  0xE0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFC, 0x1F, 0xC7, 0xFF, 0xFE, 0x7F, 0xC7,
  0xF8, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3,
  0xFF, 0xFF, 0x1F, 0xE7, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xDF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC, 0xFF,
  0x87, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0xF0,
  0x7F, 0xDF, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x07,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x3F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x7F, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x7F, 0x1F, 0xF0, 0x07,
  0xF8, 0xFE, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0xFE, 0x7F, 0x9F, 0xE0, 0x07,
  0xFD, 0xFE, 0x7F, 0x9F, 0xE0, 0x07, 0xFD, 0xFE, 0x3F, 0xBF, 0xE0, 0x07,
  0xFD, 0xFE, 0x3F, 0xBF, 0xE0, 0x03, 0xFD, 0xFC, 0x3F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFC, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFE, 0x7F,
  0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8,
  0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF8, 0x0F, 0xFB,
  0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x0F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC1, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xDF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF,
  0xF0, 0xFF, 0x9F, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x00,
  0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x1F, 0xF3, 0xFF,
  0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7C, 0x1F, 0xF0, 0x3F, 0xF1,
  0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0,
  0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0x3F, 0xF1, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8,
  0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x08, 0x3F,
  0xF0, 0x03, 0x87, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0x07, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F,
  0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xF9, 0xFF, 0x00,
  0x3C, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x06, 0x00, 0x3F, 0xF0, 0x78, 0x07, 0xFF, 0x0F, 0xF1, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x78, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x9F, 0xFE, 0x1F, 0xF7, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xDF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFC, 0x0E, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F,
  0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0x7F, 0xC0, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x1F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xC3,
  0xFE, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xDF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x7F,
  0xF8, 0x7F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x0F,
  0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB,
  0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF,
  0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xFE, 0x0F, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xC1, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x07, 0xFF,
  0xDF, 0xF0, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE,
  0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFD, 0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0x3F, 0xF1, 0xFF, 0x00, 0x7C, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xBF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF9, 0xFF, 0xC7, 0xFE, 0x7F, 0xC0, 0xFF,
  0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xE1, 0xFF, 0xE7, 0xFC, 0x1F, 0xF8, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x9F, 0xF0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F,
  0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x7F, 0xC0,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x3F, 0xC1, 0xFF, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x83, 0xFE, 0x3F,
  0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0xC3, 0xFC, 0x3F, 0xE3, 0xFF,
  0xC3, 0xFC, 0x1F, 0xE3, 0xFF, 0xC3, 0xFC, 0x1F, 0xE3, 0xFF, 0xC7, 0xFC,
  0x1F, 0xE3, 0xFF, 0xE7, 0xF8, 0x1F, 0xE7, 0xFF, 0xE7, 0xF8, 0x1F, 0xE7,
  0xFF, 0xE7, 0xF8, 0x0F, 0xF7, 0xF7, 0xE7, 0xF8, 0x0F, 0xF7, 0xF7, 0xF7,
  0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE,
  0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x9F,
  0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFB, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x3F,
  0xFC, 0x03, 0xF8, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF,
  0xF8, 0x3F, 0xCF, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F,
  0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xE7, 0xF0, 0x0F,
  0xFF, 0x8F, 0xE0, 0x0F, 0xFE, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00,
};

const GFXglyph RobotoCondensed_Bold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 49, 17, 4, -48 },
  { 63, 17, 18, 22, 2, -50 },
  { 102, 31, 48, 35, 2, -48 },
  { 288, 28, 63, 34, 3, -56 },
  { 509, 37, 50, 43, 3, -49 },
  { 741, 36, 50, 39, 2, -49 },
  { 966, 7, 18, 11, 2, -50 },
  { 982, 16, 68, 22, 4, -53 },
  { 1118, 16, 68, 22, 2, -53 },
  { 1254, 29, 29, 30, 1, -48 },
  { 1360, 28, 35, 32, 2, -40 },
  { 1483, 12, 20, 16, 1, -8 },
  { 1513, 16, 8, 24, 4, -25 },
  { 1529, 11, 10, 19, 4, -9 },
  { 1543, 21, 52, 22, 0, -48 },
  { 1680, 28, 50, 34, 3, -49 },
  { 1855, 18, 48, 34, 5, -48 },
  { 1963, 29, 49, 34, 2, -49 },
  { 2141, 29, 50, 34, 2, -49 },
  { 2323, 30, 48, 34, 2, -48 },
  { 2503, 28, 49, 34, 3, -48 },
  { 2675, 28, 49, 34, 3, -48 },
  { 2847, 29, 48, 34, 2, -48 },
  { 3021, 28, 50, 34, 3, -49 },
  { 3196, 27, 49, 34, 3, -49 },
  { 3362, 11, 37, 18, 4, -36 },
  { 3413, 12, 48, 17, 2, -36 },
  { 3485, 24, 32, 30, 2, -36 },
  { 3581, 25, 22, 34, 4, -32 },
  { 3650, 24, 31, 30, 4, -36 },
  { 3743, 25, 50, 30, 2, -49 },
  { 3900, 46, 61, 51, 3, -46 },
  { 4251, 38, 48, 40, 1, -48 },
  { 4479, 30, 48, 38, 4, -48 },
  { 4659, 33, 50, 38, 3, -49 },
  { 4866, 31, 48, 38, 4, -48 },
  { 5052, 27, 48, 33, 4, -48 },
  { 5214, 26, 48, 32, 4, -48 },
  { 5370, 33, 50, 39, 3, -49 },
  { 5577, 33, 48, 41, 4, -48 },
  { 5775, 10, 48, 18, 4, -48 },
  { 5835, 28, 49, 33, 1, -48 },
  { 6007, 33, 48, 37, 4, -48 },
  { 6205, 26, 48, 32, 4, -48 },
  { 6361, 43, 48, 51, 4, -48 },
  { 6619, 33, 48, 41, 4, -48 },
  { 6817, 34, 50, 40, 3, -49 },
  { 7030, 32, 48, 38, 4, -48 },
  { 7222, 34, 58, 40, 3, -49 },
  { 7469, 32, 48, 37, 4, -48 },
  { 7661, 32, 50, 36, 2, -49 },
  { 7861, 33, 48, 36, 2, -48 },
  { 8059, 32, 49, 38, 3, -48 },
  { 8255, 37, 48, 39, 1, -48 },
  { 8477, 48, 48, 50, 1, -48 },
  { 8765, 35, 48, 37, 1, -48 },
  { 8975, 35, 48, 36, 1, -48 },
  { 9185, 31, 48, 36, 2, -48 },
  { 9371, 12, 66, 18, 4, -55 },
  { 9470, 26, 52, 26, 0, -48 },
  { 9639, 13, 66, 18, 1, -55 },
  { 9747, 23, 24, 26, 2, -48 },
  { 9816, 25, 7, 27, 1, 0 },
  { 9838, 17, 10, 22, 2, -50 },
  { 9860, 27, 37, 32, 2, -36 },
  { 9985, 28, 51, 33, 3, -50 },
  { 10164, 27, 37, 31, 2, -36 },
  { 10289, 28, 51, 33, 2, -50 },
  { 10468, 27, 37, 32, 3, -36 },
  { 10593, 20, 51, 22, 1, -51 },
  { 10721, 28, 50, 34, 2, -36 },
  { 10896, 27, 50, 33, 3, -50 },
  { 11065, 10, 49, 17, 3, -49 },
  { 11127, 15, 63, 16, -2, -49 },
  { 11246, 29, 50, 32, 3, -50 },
  { 11428, 9, 50, 17, 4, -50 },
  { 11485, 43, 36, 50, 3, -36 },
  { 11679, 27, 36, 33, 3, -36 },
  { 11801, 29, 37, 33, 2, -36 },
  { 11936, 28, 50, 33, 3, -36 },
  { 12111, 28, 50, 33, 2, -36 },
  { 12286, 18, 36, 22, 3, -36 },
  { 12367, 26, 37, 30, 2, -36 },
  { 12488, 18, 45, 21, 1, -44 },
  { 12590, 27, 36, 33, 3, -35 },
  { 12712, 28, 35, 30, 1, -35 },
  { 12835, 40, 35, 42, 1, -35 },
  { 13010, 28, 35, 30, 1, -35 },
  { 13133, 28, 49, 30, 1, -35 },
  { 13305, 25, 35, 30, 3, -35 },
  { 13415, 16, 64, 20, 2, -52 },
  { 13543, 5, 57, 17, 6, -48 },
  { 13579, 16, 64, 20, 2, -52 },
  { 13707, 31, 15, 37, 3, -27 },
};

const GFXfont RobotoCondensed_Bold67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_BOLD67PT7B_H_
