#ifndef _ROBOTOCONDENSED_BOLD52PT7B_H_
#define _ROBOTOCONDENSED_BOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x01,
  0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03,
  0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x8F, 0x80, 0x0F,
  0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x83, 0xF8, 0xFF,
  0xBF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x80, 0x3E, 0x3E, 0x06, 0x01, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x83,
  0xC0, 0xF8, 0x3C, 0x3E, 0x07, 0xC1, 0xE1, 0xE0, 0x3E, 0x0F, 0x1F, 0x00,
  0xF0, 0xF8, 0xF0, 0x07, 0xC7, 0xCF, 0x80, 0x3F, 0xFE, 0x78, 0x00, 0xFF,
  0xE7, 0xC0, 0x07, 0xFE, 0x3C, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x08, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x07, 0xCF, 0xFC, 0x00,
  0x3C, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0x80, 0x1E, 0x7E, 0x3E, 0x01, 0xF3,
  0xE1, 0xF0, 0x0F, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x7C, 0x07, 0x87, 0xC3,
  0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x1E, 0x0F, 0xC7, 0xC0,
  0x60, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0x0F, 0xFF, 0xC7, 0xE3,
  0xFB, 0xFC, 0xFC, 0xFF, 0x3F, 0xDF, 0x9F, 0xC7, 0xFF, 0xF3, 0xF8, 0x7F,
  0xFC, 0x7F, 0x07, 0xFF, 0x8F, 0xE0, 0xFF, 0xF1, 0xFC, 0x0F, 0xFC, 0x3F,
  0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFC, 0x0F,
  0xFC, 0x3F, 0xC0, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xEF, 0x78, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x20,
  0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x02,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x07, 0x81, 0x9F, 0x1E, 0x3E,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xCF,
  0x80, 0x7E, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0E, 0x03, 0xC0,
  0x00, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xDF, 0xEF, 0xF3, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F,
  0xE1, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0x9F, 0xC1,
  0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0x1F, 0xC1, 0xFE, 0xFF, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xBF, 0xC1, 0xFE, 0x7F, 0xDF, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3E,
  0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x87, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F,
  0x9F, 0xFB, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0x03, 0xFB, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xFB, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F,
  0x8F, 0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xF1, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0x9F, 0xE0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFE, 0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F,
  0x07, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD,
  0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xCF,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xDF, 0xEF, 0xF3, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD,
  0xFE, 0xFF, 0xFF, 0x9F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x87,
  0x81, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x3C, 0x3E,
  0x01, 0xFF, 0x03, 0xE3, 0xE0, 0x3F, 0xFC, 0x3E, 0x3E, 0x07, 0xFF, 0xC1,
  0xE7, 0xC0, 0xFF, 0xFC, 0x1E, 0x7C, 0x0F, 0x87, 0xC1, 0xE7, 0xC1, 0xF8,
  0x7C, 0x1F, 0x7C, 0x1F, 0x07, 0xC1, 0xF7, 0x83, 0xF0, 0x7C, 0x1F, 0xF8,
  0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1,
  0xFF, 0x83, 0xE0, 0x78, 0x1F, 0xF8, 0x7E, 0x0F, 0x81, 0xFF, 0x87, 0xE0,
  0xF8, 0x1E, 0xF8, 0x7E, 0x0F, 0x81, 0xEF, 0x87, 0xE0, 0xF8, 0x1E, 0xF8,
  0x7E, 0x0F, 0x83, 0xEF, 0x87, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x1F, 0x83,
  0xCF, 0x83, 0xF3, 0xF8, 0x7C, 0x78, 0x3F, 0xFF, 0xFF, 0x87, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7C, 0x1F, 0xF3, 0xFE, 0x07, 0xC0, 0xFE, 0x1F, 0xC0, 0x3E,
  0x01, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0x80, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF,
  0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x3F,
  0xEF, 0xE0, 0x1F, 0xF3, 0xF8, 0x07, 0xFC, 0xFE, 0x03, 0xFE, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x87, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0,
  0x3F, 0x9F, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0x80,
  0xFF, 0x9F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F,
  0xE0, 0xFE, 0x07, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xFB,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFD, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF,
  0xF8, 0x1F, 0xBF, 0xFE, 0xFC, 0x1F, 0xBF, 0xFF, 0x7E, 0x0F, 0xDF, 0xFF,
  0xBF, 0x87, 0xEF, 0xFF, 0xCF, 0xC7, 0xE7, 0xFF, 0xE7, 0xE3, 0xF3, 0xFF,
  0xF3, 0xF9, 0xF9, 0xFF, 0xF9, 0xFC, 0xFC, 0xFF, 0xFC, 0x7E, 0xFC, 0x7F,
  0xFE, 0x3F, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xE1,
  0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFE, 0x07, 0xF8,
  0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF8, 0x7F, 0xFE, 0xFE,
  0x1F, 0xFF, 0x9F, 0xC7, 0xFF, 0xE7, 0xF1, 0xFF, 0xF8, 0xFE, 0x7F, 0xFE,
  0x3F, 0x9F, 0xFF, 0x87, 0xF7, 0xFF, 0xE1, 0xFD, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC,
  0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xF8, 0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x7F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80,
  0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xF9, 0xFC, 0x03, 0xFC,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F,
  0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03,
  0xFC, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC,
  0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1,
  0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xDF,
  0xC0, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0,
  0x7F, 0x3F, 0x81, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xF8, 0x1F, 0xC7, 0xF0,
  0x7F, 0xC1, 0xFE, 0x3F, 0x83, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xF0, 0x7F,
  0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0xF0, 0xFE, 0x0F, 0xE3, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xFC, 0x7F, 0x03,
  0xF8, 0xFB, 0xF3, 0xF8, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0xFE, 0x7E, 0xFC,
  0xFE, 0x07, 0xF3, 0xF7, 0xE7, 0xF0, 0x1F, 0x9F, 0xBF, 0x3F, 0x00, 0xFE,
  0xF8, 0xFB, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07,
  0xF9, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE,
  0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0x7F,
  0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xBE, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xE7, 0xE0, 0xF9,
  0xF8, 0x3E, 0x7C, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xE1, 0xFE, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xF8, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xFC, 0x7F, 0xDF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xC7,
  0xF0, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xCF, 0xDF, 0xFE, 0x7E, 0xFF, 0xE3, 0xF1, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xDF, 0xF7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xDF, 0xF7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x3F,
  0x8F, 0xFD, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFD, 0xFC, 0x3F, 0xC7, 0xE0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF9, 0xFF, 0xBF, 0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x71, 0xFF, 0xDF, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE7,
  0xF1, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF,
  0x00, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x82, 0x00, 0xFE, 0x1C,
  0x07, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x08, 0x0F, 0xF3, 0xF8, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xE0, 0x18, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x00, 0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xFB, 0xF8, 0x3F, 0xCF, 0xE1,
  0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x3F, 0xC3, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8,
  0x3F, 0xBF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xFC, 0xFE,
  0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x40, 0x7E,
  0x3F, 0xC1, 0xFC, 0x3F, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0xF7, 0xFD,
  0xFC, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F,
  0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F,
  0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x3F, 0xBF, 0xF9, 0xFD,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFC, 0xFE, 0x0F, 0xE0, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFE, 0xFE, 0x1F, 0xE7, 0xF0, 0x08, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x40, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x04, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xDF,
  0xC3, 0xFC, 0xFE, 0x01, 0x00, 0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0xFE,
  0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x7F, 0x00, 0xFD, 0xFC, 0x03,
  0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xC0,
  0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xF8, 0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x07,
  0xE7, 0xE0, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x9F, 0xC7, 0xFC, 0x7F,
  0x3F, 0x8F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF1, 0xF8, 0x7E, 0x3F, 0xE3, 0xF0,
  0xFC, 0xFF, 0xEF, 0xE1, 0xFD, 0xFF, 0xDF, 0xC1, 0xFB, 0xEF, 0xBF, 0x03,
  0xF7, 0xDF, 0x7E, 0x07, 0xFF, 0xBE, 0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE7,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE1, 0xFC,
  0x7F, 0x87, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x03, 0x80, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x70,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x03, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80,
  0x78, 0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0,
  0xFB, 0xFF, 0xC1, 0xF7, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x7C, 0x1F, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoCondensed_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 13, 14, 17, 2, -39 },
  { 62, 24, 37, 27, 2, -37 },
  { 173, 22, 49, 26, 2, -43 },
  { 308, 29, 39, 33, 2, -38 },
  { 450, 27, 39, 30, 2, -38 },
  { 582, 5, 14, 8, 2, -39 },
  { 591, 12, 53, 17, 3, -41 },
  { 671, 13, 53, 17, 1, -41 },
  { 758, 22, 22, 24, 1, -37 },
  { 819, 21, 27, 25, 2, -31 },
  { 890, 9, 16, 13, 1, -6 },
  { 908, 12, 6, 19, 3, -19 },
  { 917, 9, 8, 15, 3, -7 },
  { 926, 16, 40, 17, 0, -37 },
  { 1006, 22, 39, 26, 2, -38 },
  { 1114, 14, 37, 26, 4, -37 },
  { 1179, 22, 38, 26, 2, -38 },
  { 1284, 22, 39, 26, 2, -38 },
  { 1392, 23, 37, 26, 2, -37 },
  { 1499, 22, 38, 26, 2, -37 },
  { 1604, 21, 38, 26, 3, -37 },
  { 1704, 22, 37, 26, 2, -37 },
  { 1806, 21, 39, 26, 3, -38 },
  { 1909, 22, 38, 26, 2, -38 },
  { 2014, 9, 29, 14, 3, -28 },
  { 2047, 9, 38, 13, 2, -28 },
  { 2090, 18, 25, 23, 2, -28 },
  { 2147, 20, 17, 26, 3, -25 },
  { 2190, 19, 24, 24, 3, -28 },
  { 2247, 20, 39, 23, 1, -38 },
  { 2345, 36, 48, 40, 2, -36 },
  { 2561, 30, 37, 31, 1, -37 },
  { 2700, 24, 37, 29, 3, -37 },
  { 2811, 26, 39, 30, 2, -38 },
  { 2938, 24, 37, 29, 3, -37 },
  { 3049, 21, 37, 26, 3, -37 },
  { 3147, 20, 37, 25, 3, -37 },
  { 3240, 26, 39, 30, 2, -38 },
  { 3367, 26, 37, 32, 3, -37 },
  { 3488, 8, 37, 14, 3, -37 },
  { 3525, 22, 38, 26, 1, -37 },
  { 3630, 26, 37, 29, 3, -37 },
  { 3751, 21, 37, 25, 3, -37 },
  { 3849, 33, 37, 39, 3, -37 },
  { 4002, 26, 37, 32, 3, -37 },
  { 4123, 27, 39, 31, 2, -38 },
  { 4255, 25, 37, 30, 3, -37 },
  { 4371, 27, 45, 31, 2, -38 },
  { 4523, 25, 37, 29, 3, -37 },
  { 4639, 24, 39, 28, 2, -38 },
  { 4756, 26, 37, 28, 1, -37 },
  { 4877, 24, 38, 30, 3, -37 },
  { 4991, 29, 37, 30, 1, -37 },
  { 5126, 37, 37, 39, 1, -37 },
  { 5298, 27, 37, 29, 1, -37 },
  { 5423, 28, 37, 28, 0, -37 },
  { 5553, 24, 37, 28, 2, -37 },
  { 5664, 10, 52, 14, 3, -43 },
  { 5729, 20, 40, 20, 0, -37 },
  { 5829, 10, 52, 14, 1, -43 },
  { 5894, 18, 18, 20, 1, -37 },
  { 5935, 19, 6, 21, 1, 0 },
  { 5950, 13, 8, 17, 1, -39 },
  { 5963, 21, 29, 25, 2, -28 },
  { 6040, 21, 40, 26, 3, -39 },
  { 6145, 20, 29, 24, 2, -28 },
  { 6218, 21, 40, 26, 2, -39 },
  { 6323, 21, 29, 25, 2, -28 },
  { 6400, 15, 40, 17, 1, -40 },
  { 6475, 22, 39, 26, 2, -28 },
  { 6583, 21, 39, 26, 2, -39 },
  { 6686, 7, 38, 13, 3, -38 },
  { 6720, 11, 49, 13, -1, -38 },
  { 6788, 22, 39, 25, 3, -39 },
  { 6896, 7, 39, 13, 3, -39 },
  { 6931, 33, 28, 39, 3, -28 },
  { 7047, 21, 28, 26, 2, -28 },
  { 7121, 22, 29, 26, 2, -28 },
  { 7201, 21, 39, 26, 3, -28 },
  { 7304, 21, 39, 26, 2, -28 },
  { 7407, 13, 28, 17, 3, -28 },
  { 7453, 20, 29, 24, 2, -28 },
  { 7526, 14, 35, 16, 1, -34 },
  { 7588, 21, 28, 26, 2, -27 },
  { 7662, 22, 27, 23, 1, -27 },
  { 7737, 31, 27, 33, 1, -27 },
  { 7842, 22, 27, 24, 1, -27 },
  { 7917, 23, 38, 23, 0, -27 },
  { 8027, 19, 27, 24, 2, -27 },
  { 8092, 13, 50, 16, 1, -41 },
  { 8174, 5, 44, 13, 4, -37 },
  { 8202, 13, 50, 16, 1, -41 },
  { 8284, 23, 11, 29, 3, -21 },
};

const GFXfont RobotoCondensed_Bold52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_BOLD52PT7B_H_
