#ifndef _ROBOTOCONDENSED_BOLD30PT7B_H_
#define _ROBOTOCONDENSED_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0xFF, 0xF6,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0xC6, 0xC6, 0x07, 0x70, 0x19, 0xC0,
  0x67, 0x01, 0x9C, 0x0E, 0x60, 0x39, 0x87, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC,
  0x33, 0x80, 0xCE, 0x07, 0x30, 0x1C, 0xC3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x19, 0xC0, 0x67, 0x03, 0x98, 0x0E, 0x60, 0x39, 0x80, 0xE6, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0x1E,
  0x78, 0x7B, 0xC3, 0xDE, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0xF7, 0x8F, 0xBE, 0xF8, 0xFF,
  0xC7, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x3F,
  0x80, 0x1D, 0xC0, 0x1C, 0x63, 0x8E, 0x31, 0x87, 0x19, 0xC3, 0x8C, 0xC0,
  0xEE, 0xE0, 0x7F, 0x60, 0x1E, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x19,
  0xE0, 0x1D, 0xF8, 0x0D, 0xFC, 0x0E, 0xE7, 0x06, 0x73, 0x87, 0x39, 0xC7,
  0x1C, 0xE1, 0x8F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3D, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x3D, 0xE0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x9E, 0x7F, 0x9E, 0x7F, 0xDE,
  0xF3, 0xFC, 0xF1, 0xFC, 0xF1, 0xFC, 0xF8, 0xF8, 0x7D, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0x04, 0x1C, 0x78, 0xE3, 0x87,
  0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0F, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0x00, 0x81,
  0x83, 0x83, 0x87, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x71, 0xE3, 0x8E,
  0x1C, 0x20, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x86, 0x17, 0x33, 0xBF,
  0xFC, 0xFF, 0xC0, 0xF0, 0x0F, 0xC0, 0xEE, 0x0F, 0x38, 0x70, 0xE0, 0x04,
  0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF, 0xFF, 0xF8, 0x27, 0xBF,
  0xF7, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0x81, 0xC0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFB, 0xE7,
  0x8F, 0x3C, 0x79, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0xF3, 0xC7, 0x9F, 0x7C,
  0x7F, 0xC1, 0xFC, 0x07, 0xC0, 0x01, 0x87, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB,
  0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB,
  0xEF, 0x8F, 0x78, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x7F, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x87, 0xBF,
  0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0E, 0x78,
  0xF3, 0xC7, 0x1E, 0x78, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9E, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7B, 0xC7, 0x9F,
  0x7C, 0x7F, 0xC3, 0xFE, 0x07, 0xC0, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x3F,
  0x83, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x78, 0x7F, 0xE3, 0xFF, 0x9F, 0x7D,
  0xF1, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xCF,
  0xFC, 0x7F, 0xE1, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xFB,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x7D, 0xF1, 0xFF, 0x07, 0xF0,
  0x7F, 0xC7, 0x8F, 0x3C, 0x79, 0xE1, 0xFF, 0x0F, 0xF8, 0xFB, 0xC7, 0xDF,
  0x7C, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFB,
  0xE7, 0x8F, 0x3C, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0, 0x7F, 0xC3, 0xDE, 0x3E,
  0xFB, 0xF7, 0xFF, 0x9F, 0xF8, 0x7B, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x27, 0xBF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xFF, 0x70, 0x03, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3D, 0xEF, 0x7B, 0xDC, 0xEE, 0x30, 0x00, 0x20, 0x1C, 0x0F, 0x8F,
  0xF7, 0xFD, 0xFC, 0x3E, 0x07, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xF0,
  0x0E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xF8, 0x3F, 0x1F, 0xEF, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00,
  0x1F, 0x0F, 0xF9, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x78, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xF3, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x30, 0xE1,
  0xF1, 0xCE, 0x1F, 0xC6, 0x71, 0xFE, 0x33, 0x8E, 0x71, 0xD8, 0xE3, 0x8F,
  0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x8E, 0x38, 0xFC, 0x71,
  0xC6, 0xE3, 0x8E, 0x37, 0x1C, 0xF3, 0xB8, 0xFF, 0xB8, 0xC3, 0xFF, 0xC7,
  0x1E, 0x78, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1E, 0x1E, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0x03, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x07, 0xBE, 0x01, 0xE0, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x0F, 0x78, 0x1E, 0xF8, 0x7C, 0xFF, 0xF1, 0xFF,
  0xE1, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC,
  0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3,
  0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF,
  0x03, 0xDE, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x3C,
  0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0xF0, 0x7D,
  0xE0, 0xFB, 0xC3, 0xE7, 0x8F, 0x8F, 0x1F, 0x1E, 0x7C, 0x3C, 0xF8, 0x7B,
  0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3E, 0xF8, 0x78, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xE7, 0x87, 0xCF,
  0x07, 0xDE, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3,
  0xBF, 0xFC, 0x77, 0xFB, 0x9E, 0xFF, 0x7B, 0xDF, 0xEF, 0x73, 0xFC, 0xEE,
  0x7F, 0x9F, 0xCF, 0xF3, 0xF1, 0xFE, 0x7E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8,
  0xFF, 0x1E, 0x1F, 0xE1, 0xC3, 0xC0, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xDE, 0x7F, 0xBC, 0xFF, 0x3D, 0xFE, 0x7B, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x04, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xE3, 0xFF, 0x8F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F,
  0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFE, 0x78, 0x7B, 0xE1, 0xFF, 0x83, 0xDE, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE1, 0xF7, 0xEF, 0xDF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0xFF,
  0x9F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0xDE, 0x03,
  0xCF, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0xF0, 0x7F, 0x87, 0x87, 0xFC, 0x3E,
  0x3D, 0xE1, 0xF1, 0xEF, 0x8F, 0x8F, 0x3C, 0xFC, 0x79, 0xE7, 0xE3, 0xCF,
  0x3F, 0x1E, 0x79, 0xFD, 0xE3, 0xCF, 0xEF, 0x1E, 0x77, 0x78, 0x7F, 0xBB,
  0xC3, 0xFD, 0xDE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8,
  0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x3C, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F,
  0x7C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8,
  0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xFF, 0xFC, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF, 0xFF, 0xFC,
  0x1E, 0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x0F, 0xC7, 0x39, 0xCE, 0x73, 0xB8,
  0xFE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xE1, 0xE0,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF9, 0xF0, 0x0F, 0x1F, 0xF3, 0xFF,
  0x7C, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF1, 0xEF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x78,
  0xFF, 0xCF, 0xFE, 0xFB, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xBE, 0xFF, 0xEE, 0xFC, 0xE7, 0x80, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0x0F, 0x7D, 0xF7, 0xFE, 0x3F, 0xC0, 0xF8, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x3F,
  0xF7, 0xFF, 0xFD, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xF7, 0xFF, 0x7F, 0xF3, 0xFF, 0x1E, 0x70, 0x0F, 0x81,
  0xFF, 0x1F, 0xF8, 0xFB, 0xE7, 0x8F, 0x78, 0x7B, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x47, 0xEF, 0x3F, 0xF8, 0xFF, 0x81, 0xF8,
  0x0F, 0x8F, 0xCF, 0xC7, 0xC3, 0xC3, 0xE1, 0xF1, 0xFE, 0xFF, 0x7F, 0x9F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x1E, 0x79, 0xFF, 0xDF, 0xFE, 0xFB, 0xFF, 0x8F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xF7, 0xDF, 0xBF,
  0xFC, 0xFF, 0xE3, 0xDF, 0x00, 0xF9, 0x07, 0x8E, 0x7C, 0xFF, 0xE7, 0xFE,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xBC, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x7C, 0x78, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFB, 0xF7,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x1F, 0xF3, 0xEF, 0x3C, 0xF7, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0x78, 0xF3, 0xCF, 0x3E, 0xF3, 0xEF, 0x1F, 0xF1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE7, 0x8F, 0x1F, 0xFB, 0xFB, 0xFF, 0xFF, 0x7D, 0xFF, 0xEF, 0x1E, 0x3F,
  0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE, 0x3C, 0x3F,
  0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F,
  0x8F, 0x0F, 0xF3, 0xCF, 0x7E, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0x78, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xE7, 0xDF, 0x3F,
  0xF8, 0xFF, 0x81, 0xF0, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0xBE, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFB, 0xEF,
  0xFE, 0xFF, 0xCF, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x73, 0xFF, 0x7F, 0xFF, 0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7D, 0xF7, 0xFF, 0x3F, 0xF1,
  0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xE7, 0xDF,
  0xFF, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xF1, 0xEF, 0x80, 0x7E, 0x07, 0xF8,
  0x1F, 0xC0, 0x7E, 0x01, 0xEF, 0x0F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x8F, 0xF7, 0xFB, 0xFC, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x78,
  0x7B, 0xC7, 0xDE, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0x87, 0xBC,
  0x1D, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0xF9, 0xFE, 0x7C, 0xFF, 0x3E, 0x7B,
  0x9F, 0x39, 0xFF, 0xBC, 0xFE, 0xFE, 0x7F, 0x7F, 0x3F, 0xBF, 0x8F, 0xDF,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x38, 0x38, 0x78,
  0xFB, 0xE7, 0x8F, 0x3C, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0xC3, 0xDE, 0x1E, 0x79, 0xF3, 0xCF,
  0x0F, 0xF8, 0x7B, 0xC7, 0xDE, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0xF8, 0xF7,
  0x87, 0xBC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x06,
  0x1C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xCF, 0x1C, 0x3C,
  0x3C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0x38, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xC3, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xE3, 0xE1, 0xC7, 0x9E, 0x38, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0x86, 0x00, 0x1C, 0x1C, 0xFC, 0x77,
  0xF1, 0xDF, 0xFF, 0x73, 0xFB, 0xC7, 0xE0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 10, 1, -23 },
  { 20, 14, 22, 16, 1, -22 },
  { 59, 13, 28, 15, 1, -25 },
  { 105, 17, 22, 19, 1, -22 },
  { 152, 16, 22, 17, 1, -22 },
  { 196, 3, 8, 5, 1, -23 },
  { 199, 7, 31, 10, 2, -24 },
  { 227, 7, 31, 10, 1, -24 },
  { 255, 13, 13, 14, 0, -22 },
  { 277, 12, 16, 14, 1, -18 },
  { 301, 5, 9, 7, 1, -4 },
  { 307, 7, 3, 11, 2, -10 },
  { 310, 5, 5, 9, 2, -5 },
  { 314, 9, 24, 10, 0, -22 },
  { 341, 13, 22, 15, 1, -22 },
  { 377, 9, 22, 15, 2, -22 },
  { 402, 13, 22, 15, 1, -22 },
  { 438, 13, 22, 15, 1, -22 },
  { 474, 13, 22, 15, 1, -22 },
  { 510, 13, 22, 15, 1, -22 },
  { 546, 13, 22, 15, 1, -22 },
  { 582, 13, 22, 15, 1, -22 },
  { 618, 13, 22, 15, 1, -22 },
  { 654, 13, 22, 15, 1, -22 },
  { 690, 5, 17, 8, 2, -17 },
  { 701, 5, 22, 8, 1, -17 },
  { 715, 11, 14, 13, 1, -16 },
  { 735, 11, 9, 15, 2, -14 },
  { 748, 11, 14, 14, 2, -16 },
  { 768, 11, 22, 13, 1, -22 },
  { 799, 21, 28, 23, 1, -21 },
  { 873, 18, 22, 18, 0, -22 },
  { 923, 13, 22, 17, 2, -22 },
  { 959, 15, 22, 17, 1, -22 },
  { 1001, 14, 22, 17, 2, -22 },
  { 1040, 12, 22, 15, 2, -22 },
  { 1073, 12, 22, 14, 2, -22 },
  { 1106, 15, 22, 18, 1, -22 },
  { 1148, 15, 22, 18, 2, -22 },
  { 1190, 4, 22, 8, 2, -22 },
  { 1201, 12, 22, 15, 1, -22 },
  { 1234, 15, 22, 17, 2, -22 },
  { 1276, 12, 22, 14, 2, -22 },
  { 1309, 19, 22, 23, 2, -22 },
  { 1362, 15, 22, 18, 2, -22 },
  { 1404, 16, 22, 18, 1, -22 },
  { 1448, 14, 22, 17, 2, -22 },
  { 1487, 16, 26, 18, 1, -22 },
  { 1539, 14, 22, 17, 2, -22 },
  { 1578, 14, 22, 16, 1, -22 },
  { 1617, 15, 22, 16, 1, -22 },
  { 1659, 14, 22, 17, 2, -22 },
  { 1698, 17, 22, 17, 0, -22 },
  { 1745, 21, 22, 22, 1, -22 },
  { 1803, 16, 22, 17, 0, -22 },
  { 1847, 16, 22, 16, 0, -22 },
  { 1891, 14, 22, 16, 1, -22 },
  { 1930, 5, 30, 8, 2, -25 },
  { 1949, 12, 24, 11, 0, -22 },
  { 1985, 5, 30, 8, 1, -25 },
  { 2004, 10, 11, 12, 1, -22 },
  { 2018, 12, 3, 12, 0, 0 },
  { 2023, 7, 5, 10, 1, -23 },
  { 2028, 12, 16, 14, 1, -16 },
  { 2052, 12, 23, 15, 2, -23 },
  { 2087, 12, 16, 14, 1, -16 },
  { 2111, 12, 23, 15, 1, -23 },
  { 2146, 13, 16, 14, 1, -16 },
  { 2172, 9, 23, 10, 1, -23 },
  { 2198, 13, 22, 15, 1, -16 },
  { 2234, 12, 23, 15, 1, -23 },
  { 2269, 4, 22, 8, 2, -22 },
  { 2280, 7, 28, 7, -1, -22 },
  { 2305, 12, 23, 14, 2, -23 },
  { 2340, 4, 23, 8, 2, -23 },
  { 2352, 19, 16, 22, 2, -16 },
  { 2390, 12, 16, 15, 1, -16 },
  { 2414, 13, 16, 15, 1, -16 },
  { 2440, 12, 22, 15, 2, -16 },
  { 2473, 12, 22, 15, 1, -16 },
  { 2506, 7, 16, 10, 2, -16 },
  { 2520, 12, 16, 14, 1, -16 },
  { 2544, 9, 20, 9, 0, -20 },
  { 2567, 12, 16, 15, 1, -16 },
  { 2591, 13, 16, 13, 0, -16 },
  { 2617, 17, 16, 19, 1, -16 },
  { 2651, 13, 16, 14, 0, -16 },
  { 2677, 13, 22, 13, 0, -16 },
  { 2713, 11, 16, 14, 1, -16 },
  { 2735, 7, 28, 9, 1, -23 },
  { 2760, 2, 26, 8, 3, -22 },
  { 2767, 7, 28, 9, 1, -23 },
  { 2792, 14, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_Bold30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_BOLD30PT7B_H_
