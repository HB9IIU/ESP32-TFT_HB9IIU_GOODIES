#ifndef _ROBOTOCONDENSED_BOLD38PT7B_H_
#define _ROBOTOCONDENSED_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0xFF, 0xFD, 0xF7, 0x80, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xB8, 0xE0, 0x01,
  0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x39, 0xE0, 0x0E, 0x78, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xE0, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0x9C,
  0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7E, 0x03, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFE, 0x7E, 0x7E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8,
  0x7D, 0xFB, 0xFB, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xE7, 0x86, 0x0E, 0x3C, 0x38, 0x71, 0xE3, 0x83, 0x8F, 0x3C,
  0x1C, 0x79, 0xC0, 0xE3, 0xDE, 0x07, 0x9E, 0xE0, 0x1F, 0xEF, 0x00, 0xFE,
  0x70, 0x01, 0xE7, 0x00, 0x00, 0x38, 0x00, 0x03, 0x9F, 0x00, 0x1D, 0xFC,
  0x01, 0xDF, 0xF0, 0x1E, 0xF7, 0x80, 0xE7, 0x1C, 0x0F, 0x78, 0xF0, 0x73,
  0xC7, 0x87, 0x9E, 0x3C, 0x38, 0x71, 0xC1, 0x83, 0xCE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x3E, 0x1F, 0xE3, 0xE3, 0xFF, 0x3E, 0x7D, 0xFB, 0xE7,
  0xCF, 0xFC, 0xFC, 0xFF, 0xCF, 0xC7, 0xFC, 0xFC, 0x3F, 0x87, 0xC1, 0xF8,
  0x7F, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xE3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x01, 0xC1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x38,
  0x08, 0x40, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x1E, 0x07,
  0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x78,
  0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x06, 0x1C, 0x13, 0xCE, 0x39, 0xFF, 0xFE, 0xFF,
  0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE3, 0xC0,
  0xF1, 0xF0, 0x70, 0x70, 0x00, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0xF3,
  0xCF, 0x3D, 0xF7, 0xDE, 0xFB, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xCF, 0x8F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xBF, 0x3F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x40, 0xF0, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE7,
  0xF3, 0xE1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0x7F, 0x7C, 0x3F,
  0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xFC,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7F, 0x7F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xDF, 0x83, 0xEF, 0xC1, 0xE7, 0xE1, 0xF3, 0xF0,
  0xF1, 0xF8, 0xF8, 0xFC, 0x78, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x3E,
  0x7E, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFE, 0xFE, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x3E, 0x7E, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xFF,
  0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0xFD, 0xFB, 0xF1, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3E, 0x3E, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xBF, 0xBF, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xC7, 0xEF, 0xDF, 0x8F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F,
  0xFE, 0x1E, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x78, 0x00, 0x39, 0xFF, 0xFF, 0x7C,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xDF, 0x38,
  0x18, 0x7D, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x79, 0xE0, 0x80,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC,
  0x3F, 0xC0, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0xFF,
  0xCF, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x38, 0x00, 0x80, 0x00, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xEF, 0xDF, 0x8F, 0xBE, 0x1F,
  0xFC, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xF0, 0x3F, 0x00, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x0F, 0x83, 0xC7, 0x83, 0xFC, 0x38,
  0xE0, 0xFF, 0xC7, 0x3C, 0x3E, 0x70, 0xE7, 0x87, 0x8E, 0x1C, 0xE1, 0xE1,
  0xC3, 0xDC, 0x3C, 0x38, 0x7B, 0x87, 0x87, 0x0F, 0x71, 0xE1, 0xE1, 0xEE,
  0x3C, 0x3C, 0x39, 0xC7, 0x87, 0x87, 0x38, 0xF0, 0xF0, 0xE7, 0x1E, 0x1E,
  0x1C, 0xE3, 0xE3, 0xC7, 0x1C, 0x3E, 0xF9, 0xE3, 0xC7, 0xFF, 0xF8, 0x78,
  0x7E, 0xFF, 0x0F, 0x07, 0x8F, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBE,
  0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x1F,
  0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xC1,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x7E,
  0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x07, 0xEF, 0xC7, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E,
  0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xDF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7E,
  0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xDF, 0x83,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xF7, 0xFF, 0xF0, 0x7B, 0xFF,
  0x78, 0x7D, 0xFF, 0xBE, 0x3E, 0xFF, 0xDF, 0x1E, 0x7F, 0xE7, 0x8F, 0x7F,
  0xF3, 0xEF, 0xBF, 0xF9, 0xF7, 0x9F, 0xFC, 0xFB, 0xCF, 0xFE, 0x3F, 0xE7,
  0xFF, 0x1F, 0xF3, 0xFF, 0x8F, 0xF1, 0xFF, 0xC3, 0xF8, 0xFF, 0xE1, 0xFC,
  0x7F, 0xF0, 0xFC, 0x3F, 0xF8, 0x3E, 0x1F, 0xFC, 0x1F, 0x0F, 0xFE, 0x0F,
  0x87, 0xE0, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE,
  0x3E, 0xFF, 0xC7, 0xDF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7C, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC,
  0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1, 0xF3, 0xF0, 0x7E, 0xFC,
  0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7F, 0xBF, 0x9F, 0x83, 0xE7, 0xC0, 0xFD, 0xF0, 0x3F,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x83, 0xF7, 0xFB, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0xFB, 0xF0,
  0x7C, 0x1F, 0x7E, 0x1F, 0x83, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8, 0x7F, 0x1F,
  0x9F, 0x0F, 0xE3, 0xF3, 0xE1, 0xFC, 0x7C, 0x7E, 0x7F, 0x8F, 0x87, 0xCF,
  0xF1, 0xF0, 0xF9, 0xFF, 0x3E, 0x1F, 0x3F, 0xE7, 0xC3, 0xE7, 0xBD, 0xF0,
  0x7D, 0xF7, 0xBE, 0x0F, 0xBE, 0xF7, 0xC0, 0xFF, 0x9E, 0xF8, 0x1F, 0xF3,
  0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F,
  0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0x01, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xBE, 0x01,
  0xFB, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xFC,
  0x7E, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC1, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x07, 0xDF, 0x00,
  0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0x87, 0xBC, 0x38, 0xE3, 0xC7, 0x9E, 0x3D,
  0xE1, 0xEF, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E,
  0xFC, 0x3E, 0xFC, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0x3F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFE, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xFE, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x87,
  0xDF, 0x0F, 0xBF, 0x3F, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0x7F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F,
  0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x07, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x04, 0x7F, 0x3E, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFC,
  0x03, 0xF0, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xF3, 0xF8, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x9F, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F,
  0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0x9F, 0x00, 0x1F,
  0x00, 0x1F, 0x10, 0x3F, 0x1C, 0x7F, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF3, 0xE3, 0xEF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0xDF, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x23, 0xEF, 0xFF,
  0xF9, 0xE0, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x04, 0x0F, 0x87, 0xC3, 0xF1, 0xF0,
  0x70, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0xFF, 0x7F, 0x3F, 0x9F, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0xFC, 0xF9,
  0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF9, 0xF0, 0xF8, 0xFB, 0xF9, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xEF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC7, 0xF7, 0xF3, 0xE1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xFE, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0xF9, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0xFE, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x9F, 0x1F,
  0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F,
  0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xDF, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x3F,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFA, 0x3F, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFE, 0xF8, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x3C, 0x78, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87,
  0xFE, 0x3F, 0x1F, 0x78, 0xFC, 0x79, 0xF3, 0xF3, 0xE7, 0xCF, 0xCF, 0x9F,
  0x7F, 0xBE, 0x7D, 0xFE, 0xF8, 0xF7, 0xFB, 0xC3, 0xDE, 0xEF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0xFC,
  0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFC, 0x7C, 0x7C, 0xFC,
  0x7E, 0xF8, 0x3E, 0xFC, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xE3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE,
  0x07, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x83, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0xFC,
  0x7C, 0x3E, 0x1F, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x70, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40,
  0x78, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xE3, 0xF1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C,
  0x3C, 0x3E, 0x0E, 0x04, 0x00, 0x1E, 0x00, 0x1F, 0xC3, 0xDF, 0xF1, 0xFF,
  0xFD, 0xFF, 0xBF, 0xFF, 0x8F, 0xFB, 0xC3, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 10, 10, 12, 1, -29 },
  { 35, 18, 27, 20, 1, -27 },
  { 96, 15, 35, 19, 2, -31 },
  { 162, 21, 27, 24, 2, -27 },
  { 233, 20, 27, 22, 1, -27 },
  { 301, 4, 10, 6, 1, -29 },
  { 306, 9, 38, 12, 2, -30 },
  { 349, 9, 38, 12, 1, -30 },
  { 392, 17, 16, 17, 0, -27 },
  { 426, 16, 20, 18, 1, -22 },
  { 466, 6, 11, 9, 1, -5 },
  { 475, 9, 4, 14, 2, -13 },
  { 480, 6, 6, 11, 2, -6 },
  { 485, 12, 29, 13, 0, -27 },
  { 529, 15, 27, 19, 2, -27 },
  { 580, 10, 27, 19, 3, -27 },
  { 614, 17, 27, 19, 1, -27 },
  { 672, 16, 27, 19, 1, -27 },
  { 726, 17, 27, 19, 1, -27 },
  { 784, 16, 27, 19, 2, -27 },
  { 838, 16, 27, 19, 2, -27 },
  { 892, 17, 27, 19, 1, -27 },
  { 950, 15, 27, 19, 2, -27 },
  { 1001, 15, 27, 19, 2, -27 },
  { 1052, 6, 21, 10, 2, -21 },
  { 1068, 7, 27, 10, 1, -21 },
  { 1092, 14, 17, 17, 1, -20 },
  { 1122, 15, 12, 19, 2, -18 },
  { 1145, 14, 17, 17, 2, -20 },
  { 1175, 15, 27, 17, 1, -27 },
  { 1226, 27, 34, 29, 1, -26 },
  { 1341, 22, 27, 23, 0, -27 },
  { 1416, 18, 27, 21, 2, -27 },
  { 1477, 19, 27, 22, 2, -27 },
  { 1542, 18, 27, 21, 2, -27 },
  { 1603, 16, 27, 19, 2, -27 },
  { 1657, 15, 27, 18, 2, -27 },
  { 1708, 19, 27, 22, 2, -27 },
  { 1773, 19, 27, 23, 2, -27 },
  { 1838, 6, 27, 10, 2, -27 },
  { 1859, 16, 27, 19, 1, -27 },
  { 1913, 19, 27, 21, 2, -27 },
  { 1978, 15, 27, 18, 2, -27 },
  { 2029, 25, 27, 29, 2, -27 },
  { 2114, 19, 27, 23, 2, -27 },
  { 2179, 19, 27, 23, 2, -27 },
  { 2244, 18, 27, 22, 2, -27 },
  { 2305, 19, 32, 23, 2, -27 },
  { 2381, 18, 27, 21, 2, -27 },
  { 2442, 18, 27, 21, 1, -27 },
  { 2503, 19, 27, 21, 1, -27 },
  { 2568, 18, 27, 22, 2, -27 },
  { 2629, 22, 27, 22, 0, -27 },
  { 2704, 27, 27, 28, 1, -27 },
  { 2796, 20, 27, 21, 1, -27 },
  { 2864, 20, 27, 21, 0, -27 },
  { 2932, 18, 27, 20, 1, -27 },
  { 2993, 7, 37, 10, 2, -31 },
  { 3026, 15, 29, 14, 0, -27 },
  { 3081, 7, 37, 10, 1, -31 },
  { 3114, 13, 13, 15, 1, -27 },
  { 3136, 15, 4, 15, 0, 0 },
  { 3144, 10, 6, 13, 1, -29 },
  { 3152, 16, 20, 18, 1, -20 },
  { 3192, 16, 29, 19, 2, -29 },
  { 3250, 15, 20, 17, 1, -20 },
  { 3288, 16, 29, 19, 1, -29 },
  { 3346, 16, 20, 18, 1, -20 },
  { 3386, 11, 29, 12, 1, -29 },
  { 3426, 16, 28, 19, 1, -20 },
  { 3482, 15, 29, 19, 2, -29 },
  { 3537, 6, 28, 10, 2, -28 },
  { 3558, 9, 36, 9, -1, -28 },
  { 3599, 16, 29, 18, 2, -29 },
  { 3657, 5, 29, 10, 2, -29 },
  { 3676, 24, 20, 28, 2, -20 },
  { 3736, 15, 20, 19, 2, -20 },
  { 3774, 17, 20, 19, 1, -20 },
  { 3817, 16, 28, 19, 2, -20 },
  { 3873, 16, 28, 19, 1, -20 },
  { 3929, 10, 20, 13, 2, -20 },
  { 3954, 15, 20, 17, 1, -20 },
  { 3992, 11, 25, 12, 0, -25 },
  { 4027, 15, 20, 19, 2, -20 },
  { 4065, 17, 20, 17, 0, -20 },
  { 4108, 22, 20, 24, 1, -20 },
  { 4163, 16, 20, 17, 1, -20 },
  { 4203, 17, 28, 17, 0, -20 },
  { 4263, 15, 20, 17, 1, -20 },
  { 4301, 9, 37, 11, 1, -30 },
  { 4343, 3, 32, 10, 3, -27 },
  { 4355, 9, 37, 11, 1, -30 },
  { 4397, 17, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_Bold38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_BOLD38PT7B_H_
