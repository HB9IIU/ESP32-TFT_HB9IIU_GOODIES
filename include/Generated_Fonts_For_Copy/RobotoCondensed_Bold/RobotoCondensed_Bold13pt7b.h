#ifndef _ROBOTOCONDENSED_BOLD13PT7B_H_
#define _ROBOTOCONDENSED_BOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xFF, 0xB0, 0x14, 0xA2, 0x9F, 0x2B, 0xF2, 0x9E,
  0x50, 0x23, 0xB7, 0xBC, 0x38, 0x73, 0xFB, 0x88, 0xE1, 0x52, 0xA7, 0x81,
  0x05, 0x8C, 0xA9, 0x0C, 0x38, 0xF1, 0xA3, 0xC3, 0x6B, 0xF7, 0x3E, 0x7E,
  0xFF, 0x29, 0x69, 0x24, 0x99, 0x22, 0x84, 0x62, 0x22, 0x32, 0x22, 0x64,
  0x80, 0x30, 0xCF, 0xCC, 0x79, 0x20, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x00,
  0x57, 0xE0, 0xF0, 0x13, 0x22, 0x26, 0x44, 0xC8, 0x77, 0xE7, 0x39, 0xCE,
  0x7F, 0x70, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0x39, 0xFC, 0xC3, 0x18, 0xC3,
  0x18, 0x7C, 0x39, 0xF4, 0xC6, 0x38, 0x3C, 0xDF, 0x38, 0x18, 0x63, 0x8A,
  0x69, 0x2F, 0xC2, 0x08, 0xFF, 0xF1, 0xED, 0x8E, 0x7F, 0x70, 0x33, 0xB1,
  0x6F, 0xCE, 0x7F, 0x70, 0xFC, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x60, 0x77,
  0xF7, 0xFF, 0x6E, 0x7F, 0x70, 0x77, 0xA7, 0x3D, 0xFC, 0x6E, 0x60, 0xF0,
  0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x09, 0xF9, 0xC3, 0x84, 0xFF, 0xC0, 0x0F,
  0xFC, 0x8E, 0x33, 0xE8, 0x7B, 0xF2, 0x33, 0x18, 0x06, 0x30, 0x1E, 0x18,
  0x98, 0x29, 0xD5, 0xAA, 0x95, 0x4A, 0xAD, 0x5B, 0x20, 0x08, 0x03, 0xC0,
  0x18, 0x18, 0x3C, 0x3C, 0x2C, 0x7E, 0x7E, 0x66, 0xC2, 0xFB, 0xEC, 0xF6,
  0xFB, 0x3C, 0xFE, 0xF8, 0x7B, 0xFC, 0xE0, 0x82, 0x0C, 0xFF, 0x78, 0xF3,
  0xEC, 0xF3, 0xCF, 0x3C, 0xFE, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0x1F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0x18, 0xC0, 0x7B, 0xFC, 0xE0, 0x82, 0x7C, 0xFF,
  0x78, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF, 0xFF, 0xC0, 0x0C,
  0x30, 0xC3, 0x0C, 0x3C, 0xDE, 0x78, 0xCF, 0x6F, 0xBC, 0xF3, 0xCD, 0xB6,
  0xCC, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xC3, 0xE7, 0xE7, 0xA7, 0xAF,
  0xFF, 0xFB, 0xDB, 0xDB, 0xCF, 0x3E, 0xFB, 0xFF, 0x7D, 0xF3, 0xCC, 0x7B,
  0xFC, 0xE3, 0x8E, 0x3C, 0xFF, 0x78, 0xFB, 0xFC, 0xF3, 0xFF, 0xEC, 0x30,
  0xC0, 0x7B, 0xFC, 0xE3, 0x8E, 0x3C, 0xFF, 0x78, 0x30, 0x40, 0xFB, 0xEC,
  0xF3, 0xFB, 0xCD, 0xB6, 0xCC, 0x38, 0xF9, 0x13, 0x03, 0x81, 0xB1, 0xBE,
  0x38, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFE, 0x78, 0xC6, 0x8D, 0x9B, 0x26, 0xC5, 0x8E, 0x1C, 0x18,
  0xCC, 0xA6, 0xDB, 0x6F, 0xB7, 0xFB, 0xF9, 0xDC, 0x66, 0x33, 0x00, 0x66,
  0xD8, 0xB1, 0xC3, 0x87, 0x1B, 0x36, 0xE6, 0xC6, 0xD9, 0xB1, 0x43, 0x87,
  0x04, 0x08, 0x10, 0xFF, 0xF0, 0xC6, 0x10, 0xC6, 0x1F, 0xFC, 0xEA, 0xAA,
  0xAA, 0xC0, 0xC2, 0x18, 0xC2, 0x18, 0xC6, 0x18, 0xC0, 0xED, 0xB6, 0xDB,
  0x6D, 0xBE, 0x23, 0x94, 0xAD, 0x80, 0xF8, 0x62, 0x79, 0xE0, 0x9E, 0x49,
  0x67, 0xC0, 0x84, 0x21, 0x6F, 0xCE, 0x73, 0xFD, 0x80, 0x79, 0xEC, 0xF0,
  0xCD, 0xE7, 0x80, 0x0C, 0x30, 0xDF, 0x7F, 0x3C, 0xF3, 0x7D, 0xF0, 0x39,
  0xF4, 0xFF, 0x41, 0xA3, 0x80, 0x37, 0x6F, 0x66, 0x66, 0x66, 0x7D, 0xFC,
  0xF3, 0xCD, 0xF7, 0xC3, 0x5D, 0xE0, 0x84, 0x21, 0x6F, 0xCE, 0x73, 0x9C,
  0xC0, 0xB3, 0xFF, 0xF0, 0x48, 0x36, 0xDB, 0x6D, 0xEC, 0x84, 0x21, 0x3B,
  0x73, 0x9E, 0x94, 0xC0, 0xFF, 0xFF, 0xF0, 0xB6, 0xFB, 0x9B, 0x9B, 0x9B,
  0x9B, 0x9B, 0xB7, 0xE7, 0x39, 0xCE, 0x60, 0x39, 0xF4, 0xF3, 0x4D, 0xF3,
  0x80, 0xB7, 0xE7, 0x39, 0xFE, 0xD0, 0x84, 0x00, 0x7D, 0xFC, 0xF3, 0xCD,
  0xF7, 0xC3, 0x0C, 0x30, 0xBE, 0x49, 0x20, 0x7A, 0xD8, 0xF1, 0xAD, 0xE0,
  0x66, 0xF6, 0x66, 0x67, 0x70, 0x9C, 0xE7, 0x39, 0xFF, 0xE0, 0xCD, 0x27,
  0x9E, 0x70, 0xC3, 0x00, 0xDB, 0x5B, 0x5A, 0x5E, 0x7E, 0x66, 0x26, 0x49,
  0xE7, 0x0C, 0x71, 0xEC, 0x80, 0xCD, 0x67, 0x9E, 0x70, 0xC3, 0x0C, 0x61,
  0x80, 0xF3, 0x26, 0xCC, 0xF0, 0x22, 0x66, 0x66, 0xC6, 0x66, 0x62, 0xFF,
  0xE0, 0x44, 0x66, 0x66, 0x36, 0x66, 0x44, 0xEF, 0xE9, 0x80,
};

const GFXglyph RobotoCondensed_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 4, 0, -10 },
  { 6, 6, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 8, 1, -9 },
  { 28, 7, 9, 8, 0, -9 },
  { 36, 2, 4, 2, 0, -10 },
  { 37, 3, 13, 4, 1, -10 },
  { 42, 4, 13, 4, 0, -10 },
  { 49, 6, 6, 6, 0, -9 },
  { 54, 6, 7, 6, 0, -8 },
  { 60, 2, 4, 3, 0, -2 },
  { 61, 3, 1, 5, 1, -4 },
  { 62, 2, 2, 4, 1, -2 },
  { 63, 4, 10, 4, 0, -9 },
  { 68, 5, 9, 7, 1, -9 },
  { 74, 4, 9, 7, 1, -9 },
  { 79, 6, 9, 7, 0, -9 },
  { 86, 6, 9, 7, 0, -9 },
  { 93, 6, 9, 7, 0, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 5, 9, 7, 1, -9 },
  { 112, 6, 9, 7, 0, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 5, 9, 7, 1, -9 },
  { 131, 2, 7, 4, 1, -7 },
  { 133, 3, 9, 3, 0, -7 },
  { 137, 5, 6, 6, 0, -7 },
  { 141, 5, 6, 7, 1, -7 },
  { 145, 4, 6, 6, 1, -7 },
  { 148, 5, 9, 6, 0, -9 },
  { 154, 9, 12, 10, 0, -9 },
  { 168, 8, 9, 8, 0, -9 },
  { 177, 6, 9, 7, 1, -9 },
  { 184, 6, 9, 7, 1, -9 },
  { 191, 6, 9, 7, 1, -9 },
  { 198, 5, 9, 6, 1, -9 },
  { 204, 5, 9, 6, 1, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 6, 9, 8, 1, -9 },
  { 224, 2, 9, 4, 1, -9 },
  { 227, 6, 9, 6, 0, -9 },
  { 234, 6, 9, 7, 1, -9 },
  { 241, 5, 9, 6, 1, -9 },
  { 247, 8, 9, 10, 1, -9 },
  { 256, 6, 9, 8, 1, -9 },
  { 263, 6, 9, 8, 1, -9 },
  { 270, 6, 9, 7, 1, -9 },
  { 277, 6, 11, 8, 1, -9 },
  { 286, 6, 9, 7, 1, -9 },
  { 293, 7, 9, 7, 0, -9 },
  { 301, 7, 9, 7, 0, -9 },
  { 309, 6, 9, 7, 1, -9 },
  { 316, 7, 9, 8, 0, -9 },
  { 324, 9, 9, 10, 0, -9 },
  { 335, 7, 9, 7, 0, -9 },
  { 343, 7, 9, 7, 0, -9 },
  { 351, 6, 9, 7, 0, -9 },
  { 358, 2, 13, 3, 1, -11 },
  { 362, 5, 10, 5, 0, -9 },
  { 369, 3, 13, 3, 0, -11 },
  { 374, 5, 5, 5, 0, -9 },
  { 378, 5, 1, 5, 0, 0 },
  { 379, 4, 2, 4, 0, -10 },
  { 380, 6, 7, 6, 0, -7 },
  { 386, 5, 10, 6, 1, -10 },
  { 393, 6, 7, 6, 0, -7 },
  { 399, 6, 10, 6, 0, -10 },
  { 407, 6, 7, 6, 0, -7 },
  { 413, 4, 10, 4, 0, -10 },
  { 418, 6, 10, 7, 0, -7 },
  { 426, 5, 10, 6, 1, -10 },
  { 433, 2, 10, 3, 1, -10 },
  { 436, 3, 13, 3, 0, -10 },
  { 441, 5, 10, 6, 1, -10 },
  { 448, 2, 10, 3, 1, -10 },
  { 451, 8, 7, 10, 1, -7 },
  { 458, 5, 7, 6, 1, -7 },
  { 463, 6, 7, 6, 0, -7 },
  { 469, 5, 10, 6, 1, -7 },
  { 476, 6, 10, 6, 0, -7 },
  { 484, 3, 7, 4, 1, -7 },
  { 487, 5, 7, 6, 0, -7 },
  { 492, 4, 9, 4, 0, -9 },
  { 497, 5, 7, 6, 1, -7 },
  { 502, 6, 7, 6, 0, -7 },
  { 508, 8, 7, 8, 0, -7 },
  { 515, 6, 7, 6, 0, -7 },
  { 521, 6, 10, 6, 0, -7 },
  { 529, 4, 7, 6, 1, -7 },
  { 533, 4, 12, 4, 0, -10 },
  { 539, 1, 11, 3, 1, -9 },
  { 541, 4, 12, 4, 0, -10 },
  { 547, 6, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Bold13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_BOLD13PT7B_H_
