#ifndef _ROBOTOCONDENSED_BOLD48PT7B_H_
#define _ROBOTOCONDENSED_BOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0xDF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1E, 0xF8, 0xF7, 0xC7, 0xBE,
  0x3D, 0xE1, 0xEF, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xDF, 0xE3, 0xF8, 0xFE, 0x7F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7F,
  0x07, 0xF7, 0xFD, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x8F, 0x83, 0x01, 0xF1, 0xF0,
  0x78, 0x3E, 0x1E, 0x1E, 0x07, 0xC3, 0xC3, 0xC0, 0xF8, 0x78, 0xF0, 0x1F,
  0x0F, 0x1E, 0x03, 0xE3, 0xE7, 0x80, 0x3C, 0x7D, 0xF0, 0x07, 0xFF, 0x3C,
  0x00, 0x7F, 0xEF, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x1E, 0x7F,
  0x80, 0x03, 0xDF, 0xF8, 0x00, 0xF7, 0xFF, 0x80, 0x3E, 0xF9, 0xF0, 0x07,
  0x9E, 0x1E, 0x01, 0xE3, 0xC3, 0xE0, 0x3C, 0x78, 0x7C, 0x0F, 0x0F, 0x0F,
  0x81, 0xE1, 0xE1, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x07, 0xC7, 0x80, 0x40,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF3,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0x0F, 0xFF, 0x1F, 0x8F,
  0xFF, 0xCF, 0xC7, 0xEF, 0xE7, 0xE7, 0xF3, 0xFB, 0xF3, 0xF0, 0xFF, 0xF9,
  0xF8, 0x7F, 0xF8, 0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFE, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFF, 0x0F, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x18, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x78, 0x06, 0x00, 0x40, 0x40, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0x78, 0x07, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xC3, 0xC1,
  0x9F, 0x9E, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0x18, 0x0E, 0x00, 0x40,
  0x20, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E,
  0x7C, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x07, 0xE7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x1F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF,
  0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE,
  0xFF, 0xBF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFB, 0xF8,
  0x03, 0xEF, 0xE0, 0x1F, 0x3F, 0x80, 0x7C, 0xFE, 0x03, 0xF3, 0xF8, 0x0F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F,
  0xE1, 0xF8, 0x3F, 0x87, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x1F, 0xE0, 0xE0, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x7C, 0x07, 0xEF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xDF, 0xF7, 0xF8,
  0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFF,
  0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0xC1,
  0xFC, 0x7E, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07,
  0xE7, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF8, 0xFE, 0x7F,
  0x07, 0xE7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE0, 0xFF, 0x7E, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF1, 0xF8,
  0xF8, 0x78, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xC7, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x7E, 0x07, 0xC7, 0xC0, 0x7F, 0xC1, 0xE3, 0xC0,
  0xFF, 0xF0, 0xF3, 0xE0, 0x7F, 0xF8, 0x79, 0xF0, 0x7E, 0x7C, 0x3C, 0xF0,
  0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x07, 0xFC, 0x1E, 0x0F, 0x83, 0xFE,
  0x1F, 0x07, 0xC1, 0xFF, 0x0F, 0x83, 0xC0, 0xFF, 0x07, 0xC1, 0xE0, 0x7F,
  0x83, 0xE0, 0xF0, 0x3F, 0xC3, 0xE0, 0x78, 0x1F, 0xE1, 0xF0, 0x3C, 0x1E,
  0xF0, 0xF8, 0x1E, 0x0F, 0x78, 0x7C, 0x1F, 0x07, 0xBC, 0x1F, 0x0F, 0x83,
  0xDF, 0x0F, 0x87, 0xC3, 0xCF, 0x87, 0xE7, 0xE3, 0xE7, 0xC3, 0xFF, 0xFF,
  0xE1, 0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0x9F, 0xF0, 0x7C, 0x0F, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x08, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0,
  0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x81,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x83, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F,
  0x80, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFE,
  0xFE, 0x03, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xBF, 0x80, 0xFF, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x7E, 0x0F, 0xBF, 0xFE, 0xFC,
  0x3F, 0x7F, 0xFD, 0xF8, 0x7E, 0xFF, 0xF9, 0xF0, 0xF9, 0xFF, 0xF3, 0xF1,
  0xF3, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0xCF, 0xCF, 0xCF, 0xFF, 0x8F, 0xDF,
  0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0x87,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0x03, 0xF8, 0x3F,
  0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFC,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x7F, 0xFD, 0xFC, 0x7F, 0xFC, 0xFC, 0x7F,
  0xFC, 0xFE, 0x7F, 0xFC, 0x7E, 0x7F, 0xFC, 0x7F, 0x7F, 0xFC, 0x3F, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x9F, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x03,
  0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0x8F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x7E, 0x7F, 0x07, 0xF8, 0x1F,
  0x9F, 0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xE0,
  0xFE, 0x3F, 0x07, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x0F, 0xC3, 0xF0, 0xFF,
  0xC3, 0xF0, 0xFE, 0x3F, 0xF1, 0xFC, 0x3F, 0x8F, 0xFC, 0x7F, 0x07, 0xE3,
  0xFF, 0x1F, 0xC1, 0xF9, 0xFF, 0xE7, 0xE0, 0x7E, 0x7F, 0xF9, 0xF8, 0x1F,
  0x9F, 0xBE, 0x7E, 0x07, 0xF7, 0xCF, 0x9F, 0x81, 0xFD, 0xF3, 0xEF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1,
  0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07,
  0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E,
  0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0xC7, 0xC3, 0xE3, 0xE3,
  0xE0, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x3F, 0xBF, 0x87,
  0xF7, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC3, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xEF, 0xE1, 0xF9, 0xFC, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x7E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE,
  0xFF, 0x8F, 0xE7, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0x7F, 0xBF, 0x83, 0xF7, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xE7, 0xFB, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x1F, 0x8F, 0xFB, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x83, 0xE3, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x87, 0xF0, 0x18, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0x7E, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF1, 0x80, 0xFE, 0x1E, 0x3F, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0xF8,
  0x7F, 0x7F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF0,
  0x3C, 0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F,
  0xCF, 0xF1, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFD, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFE, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F,
  0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xDF, 0xC1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x03, 0xE1, 0xFD, 0xFF,
  0x1F, 0xF3, 0xFF, 0xFF, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0x07, 0xF0,
  0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0x81,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x0F,
  0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x7F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0x03, 0xFF,
  0xE0, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x1F, 0xFF,
  0x03, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC,
  0x3E, 0x1F, 0xDF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x7E, 0x0F, 0xEF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE7, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xF7, 0xE0,
  0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0xDF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFE, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x1F, 0xF7, 0xE0, 0xF8, 0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F,
  0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F,
  0x9F, 0x81, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x0F,
  0x83, 0xF7, 0xE0, 0xFC, 0x1F, 0xBF, 0x87, 0xE0, 0xFC, 0xFC, 0x3F, 0x07,
  0xE7, 0xE1, 0xFC, 0x7F, 0x3F, 0x0F, 0xE3, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F,
  0xC7, 0xF8, 0xFC, 0x3E, 0x3F, 0xC7, 0xE1, 0xF9, 0xFF, 0x3F, 0x0F, 0xDF,
  0xF9, 0xF0, 0x7E, 0xFF, 0xDF, 0x83, 0xF7, 0xDE, 0xFC, 0x0F, 0xBE, 0xFF,
  0xE0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80,
  0xFF, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFE, 0x07, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC1, 0xFD, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0x9F, 0x83, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFC, 0xFE, 0x0F,
  0xE3, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x0E, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0E, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x07, 0x80, 0x60, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0x80, 0xF3, 0xFF, 0x07, 0xCF, 0xFE, 0x1F, 0x7F,
  0xFC, 0x7D, 0xFF, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F, 0x0F, 0xFE, 0xF8, 0x1F,
  0xF3, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 34, 13, 3, -34 },
  { 31, 13, 13, 15, 1, -36 },
  { 53, 22, 34, 25, 2, -34 },
  { 147, 20, 44, 24, 2, -39 },
  { 257, 27, 34, 31, 2, -34 },
  { 372, 25, 34, 28, 2, -34 },
  { 479, 5, 13, 8, 1, -36 },
  { 488, 11, 49, 16, 3, -38 },
  { 556, 12, 49, 16, 1, -38 },
  { 630, 21, 21, 22, 1, -34 },
  { 686, 19, 25, 23, 2, -28 },
  { 746, 8, 14, 12, 1, -6 },
  { 760, 11, 5, 17, 3, -17 },
  { 767, 8, 7, 14, 3, -7 },
  { 774, 15, 37, 16, 0, -34 },
  { 844, 20, 34, 24, 2, -34 },
  { 929, 13, 34, 24, 4, -34 },
  { 985, 20, 34, 24, 2, -34 },
  { 1070, 20, 34, 24, 2, -34 },
  { 1155, 22, 34, 24, 1, -34 },
  { 1249, 20, 34, 24, 2, -34 },
  { 1334, 21, 34, 24, 2, -34 },
  { 1424, 20, 34, 24, 2, -34 },
  { 1509, 20, 34, 24, 2, -34 },
  { 1594, 20, 34, 24, 2, -34 },
  { 1679, 8, 26, 13, 3, -26 },
  { 1705, 9, 34, 12, 1, -26 },
  { 1744, 18, 23, 21, 1, -26 },
  { 1796, 18, 17, 24, 3, -24 },
  { 1835, 17, 23, 22, 3, -26 },
  { 1884, 19, 34, 21, 1, -34 },
  { 1965, 33, 44, 37, 2, -33 },
  { 2147, 27, 34, 29, 1, -34 },
  { 2262, 22, 34, 27, 3, -34 },
  { 2356, 24, 34, 27, 2, -34 },
  { 2458, 22, 34, 27, 3, -34 },
  { 2552, 19, 34, 24, 3, -34 },
  { 2633, 19, 34, 23, 3, -34 },
  { 2714, 24, 34, 28, 2, -34 },
  { 2816, 24, 34, 29, 3, -34 },
  { 2918, 7, 34, 13, 3, -34 },
  { 2948, 20, 34, 24, 1, -34 },
  { 3033, 24, 34, 27, 3, -34 },
  { 3135, 19, 34, 23, 3, -34 },
  { 3216, 31, 34, 36, 3, -34 },
  { 3348, 24, 34, 29, 3, -34 },
  { 3450, 25, 34, 29, 2, -34 },
  { 3557, 22, 34, 27, 3, -34 },
  { 3651, 25, 40, 29, 2, -34 },
  { 3776, 23, 34, 27, 3, -34 },
  { 3874, 22, 34, 26, 2, -34 },
  { 3968, 24, 34, 26, 1, -34 },
  { 4070, 22, 34, 27, 3, -34 },
  { 4164, 26, 34, 28, 1, -34 },
  { 4275, 34, 34, 36, 1, -34 },
  { 4420, 25, 34, 27, 1, -34 },
  { 4527, 26, 34, 26, 0, -34 },
  { 4638, 22, 34, 25, 2, -34 },
  { 4732, 9, 48, 13, 3, -40 },
  { 4786, 19, 37, 18, 0, -34 },
  { 4874, 9, 48, 13, 1, -40 },
  { 4928, 17, 17, 19, 1, -34 },
  { 4965, 19, 5, 19, 0, 0 },
  { 4977, 12, 7, 16, 1, -36 },
  { 4988, 19, 26, 23, 2, -26 },
  { 5050, 20, 36, 24, 2, -36 },
  { 5140, 19, 26, 22, 2, -26 },
  { 5202, 19, 36, 24, 2, -36 },
  { 5288, 20, 26, 23, 2, -26 },
  { 5353, 14, 36, 16, 1, -36 },
  { 5416, 20, 36, 24, 2, -26 },
  { 5506, 19, 36, 24, 2, -36 },
  { 5592, 8, 36, 12, 2, -36 },
  { 5628, 11, 46, 12, -1, -36 },
  { 5692, 21, 36, 23, 2, -36 },
  { 5787, 6, 36, 12, 3, -36 },
  { 5814, 31, 26, 36, 2, -26 },
  { 5915, 19, 26, 24, 2, -26 },
  { 5977, 20, 26, 24, 2, -26 },
  { 6042, 20, 36, 24, 2, -26 },
  { 6132, 19, 36, 24, 2, -26 },
  { 6218, 13, 26, 16, 2, -26 },
  { 6261, 19, 26, 22, 1, -26 },
  { 6323, 13, 32, 15, 1, -32 },
  { 6375, 19, 26, 24, 2, -26 },
  { 6437, 20, 26, 22, 1, -26 },
  { 6502, 29, 26, 30, 1, -26 },
  { 6597, 20, 26, 22, 1, -26 },
  { 6662, 21, 36, 21, 0, -26 },
  { 6757, 18, 26, 22, 2, -26 },
  { 6816, 12, 45, 14, 1, -37 },
  { 6884, 4, 40, 12, 4, -34 },
  { 6904, 12, 45, 14, 1, -37 },
  { 6972, 22, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_Bold48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_BOLD48PT7B_H_
