#ifndef _ROBOTOCONDENSED_BOLD29PT7B_H_
#define _ROBOTOCONDENSED_BOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0xFF, 0xE0,
  0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0x06, 0x70, 0x33, 0x03, 0x98,
  0x1C, 0xC0, 0xE6, 0x07, 0x71, 0xFF, 0xEF, 0xFF, 0x0C, 0xC0, 0xE6, 0x07,
  0x30, 0x39, 0x81, 0xDC, 0x7F, 0xFB, 0xFF, 0xC3, 0x30, 0x39, 0x81, 0xCC,
  0x0E, 0x60, 0x77, 0x03, 0x38, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0xF8,
  0x1F, 0xC3, 0xFE, 0x7D, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x7C, 0x03, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F,
  0x7D, 0xF7, 0xFF, 0x3F, 0xE0, 0xF8, 0x07, 0x00, 0x70, 0x07, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x77, 0x10, 0xE7, 0x18, 0xE7, 0x38, 0xE7, 0x30, 0xE7,
  0x70, 0x77, 0x60, 0x7E, 0xE0, 0x3C, 0xC0, 0x01, 0xC0, 0x01, 0xBC, 0x03,
  0xFE, 0x03, 0x77, 0x06, 0x63, 0x0E, 0x63, 0x0C, 0x63, 0x1C, 0x63, 0x08,
  0x77, 0x00, 0x7E, 0x00, 0x3C, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x81, 0xEF,
  0x03, 0x8E, 0x0F, 0x1C, 0x0E, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x3E, 0x00,
  0xFC, 0x03, 0xFC, 0xE7, 0xF9, 0xDE, 0x7F, 0xBC, 0xFF, 0x78, 0xFC, 0xF0,
  0xF9, 0xF3, 0xF1, 0xFF, 0xF1, 0xFF, 0xE1, 0xFB, 0xE0, 0xFF, 0xFF, 0xFF,
  0x04, 0x18, 0x71, 0xE3, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0x40, 0x81, 0x83, 0x83, 0x87, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x78,
  0xE3, 0x86, 0x08, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x86, 0x07, 0x33,
  0x3F, 0xFC, 0xFF, 0xC0, 0xF0, 0x0F, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xC1,
  0x04, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x77, 0x77, 0x77, 0xFE, 0x40, 0xFF, 0xFF, 0xF8, 0xFF, 0xF7,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x80, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x78, 0xF7, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF7, 0x8F, 0x78, 0xF7, 0xDE, 0x3F, 0xE1, 0xFC, 0x0F, 0x80, 0x01, 0x0F,
  0x3F, 0xFF, 0xFF, 0xEF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x81, 0xFE, 0x1F, 0xF8,
  0xFB, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xDF,
  0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE,
  0x01, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xE3, 0xCF, 0x1E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF7, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xF8, 0x7F, 0xE7, 0xFE, 0x79, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x0F, 0x78, 0xF7, 0xDF, 0x7F, 0xE3, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x7E,
  0x07, 0xF0, 0x7F, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x7F, 0xE7,
  0xFF, 0xBF, 0x7D, 0xF1, 0xEF, 0x0F, 0xF8, 0x3D, 0xC1, 0xEF, 0x1F, 0x78,
  0xF3, 0xEF, 0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0xDF, 0x78, 0xF7,
  0x8F, 0x78, 0xF7, 0x8F, 0x7D, 0xE3, 0xFE, 0x1F, 0xC3, 0xFE, 0x79, 0xF7,
  0x8F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0xDF, 0x7F, 0xE3, 0xFE, 0x0F, 0x80,
  0x0F, 0x03, 0xFC, 0x3F, 0xE7, 0xDE, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0x79, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0xF0, 0x1E,
  0x01, 0xE1, 0xFC, 0x1F, 0x81, 0xF0, 0x1C, 0x00, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF7, 0x7B, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3D, 0xEF, 0x7B, 0xDC, 0xEE, 0x20, 0x00, 0x40, 0x70, 0x7C, 0x7F, 0x7F,
  0xBF, 0x8F, 0x83, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0x01, 0xC0, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7C, 0x1F, 0x1F,
  0xDF, 0xEF, 0xE3, 0xE0, 0xE0, 0x20, 0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0x7D,
  0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x1C, 0x1C, 0x00,
  0xC3, 0x80, 0x0E, 0x30, 0x78, 0x67, 0x0F, 0xE7, 0x71, 0xFE, 0x76, 0x38,
  0xE3, 0xE3, 0x8C, 0x3E, 0x38, 0xC3, 0xE7, 0x0C, 0x3E, 0x70, 0xC3, 0xE7,
  0x1C, 0x7E, 0x71, 0xC7, 0xE7, 0x9C, 0x6E, 0x3F, 0xEE, 0x63, 0xFF, 0xC7,
  0x1E, 0x78, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0x9C, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xFF,
  0x80, 0xF8, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE7, 0xEF, 0x0F, 0x78, 0x7F,
  0xC3, 0xFE, 0x1E, 0xF0, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0xEF, 0x0F, 0x78,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x07,
  0xBE, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x0F, 0xBC, 0x1E, 0x78, 0x3C, 0xFD, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xEF, 0xEF,
  0x0F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xF7, 0x9F, 0xBF, 0xF9,
  0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xF7,
  0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x7C,
  0x1E, 0xFE, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0x7E, 0x00, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x1F, 0xF1, 0xEF, 0xBE,
  0x7F, 0xC7, 0xFC, 0x1F, 0x00, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x7C,
  0xF3, 0xE3, 0xCF, 0x8F, 0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC3, 0xEF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3,
  0xCF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xF8, 0x77, 0xEE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xBF,
  0xDC, 0xEF, 0xF7, 0x3B, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0xCF, 0xCF, 0xF3,
  0xF3, 0xFC, 0xFC, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xC0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFC, 0xFF, 0x7B, 0xFD, 0xEF, 0xF3, 0xFF, 0xCF, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3C,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xFD, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xEF,
  0xFE, 0x7F, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83,
  0xCF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xFD,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0E,
  0x00, 0x08, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE7, 0xEF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0xBF, 0xFD, 0xFF, 0x8F, 0xFC, 0x79,
  0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xF7, 0x87, 0xBC, 0x3F, 0xE1, 0xFF, 0x07,
  0x80, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0x7E, 0xF8, 0x7B, 0xE1, 0xEF,
  0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xEF, 0x07, 0xBC, 0x1F, 0xF8, 0x79, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xEF, 0xDF, 0xFC, 0xFF, 0xC1,
  0xF8, 0x00, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C,
  0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF1, 0xF1, 0xE7, 0x9F, 0x9E, 0x79,
  0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0xBF, 0x9C, 0x7B, 0xFF, 0xC3,
  0xBB, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xF8,
  0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0x7C, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F,
  0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3E,
  0x3C, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBF, 0xFF, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF,
  0xFC, 0x1C, 0x07, 0x83, 0xE0, 0xF8, 0x37, 0x1D, 0xC7, 0x31, 0xCE, 0xE3,
  0xB8, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0xF0, 0xF0, 0xF0, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x9E, 0xF1, 0xE0, 0x1E, 0x1F, 0xE7, 0xFE, 0x7D,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF9, 0xEF, 0xFE, 0x7F, 0xE3, 0xCF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xCF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0x3C, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xFF, 0x0E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9,
  0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0xE7, 0xFF, 0x3F, 0xE0, 0xF8, 0x0F, 0x1F, 0x3F, 0x3E, 0x7C, 0x78, 0xFF,
  0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x1E, 0xF3, 0xFF, 0x7F, 0xF7, 0xDF, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7D, 0xF7, 0xFF,
  0x3F, 0xF1, 0xEF, 0x00, 0xF0, 0x0F, 0x31, 0xF7, 0xFE, 0x7F, 0xC1, 0xF8,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xCF, 0xFE,
  0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x77, 0xDE, 0xE0,
  0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x1C,
  0x7C, 0xF8, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3D, 0xFB, 0xF7, 0x80,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC7, 0xDE,
  0x3C, 0xF3, 0xE7, 0x9E, 0x3D, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF8, 0xFB, 0xC7, 0x9F, 0x3C, 0x79, 0xE3, 0xEF, 0x0F, 0x78, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xC7, 0x9F, 0xFD, 0xFB, 0xFF, 0xFF, 0x7E, 0xFD, 0xFF, 0x0F, 0x1F, 0xE1,
  0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC3,
  0xC7, 0xF8, 0x78, 0xFF, 0x0F, 0x1F, 0xE1, 0xE3, 0xFC, 0x3C, 0x7F, 0x87,
  0x8F, 0xF3, 0xCF, 0xFE, 0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x79, 0xF7, 0xFE, 0x3F, 0xC0,
  0xF8, 0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF,
  0x3C, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0xF7,
  0xFF, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF7, 0xF7, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F,
  0x07, 0xF9, 0xFF, 0xF8, 0xFF, 0x1F, 0xF0, 0x1F, 0x83, 0xFC, 0x1F, 0xC0,
  0xFC, 0x07, 0xF8, 0xFF, 0x1E, 0xFF, 0xDF, 0xF0, 0xF8, 0x3C, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3F, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7B, 0xF7,
  0xFF, 0x7F, 0xF1, 0xEF, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0x8E,
  0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x70, 0xE3, 0xDE, 0x78, 0xF7, 0x9E,
  0x39, 0xE7, 0x9E, 0x79, 0xF7, 0x8E, 0xFD, 0xE3, 0xBF, 0x78, 0xEF, 0xDC,
  0x3F, 0xBF, 0x0F, 0xEF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x1E, 0x07,
  0xC7, 0x81, 0xE1, 0xE0, 0x38, 0x78, 0x78, 0xF3, 0xE7, 0x8F, 0x78, 0x7B,
  0xC1, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0,
  0x3F, 0x83, 0xDE, 0x1E, 0xF1, 0xE3, 0xCF, 0x1E, 0xF8, 0xFB, 0xC7, 0x9E,
  0x3C, 0xF1, 0xE3, 0x9E, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x3C, 0x71, 0xE3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE3, 0xCF, 0x1C, 0x3C, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3C, 0x3C, 0x38, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xC3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE1, 0xE3, 0xE1, 0xC7, 0x9E, 0x38, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x71, 0xE3, 0x86, 0x00, 0x1C, 0x1D, 0xFC, 0x77, 0xFB, 0x9D,
  0xFE, 0xE1, 0xF0, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 7, 8, 9, 1, -22 },
  { 19, 13, 21, 15, 1, -21 },
  { 54, 12, 27, 15, 1, -24 },
  { 95, 16, 21, 19, 1, -21 },
  { 137, 15, 21, 17, 1, -21 },
  { 177, 3, 8, 5, 1, -22 },
  { 180, 7, 29, 9, 2, -23 },
  { 206, 7, 29, 9, 1, -23 },
  { 232, 13, 13, 13, 0, -21 },
  { 254, 12, 16, 14, 1, -18 },
  { 278, 4, 9, 7, 1, -3 },
  { 283, 7, 3, 10, 2, -10 },
  { 286, 4, 4, 8, 2, -4 },
  { 288, 9, 23, 10, 0, -21 },
  { 314, 12, 21, 15, 1, -21 },
  { 346, 8, 21, 15, 2, -21 },
  { 367, 13, 21, 15, 1, -21 },
  { 402, 12, 21, 15, 1, -21 },
  { 434, 13, 21, 15, 1, -21 },
  { 469, 12, 21, 15, 1, -21 },
  { 501, 13, 21, 15, 1, -21 },
  { 536, 12, 21, 15, 1, -21 },
  { 568, 12, 21, 15, 1, -21 },
  { 600, 12, 21, 15, 1, -21 },
  { 632, 4, 16, 8, 2, -16 },
  { 640, 5, 22, 7, 1, -16 },
  { 654, 10, 14, 13, 1, -16 },
  { 672, 11, 9, 15, 2, -14 },
  { 685, 10, 14, 13, 2, -16 },
  { 703, 11, 21, 13, 1, -21 },
  { 732, 20, 26, 22, 1, -20 },
  { 797, 17, 21, 17, 0, -21 },
  { 842, 13, 21, 16, 2, -21 },
  { 877, 15, 21, 17, 1, -21 },
  { 917, 13, 21, 16, 2, -21 },
  { 952, 12, 21, 14, 2, -21 },
  { 984, 11, 21, 14, 2, -21 },
  { 1013, 15, 21, 17, 1, -21 },
  { 1053, 14, 21, 18, 2, -21 },
  { 1090, 4, 21, 8, 2, -21 },
  { 1101, 12, 21, 14, 1, -21 },
  { 1133, 14, 21, 16, 2, -21 },
  { 1170, 11, 21, 14, 2, -21 },
  { 1199, 18, 21, 22, 2, -21 },
  { 1247, 14, 21, 18, 2, -21 },
  { 1284, 15, 21, 18, 1, -21 },
  { 1324, 13, 21, 16, 2, -21 },
  { 1359, 15, 25, 18, 1, -21 },
  { 1406, 13, 21, 16, 2, -21 },
  { 1441, 14, 21, 16, 1, -21 },
  { 1478, 14, 21, 16, 1, -21 },
  { 1515, 13, 21, 17, 2, -21 },
  { 1550, 16, 21, 17, 0, -21 },
  { 1592, 20, 21, 22, 1, -21 },
  { 1645, 16, 21, 16, 0, -21 },
  { 1687, 16, 21, 16, 0, -21 },
  { 1729, 13, 21, 15, 1, -21 },
  { 1764, 5, 29, 8, 2, -24 },
  { 1783, 11, 23, 11, 0, -21 },
  { 1815, 6, 29, 8, 0, -24 },
  { 1837, 10, 10, 11, 1, -21 },
  { 1850, 11, 3, 12, 0, 0 },
  { 1855, 7, 4, 10, 1, -21 },
  { 1859, 12, 16, 14, 1, -16 },
  { 1883, 12, 22, 14, 1, -22 },
  { 1916, 12, 16, 13, 1, -16 },
  { 1940, 12, 22, 14, 1, -22 },
  { 1973, 12, 16, 14, 1, -16 },
  { 1997, 8, 22, 10, 1, -22 },
  { 2019, 12, 22, 15, 1, -16 },
  { 2052, 12, 22, 14, 1, -22 },
  { 2085, 5, 22, 7, 1, -22 },
  { 2099, 7, 28, 7, -1, -22 },
  { 2124, 13, 22, 14, 1, -22 },
  { 2160, 4, 22, 7, 2, -22 },
  { 2171, 19, 16, 22, 1, -16 },
  { 2209, 12, 16, 14, 1, -16 },
  { 2233, 12, 16, 14, 1, -16 },
  { 2257, 12, 22, 14, 1, -16 },
  { 2290, 12, 22, 14, 1, -16 },
  { 2323, 8, 16, 10, 1, -16 },
  { 2339, 11, 16, 13, 1, -16 },
  { 2361, 8, 19, 9, 0, -19 },
  { 2380, 12, 16, 14, 1, -16 },
  { 2404, 13, 16, 13, 0, -16 },
  { 2430, 18, 16, 18, 0, -16 },
  { 2466, 13, 16, 13, 0, -16 },
  { 2492, 13, 22, 13, 0, -16 },
  { 2528, 11, 16, 13, 1, -16 },
  { 2550, 7, 28, 9, 1, -23 },
  { 2575, 3, 25, 7, 2, -21 },
  { 2585, 7, 28, 9, 1, -23 },
  { 2610, 14, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_Bold29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_BOLD29PT7B_H_
