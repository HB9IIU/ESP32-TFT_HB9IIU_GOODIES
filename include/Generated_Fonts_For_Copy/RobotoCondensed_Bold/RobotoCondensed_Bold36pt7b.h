#ifndef _ROBOTOCONDENSED_BOLD36PT7B_H_
#define _ROBOTOCONDENSED_BOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xCF, 0xBF, 0xF9, 0xE0, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x03, 0x8E, 0x01,
  0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x70,
  0x0E, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xE7, 0x00, 0xF3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC3, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7C, 0xFC, 0xF8, 0xFB,
  0xE1, 0xF7, 0xC1, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xBE, 0x0F,
  0x7C, 0x1E, 0xF8, 0x7D, 0xF8, 0xF9, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01,
  0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x71, 0xC3, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x87,
  0x1C, 0xE0, 0xE3, 0xBC, 0x1F, 0xF7, 0x01, 0xFD, 0xC0, 0x1F, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x73, 0xE0, 0x0E, 0xFE, 0x03, 0xBF, 0xE0,
  0x77, 0x9C, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0xE3, 0x8E, 0x1C, 0x71, 0xC7,
  0x0F, 0x38, 0x21, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F,
  0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x87, 0x8F, 0xF8, 0xF3, 0xFF, 0xBE, 0x7D,
  0xFF, 0xDF, 0x1F, 0xF3, 0xE3, 0xFE, 0x7C, 0x3F, 0xCF, 0xC3, 0xF0, 0xFC,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7, 0xC1, 0xF8, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xEE, 0x01, 0x01, 0x81, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x20, 0x40, 0x70, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38,
  0x08, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC0,
  0x79, 0xCE, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x1C, 0x38, 0x00, 0x10, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF,
  0xC3, 0xFF, 0xC7, 0xCF, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x3D,
  0xF0, 0x7B, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xCF, 0x9F,
  0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xC1, 0xF1, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0x83,
  0xEF, 0x8F, 0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3C, 0x7C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7, 0xC3, 0xFF, 0xC7, 0xFF,
  0xCF, 0xFF, 0xCF, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x9F, 0x9F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF3, 0xC3, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0xDF, 0x9F, 0xBE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xCF, 0x9F, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9F, 0xFE, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D,
  0xE1, 0xF7, 0xCF, 0x8F, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0xBF, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xF7, 0xFF,
  0xDF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F,
  0xFE, 0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC,
  0x7D, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0x78, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFD, 0xF7, 0x80, 0x3C, 0xFD, 0xFB, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0x9E, 0x3C, 0xF0, 0x40, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0xFF, 0x9F, 0xFB, 0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0xF8, 0x1F, 0xC3, 0xFE,
  0x7F, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x01, 0xC0,
  0x78, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x38, 0x1E, 0x0E, 0x3C, 0x3F, 0xC7,
  0x1C, 0x3F, 0xE1, 0xDE, 0x1E, 0x70, 0xEE, 0x1E, 0x38, 0x77, 0x0E, 0x1C,
  0x3B, 0x8F, 0x0E, 0x1D, 0xC7, 0x87, 0x0E, 0xE3, 0xC3, 0x87, 0xF1, 0xE1,
  0xC3, 0xF8, 0xF1, 0xE1, 0xFC, 0x78, 0xF0, 0xFE, 0x3C, 0x78, 0xE7, 0x1E,
  0x3C, 0x73, 0x8F, 0xBE, 0x79, 0xC3, 0xFF, 0xF8, 0xE1, 0xFB, 0xF8, 0x78,
  0x78, 0xF8, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x07,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x07,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x87, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F,
  0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0, 0x7E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC3, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF7, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xF1, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0x8F, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF,
  0x83, 0xF7, 0xC3, 0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xF3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF8, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xDF, 0x9F, 0x9F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F,
  0x80, 0xF8, 0x1F, 0xFE, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x7E,
  0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F,
  0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFE, 0xF8, 0x3F, 0x3F, 0x0F, 0x8F, 0xC3, 0xE1, 0xF8, 0xF8, 0x7E,
  0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x03, 0xF0,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xDF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xBC, 0x7B, 0xFF,
  0x78, 0xF7, 0xFE, 0xF9, 0xEF, 0xFC, 0xF7, 0xDF, 0xF9, 0xEF, 0x3F, 0xF3,
  0xFE, 0x7F, 0xE7, 0xFC, 0xFF, 0xC7, 0xF1, 0xFF, 0x8F, 0xE3, 0xFF, 0x1F,
  0xC7, 0xFE, 0x1F, 0x8F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0x78,
  0x7C, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xEF, 0x9F, 0xFB, 0xE7, 0xFE, 0x7D, 0xFF, 0x9F, 0x7F, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x7C, 0x0F, 0x9F,
  0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0x87, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x0F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3,
  0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF1, 0xFD,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xF7, 0xF1, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFC, 0x03, 0xF8, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7D,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF7, 0xC3, 0xE1,
  0xF3, 0xE3, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F,
  0x1F, 0x3E, 0x3F, 0x8F, 0x8F, 0x3F, 0xE7, 0x87, 0xDE, 0xF7, 0xC3, 0xEF,
  0x7B, 0xE1, 0xF7, 0xBD, 0xF0, 0xFB, 0xDE, 0xF8, 0x3D, 0xEF, 0xFC, 0x1F,
  0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81,
  0xFE, 0x3F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xDF, 0x81, 0xF9,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xCF, 0x80,
  0xFD, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xF0, 0x7C, 0x3E, 0x1F,
  0x87, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0xFC, 0x07, 0xEF,
  0x80, 0xFD, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC7, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xFC, 0x3D, 0xC3, 0x9C, 0x79, 0xE7, 0x9E, 0x70, 0xEF,
  0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xC7, 0xCF, 0x8F, 0x80, 0x1F, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF1,
  0xF7, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBF, 0x1F, 0x3F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7C, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0xE1, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xBF, 0x1F, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xCF, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x87, 0xBE, 0x0F, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x83, 0xEF, 0x87, 0x9F, 0x1F, 0x3F,
  0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0x3E,
  0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87,
  0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x3C, 0xF8, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x87, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0xC3,
  0xF1, 0xFC, 0xFF, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0x9E, 0x3F, 0xBC,
  0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x87, 0xDF, 0x9F,
  0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xE3,
  0x0F, 0xCF, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0xF7,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x7D, 0xF1, 0xFB, 0xE7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F,
  0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF,
  0x0F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0xFD, 0xF0, 0xFB,
  0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xE1, 0xF1, 0xFF, 0xE7,
  0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xCF, 0xE7, 0xFF, 0x0F, 0x87,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE,
  0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1,
  0xF0, 0xF8, 0xF1, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xF3, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xDF,
  0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xDF, 0x0F, 0xBF, 0x3F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3,
  0xEF, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0x1E, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0x3C, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7D, 0xE1,
  0xF7, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0xE1, 0xFF, 0x87, 0xDF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFD,
  0xFF, 0xF1, 0xE7, 0xC0, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0x78,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF0, 0xF0, 0xFF, 0xC7, 0x87, 0xFE,
  0x3E, 0x3F, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C, 0xFC, 0x79, 0xE7, 0xF7,
  0xCF, 0xBF, 0xBE, 0x7D, 0xDD, 0xE1, 0xFE, 0xEF, 0x0F, 0xF7, 0xF8, 0x7F,
  0xBF, 0xC3, 0xF9, 0xFE, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0xF8, 0x7D, 0xF8, 0xF9,
  0xF3, 0xE3, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x3E, 0x7C, 0x7C, 0xFD, 0xF8, 0xFB, 0xE1, 0xF8, 0xFC, 0x3F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x03,
  0x83, 0xE3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF1, 0xF8, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x40, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xC7, 0xE3, 0xC3,
  0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0x20, 0x00, 0x1E, 0x00, 0x7F, 0x07, 0x7F, 0x8F, 0xFF, 0xCF,
  0xF3, 0xFF, 0xF1, 0xFE, 0xE0, 0xFE, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 9, 2, -26 },
  { 21, 9, 10, 12, 1, -27 },
  { 33, 17, 26, 19, 1, -26 },
  { 89, 15, 33, 18, 2, -30 },
  { 151, 19, 26, 23, 2, -26 },
  { 213, 19, 26, 21, 1, -26 },
  { 275, 4, 10, 6, 1, -27 },
  { 280, 9, 36, 12, 2, -28 },
  { 321, 9, 36, 12, 1, -28 },
  { 362, 16, 16, 16, 0, -26 },
  { 394, 15, 19, 17, 1, -22 },
  { 430, 6, 11, 9, 1, -4 },
  { 439, 9, 4, 13, 2, -13 },
  { 444, 6, 5, 10, 2, -5 },
  { 448, 11, 28, 12, 0, -26 },
  { 487, 15, 26, 18, 2, -26 },
  { 536, 10, 26, 18, 3, -26 },
  { 569, 16, 26, 18, 1, -26 },
  { 621, 15, 26, 18, 1, -26 },
  { 670, 16, 26, 18, 1, -26 },
  { 722, 15, 26, 18, 2, -26 },
  { 771, 15, 26, 18, 2, -26 },
  { 820, 16, 26, 18, 1, -26 },
  { 872, 14, 26, 18, 2, -26 },
  { 918, 14, 26, 18, 2, -26 },
  { 964, 6, 19, 10, 2, -19 },
  { 979, 7, 26, 9, 1, -19 },
  { 1002, 13, 17, 16, 1, -19 },
  { 1030, 14, 11, 18, 2, -17 },
  { 1050, 13, 17, 16, 2, -19 },
  { 1078, 14, 26, 16, 1, -26 },
  { 1124, 25, 33, 28, 1, -25 },
  { 1228, 21, 26, 22, 0, -26 },
  { 1297, 17, 26, 20, 2, -26 },
  { 1353, 17, 26, 21, 2, -26 },
  { 1409, 17, 26, 20, 2, -26 },
  { 1465, 15, 26, 18, 2, -26 },
  { 1514, 14, 26, 17, 2, -26 },
  { 1560, 17, 26, 21, 2, -26 },
  { 1616, 18, 26, 22, 2, -26 },
  { 1675, 5, 26, 10, 2, -26 },
  { 1692, 15, 26, 18, 1, -26 },
  { 1741, 18, 26, 20, 2, -26 },
  { 1800, 14, 26, 17, 2, -26 },
  { 1846, 23, 26, 27, 2, -26 },
  { 1921, 18, 26, 22, 2, -26 },
  { 1980, 18, 26, 22, 2, -26 },
  { 2039, 17, 26, 20, 2, -26 },
  { 2095, 18, 31, 22, 2, -26 },
  { 2165, 17, 26, 20, 2, -26 },
  { 2221, 17, 26, 19, 1, -26 },
  { 2277, 18, 26, 20, 1, -26 },
  { 2336, 17, 26, 21, 2, -26 },
  { 2392, 20, 26, 21, 0, -26 },
  { 2457, 25, 26, 27, 1, -26 },
  { 2539, 19, 26, 20, 1, -26 },
  { 2601, 19, 26, 20, 0, -26 },
  { 2663, 17, 26, 19, 1, -26 },
  { 2719, 7, 36, 10, 2, -30 },
  { 2751, 14, 28, 14, 0, -26 },
  { 2800, 6, 36, 10, 1, -30 },
  { 2827, 12, 13, 14, 1, -26 },
  { 2847, 14, 4, 14, 0, 0 },
  { 2854, 9, 5, 12, 1, -27 },
  { 2860, 15, 19, 17, 1, -19 },
  { 2896, 15, 27, 18, 2, -27 },
  { 2947, 15, 19, 17, 1, -19 },
  { 2983, 15, 27, 18, 1, -27 },
  { 3034, 15, 19, 17, 1, -19 },
  { 3070, 10, 27, 12, 1, -27 },
  { 3104, 15, 26, 18, 1, -19 },
  { 3153, 14, 27, 18, 2, -27 },
  { 3201, 5, 26, 9, 2, -26 },
  { 3218, 8, 33, 9, -1, -26 },
  { 3251, 15, 27, 17, 2, -27 },
  { 3302, 5, 27, 9, 2, -27 },
  { 3319, 23, 19, 27, 2, -19 },
  { 3374, 14, 19, 18, 2, -19 },
  { 3408, 16, 19, 18, 1, -19 },
  { 3446, 15, 26, 18, 2, -19 },
  { 3495, 15, 26, 18, 1, -19 },
  { 3544, 9, 19, 12, 2, -19 },
  { 3566, 14, 19, 16, 1, -19 },
  { 3600, 10, 24, 11, 0, -24 },
  { 3630, 14, 19, 18, 2, -19 },
  { 3664, 16, 19, 16, 0, -19 },
  { 3702, 21, 19, 23, 1, -19 },
  { 3752, 15, 19, 16, 1, -19 },
  { 3788, 16, 26, 16, 0, -19 },
  { 3840, 14, 19, 16, 1, -19 },
  { 3874, 9, 34, 11, 1, -28 },
  { 3913, 3, 31, 9, 3, -26 },
  { 3925, 9, 34, 11, 1, -28 },
  { 3964, 16, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_Bold36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_BOLD36PT7B_H_
