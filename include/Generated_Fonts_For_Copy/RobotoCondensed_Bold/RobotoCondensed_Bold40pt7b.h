#ifndef _ROBOTOCONDENSED_BOLD40PT7B_H_
#define _ROBOTOCONDENSED_BOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x00, 0x03, 0x9F, 0xFF, 0xF7, 0xCE, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xEF, 0x1D, 0xE3, 0xBC, 0x77, 0x8E, 0xF1, 0xDE, 0x3B,
  0x87, 0x00, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07,
  0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x40, 0xF1, 0xC3, 0xC3, 0x87,
  0x8E, 0x0E, 0x1E, 0x78, 0x38, 0x79, 0xC0, 0xF1, 0xCF, 0x03, 0xEF, 0x38,
  0x07, 0xFD, 0xE0, 0x1F, 0xE7, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0xE7, 0xF0, 0x07, 0xBF, 0xE0, 0x1D,
  0xF7, 0x80, 0xF7, 0x8F, 0x03, 0x9E, 0x3C, 0x1C, 0x78, 0xF0, 0xF1, 0xE3,
  0xC3, 0x87, 0x8F, 0x0E, 0x1F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1F,
  0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF9, 0xF3, 0xE7,
  0xEF, 0x9F, 0x3F, 0xF9, 0xF8, 0xFF, 0xCF, 0xC3, 0xFE, 0x7E, 0x0F, 0xE1,
  0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80,
  0x60, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x06,
  0x00, 0x80, 0x40, 0x18, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x01, 0x80, 0x40, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x07, 0x8E, 0x3B, 0xF7, 0x7D, 0xFF, 0xFF, 0x3F,
  0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xF3, 0xE0,
  0xF0, 0xF0, 0x30, 0x38, 0x08, 0x10, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E, 0x79,
  0xF3, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0xFB,
  0xFB, 0xF7, 0xC7, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xF8, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E,
  0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE7, 0xE3, 0xF8, 0x20, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xEF, 0x81, 0xF7, 0xE0, 0xFB, 0xF0, 0xFC, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x78, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xF8, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3E, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0xBF, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3C, 0xFB, 0xFB, 0xF7, 0xC7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7,
  0x80, 0x3C, 0x7E, 0x7E, 0x7E, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x30, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x7F, 0x07, 0xFC, 0x7F, 0xF3, 0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFC,
  0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xF8,
  0x01, 0xC0, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1C, 0x1E, 0x07, 0xC1, 0xE3, 0xC0, 0xFF, 0x0E, 0x3C, 0x1F, 0xF8,
  0xE3, 0xC3, 0xEF, 0x8F, 0x78, 0x7C, 0x70, 0xF7, 0x87, 0x87, 0x07, 0x78,
  0x78, 0x70, 0x77, 0x8F, 0x0F, 0x07, 0x70, 0xF0, 0xF0, 0x77, 0x0F, 0x0F,
  0x07, 0x70, 0xF0, 0xF0, 0x77, 0x0F, 0x0F, 0x0F, 0x70, 0xF0, 0xF0, 0xF7,
  0x0F, 0x0F, 0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x1F, 0x1E, 0x78, 0xFF,
  0xF3, 0xC7, 0x87, 0xFF, 0xFC, 0x78, 0x7F, 0x7F, 0x83, 0x81, 0xE3, 0xE0,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x7F, 0x9F, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xBF, 0x03, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0x7E, 0x07,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF9, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x3E,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7F,
  0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE,
  0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE,
  0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0x7F, 0xFF, 0x87, 0xDF, 0xFF,
  0xE1, 0xF7, 0xFF, 0x78, 0x79, 0xFF, 0xDF, 0x1E, 0x7F, 0xF7, 0xCF, 0x9F,
  0xFD, 0xF3, 0xE7, 0xFF, 0x3E, 0xF1, 0xFF, 0xCF, 0xFC, 0xFF, 0xF3, 0xFF,
  0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8, 0xFF, 0xF0,
  0xFE, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC1, 0xF0, 0xFF,
  0xF0, 0x78, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFD, 0xF1, 0xFF,
  0xDF, 0x9F, 0xFC, 0xF9, 0xFF, 0xCF, 0xDF, 0xFC, 0x7D, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x7E, 0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E,
  0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xF7,
  0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x83, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xEF,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF7, 0xC1, 0xF8, 0x3F, 0x7C,
  0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7E, 0x3F, 0xC3, 0xE7, 0xE3, 0xFC,
  0x7E, 0x7E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3,
  0xE7, 0xFE, 0x7C, 0x3E, 0x7F, 0xE7, 0xC3, 0xF7, 0xFE, 0xFC, 0x1F, 0x79,
  0xEF, 0xC1, 0xF7, 0x9E, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF8,
  0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0xFE,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F,
  0xC0, 0x7E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x0F, 0x38, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x1E, 0xF8, 0x7B,
  0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xF7, 0xF3, 0xF1, 0xF9, 0xF0, 0xFC, 0x00, 0x7E, 0x07,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xE7, 0xE7, 0xC3, 0xF3, 0xE1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7E, 0x7E, 0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFB,
  0xE0, 0xF9, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB,
  0xFC, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F,
  0xFF, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x87, 0xCF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3F,
  0x7E, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x3C,
  0x7C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x0C, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x1F, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x07, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E,
  0xFC, 0x3F, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFD, 0xF0, 0x7C,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x30, 0x3F, 0x1E, 0x7F, 0x9F, 0xFF, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x3B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xBF, 0xDF, 0xEF, 0xE7, 0xC0,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0xBF, 0x1F, 0xDF,
  0x8F, 0xCF, 0xCF, 0xC7, 0xEF, 0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xF7,
  0xE1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x87, 0xEF,
  0xC3, 0xF7, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x0F, 0xC3, 0xEF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xC0,
  0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x3E,
  0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFD, 0xF0,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E,
  0xFC, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7D,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F,
  0x0F, 0xE0, 0x7C, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xF8, 0x3C, 0x3F, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E,
  0xFC, 0x7C, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0x7C,
  0x7C, 0xFE, 0x7C, 0x7C, 0xFF, 0x7C, 0x3D, 0xFF, 0x7C, 0x3F, 0xEF, 0x78,
  0x3F, 0xEF, 0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8,
  0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xE0, 0xFC, 0x3F, 0x3E, 0x1F, 0x9F, 0x9F,
  0x87, 0xCF, 0xC3, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0x7C, 0x3F, 0x3F, 0x1F, 0x8F, 0x9F, 0x87,
  0xEF, 0xC3, 0xF0, 0xFC, 0x0F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF1, 0xF8, 0xFC, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBF,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xE0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x1C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x70, 0x10, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xEF, 0x0F, 0xFB, 0xC1, 0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 11, 11, 13, 1, -30 },
  { 38, 19, 28, 21, 1, -28 },
  { 105, 16, 36, 20, 2, -32 },
  { 177, 22, 28, 26, 2, -28 },
  { 254, 21, 28, 23, 1, -28 },
  { 328, 4, 11, 6, 1, -30 },
  { 334, 10, 41, 13, 2, -32 },
  { 386, 10, 41, 13, 1, -32 },
  { 438, 17, 17, 18, 1, -28 },
  { 475, 17, 21, 19, 1, -24 },
  { 520, 7, 12, 10, 1, -5 },
  { 531, 10, 5, 14, 2, -15 },
  { 538, 7, 6, 12, 2, -6 },
  { 544, 13, 30, 13, 0, -28 },
  { 593, 16, 28, 20, 2, -28 },
  { 649, 11, 28, 20, 3, -28 },
  { 688, 18, 28, 20, 1, -28 },
  { 751, 17, 28, 20, 1, -28 },
  { 811, 18, 28, 20, 1, -28 },
  { 874, 17, 28, 20, 2, -28 },
  { 934, 17, 28, 20, 2, -28 },
  { 994, 18, 28, 20, 1, -28 },
  { 1057, 16, 28, 20, 2, -28 },
  { 1113, 16, 28, 20, 2, -28 },
  { 1169, 7, 22, 11, 2, -22 },
  { 1189, 8, 29, 10, 1, -22 },
  { 1218, 14, 19, 18, 1, -22 },
  { 1252, 14, 14, 20, 3, -20 },
  { 1277, 15, 19, 18, 2, -22 },
  { 1313, 15, 28, 18, 1, -28 },
  { 1366, 28, 37, 31, 1, -28 },
  { 1496, 24, 28, 24, 0, -28 },
  { 1580, 19, 28, 22, 2, -28 },
  { 1647, 20, 28, 23, 2, -28 },
  { 1717, 19, 28, 23, 2, -28 },
  { 1784, 17, 28, 20, 2, -28 },
  { 1844, 16, 28, 19, 2, -28 },
  { 1900, 20, 28, 23, 2, -28 },
  { 1970, 20, 28, 25, 2, -28 },
  { 2040, 5, 28, 11, 3, -28 },
  { 2058, 16, 28, 20, 1, -28 },
  { 2114, 20, 28, 22, 2, -28 },
  { 2184, 16, 28, 19, 2, -28 },
  { 2240, 26, 28, 30, 2, -28 },
  { 2331, 20, 28, 25, 2, -28 },
  { 2401, 20, 28, 24, 2, -28 },
  { 2471, 19, 28, 23, 2, -28 },
  { 2538, 20, 33, 24, 2, -28 },
  { 2621, 19, 28, 22, 2, -28 },
  { 2688, 19, 28, 22, 1, -28 },
  { 2755, 20, 28, 22, 1, -28 },
  { 2825, 19, 28, 23, 2, -28 },
  { 2892, 23, 28, 23, 0, -28 },
  { 2973, 28, 28, 30, 1, -28 },
  { 3071, 21, 28, 22, 1, -28 },
  { 3145, 21, 28, 22, 0, -28 },
  { 3219, 19, 28, 21, 1, -28 },
  { 3286, 8, 40, 11, 2, -33 },
  { 3326, 16, 30, 15, 0, -28 },
  { 3386, 7, 40, 11, 1, -33 },
  { 3421, 14, 14, 16, 1, -28 },
  { 3446, 16, 4, 16, 0, 0 },
  { 3454, 10, 6, 13, 1, -30 },
  { 3462, 17, 21, 19, 1, -21 },
  { 3507, 16, 30, 20, 2, -30 },
  { 3567, 16, 21, 18, 1, -21 },
  { 3609, 17, 30, 20, 1, -30 },
  { 3673, 16, 21, 19, 2, -21 },
  { 3715, 12, 30, 13, 1, -30 },
  { 3760, 17, 29, 20, 1, -21 },
  { 3822, 16, 30, 20, 2, -30 },
  { 3882, 6, 30, 10, 2, -30 },
  { 3905, 9, 38, 10, -1, -30 },
  { 3948, 17, 30, 19, 2, -30 },
  { 4012, 6, 30, 10, 2, -30 },
  { 4035, 26, 21, 30, 2, -21 },
  { 4104, 16, 21, 20, 2, -21 },
  { 4146, 18, 21, 20, 1, -21 },
  { 4194, 16, 29, 20, 2, -21 },
  { 4252, 17, 29, 20, 1, -21 },
  { 4314, 10, 21, 13, 2, -21 },
  { 4341, 16, 21, 18, 1, -21 },
  { 4383, 11, 26, 12, 0, -26 },
  { 4419, 16, 21, 20, 2, -21 },
  { 4461, 16, 21, 18, 1, -21 },
  { 4503, 24, 21, 25, 1, -21 },
  { 4566, 17, 21, 18, 1, -21 },
  { 4611, 17, 29, 18, 0, -21 },
  { 4673, 14, 21, 18, 2, -21 },
  { 4710, 10, 38, 12, 1, -31 },
  { 4758, 4, 33, 10, 3, -28 },
  { 4775, 10, 38, 12, 1, -31 },
  { 4823, 18, 9, 22, 2, -16 },
};

const GFXfont RobotoCondensed_Bold40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_BOLD40PT7B_H_
