#ifndef _ROBOTOCONDENSED_BOLD26PT7B_H_
#define _ROBOTOCONDENSED_BOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xCF, 0x9F, 0x36,
  0x6C, 0xD9, 0xB3, 0x00, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1,
  0xDC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3,
  0xB0, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x0F, 0x83, 0xF8, 0xFF, 0x9E, 0x7B, 0x8F, 0x71, 0xEF, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0xF1, 0xFE, 0x3D, 0xC7, 0xBF,
  0xE3, 0xFC, 0x3E, 0x01, 0x80, 0x30, 0x3C, 0x01, 0xF8, 0x0E, 0xE2, 0x39,
  0x9C, 0xE6, 0x63, 0x9B, 0x8E, 0xEC, 0x1F, 0xF0, 0x3D, 0x80, 0x0E, 0x00,
  0x37, 0x81, 0xBF, 0x06, 0xCC, 0x33, 0x30, 0xCC, 0xC6, 0x33, 0x18, 0xCC,
  0x03, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x03, 0xF8, 0x1E, 0x70, 0x71,
  0xC1, 0xE7, 0x07, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xF3, 0xBF,
  0xDE, 0xF7, 0xF3, 0xCF, 0xCF, 0x3F, 0x3C, 0x78, 0x7F, 0xF1, 0xFF, 0xE1,
  0xF7, 0x80, 0xFF, 0xFC, 0x08, 0x73, 0x8E, 0x71, 0xC6, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x0E, 0x38, 0x70,
  0x80, 0x83, 0x0E, 0x1C, 0x70, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x73, 0xCE, 0x38, 0xE7, 0x1C, 0xE3, 0x08, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x06, 0x66, 0x7F, 0xE3, 0xFC, 0x0F, 0x01, 0xF8, 0x39, 0x83,
  0x9C, 0x10, 0x80, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0x39, 0xCE, 0x73, 0xB9,
  0xCC, 0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0x1F, 0x07, 0xF1, 0xFF, 0x3C, 0xE7, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDC, 0x7B,
  0xCE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x06, 0x3D, 0xFF, 0xFF, 0xF1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x1F,
  0x07, 0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xE3, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x1F, 0x83, 0xE0, 0x7F, 0x00, 0xE0, 0x1E, 0x03, 0xF8, 0x7F, 0x8F,
  0xFF, 0xCF, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xF1, 0xDE, 0x3B, 0xCE, 0x79, 0xCF, 0x79, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xCF, 0xF9, 0xFF,
  0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xFE, 0x7F, 0xC6, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFC, 0x7F, 0x8F, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x07,
  0x81, 0xF0, 0x7E, 0x1E, 0x07, 0x80, 0xE0, 0x1D, 0xE7, 0xFE, 0xFF, 0xDE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x7B, 0xCF, 0x7F, 0xC7, 0xF0,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3C, 0xE7, 0x1E,
  0xE3, 0xDC, 0x73, 0xCE, 0x3F, 0x83, 0xF1, 0xFF, 0x38, 0xEF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0x7F, 0xC7, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xF1, 0xFF,
  0x3D, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xEE, 0x3D, 0xFF, 0x9F,
  0xF1, 0xDC, 0x03, 0x80, 0xF0, 0x3C, 0x3F, 0x87, 0xE0, 0xF0, 0x00, 0xEF,
  0xFE, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x77, 0xBC, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE7, 0x39, 0xCE, 0x77, 0x10, 0x00, 0x81, 0xC3, 0xE7, 0xFF, 0xE7,
  0x83, 0xC1, 0xFC, 0x3F, 0x87, 0xC0, 0xE0, 0x10, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3E, 0x1F, 0xC3, 0xF8, 0x7C,
  0x3E, 0x7F, 0xFE, 0x7C, 0x38, 0x10, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xCF,
  0xE3, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x00,
  0xE0, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x3C, 0x67, 0x1F, 0x99, 0x8E,
  0x67, 0x63, 0x38, 0xF9, 0xCE, 0x3E, 0x73, 0x8F, 0x98, 0xE3, 0xC6, 0x38,
  0xF1, 0x8E, 0x7C, 0x73, 0x1B, 0x9D, 0xEE, 0xE7, 0xDF, 0x18, 0xE7, 0x86,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x84, 0x00, 0xFF, 0x80, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xB8, 0x07, 0x78, 0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xE0, 0xE3, 0xC3,
  0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3F, 0xC0,
  0x78, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xEF, 0xFC, 0xFF, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF1,
  0xE7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x3D, 0xC1, 0xEF, 0x1F, 0x7F, 0xF1, 0xFF, 0x03,
  0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF1, 0xF7, 0x07, 0xF8, 0x3F, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xF8, 0x3D, 0xE1,
  0xEF, 0x0F, 0x3F, 0xF9, 0xFF, 0x83, 0xF0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xF8, 0x7E, 0x3F, 0xCF, 0xFF, 0x9F, 0xE1, 0xE0, 0xF0, 0x7F,
  0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x3E, 0x79, 0xE3, 0xDE, 0x1E, 0xF0, 0xFF,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xBC, 0x78, 0xF3, 0xC7, 0x9E, 0x3E,
  0xF0, 0xF7, 0x87, 0xFC, 0x1E, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x77, 0xFF, 0x3B, 0xFB, 0x9D, 0xFD, 0xCE, 0xFE, 0xEE, 0x7F, 0x3F, 0x3F,
  0x9F, 0x9F, 0xCF, 0x8F, 0xE7, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x70,
  0xE0, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xE7, 0xF7, 0x3F, 0xBD, 0xFC, 0xEF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0E, 0x0F, 0xC0, 0xFF, 0x0F,
  0xFC, 0xF1, 0xF7, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC1, 0xEF, 0x1F, 0x3F, 0xF1,
  0xFF, 0x03, 0xF0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xC0,
  0x7F, 0x83, 0xFF, 0x1E, 0x3E, 0x70, 0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0E,
  0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC1, 0xE7, 0x87,
  0x9E, 0x3E, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x40, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE,
  0x1E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xF8, 0xE7, 0x8E, 0x3C, 0xE3, 0xCE,
  0x3C, 0xE1, 0xEE, 0x1E, 0xE0, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9E,
  0xF0, 0xFF, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x03, 0xE0, 0xF0,
  0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0xC7, 0x8F, 0x0F, 0x1E,
  0x1E, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xEE, 0x01,
  0xDC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xE1,
  0xC3, 0xF8, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8E, 0xF3, 0xE3, 0x9C, 0xF9,
  0xE7, 0x3F, 0x79, 0xCF, 0xDE, 0x7B, 0xF7, 0x1F, 0xDD, 0xC7, 0xF7, 0x70,
  0xFD, 0xDC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x3D, 0xE1, 0xE3, 0xC7, 0x8F,
  0x1C, 0x1E, 0xF0, 0x7B, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0x79,
  0xE1, 0xE7, 0x83, 0xC0, 0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x8E, 0x1C, 0x3C,
  0xF0, 0xF3, 0xC1, 0xCE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF, 0xFF, 0xC0,
  0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x0F, 0x07,
  0xC7, 0xE3, 0x31, 0x9D, 0xCE, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1,
  0xE3, 0x87, 0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0x03, 0xC7, 0xF7, 0xFF, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xFF, 0x7F, 0xCF, 0x70, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFB, 0xFF, 0x7B, 0xC0,
  0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xF1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x7F, 0x3D, 0xFF, 0x7F, 0x87, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xCF, 0x7B, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xEF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1F, 0x07,
  0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03,
  0xC3, 0x3F, 0xE3, 0xFC, 0x3E, 0x00, 0x0F, 0x1F, 0x1F, 0x3C, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3D, 0xEF, 0xFD, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xFE, 0x7B, 0xC0, 0x79, 0x0F,
  0x7F, 0xCF, 0xF0, 0x7C, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE, 0x3B, 0xC7, 0x78, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x6F, 0xF7, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF3, 0xC7, 0x00, 0x03,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0xFE, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x7F,
  0x9E, 0xF7, 0x9E, 0xF3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xE7, 0xBC,
  0xF3, 0xDE, 0x7B, 0xC7, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9E, 0x7F, 0xFF, 0xBF, 0xFF, 0xFE, 0x3C,
  0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8,
  0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x3C, 0xF7, 0x9F,
  0xFB, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFF,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xBF, 0xE3, 0xF8,
  0x3E, 0x00, 0xF7, 0x9F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFF, 0xEF, 0xFD, 0xEF, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3D, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xFE, 0x7B,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF7, 0xFF, 0xFF, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x3E, 0x1F, 0xEF,
  0xFB, 0xCF, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x3F, 0xFF,
  0x7F, 0x8F, 0x80, 0x38, 0x70, 0xE7, 0xFF, 0xFF, 0xCE, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x8F, 0x9F, 0x1E, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xFE,
  0x7B, 0xC0, 0xF1, 0xEE, 0x3D, 0xE7, 0xBC, 0xE3, 0x9C, 0x77, 0x8E, 0xF1,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x71, 0xCF,
  0x71, 0xCF, 0x73, 0xCF, 0x73, 0xCE, 0x7B, 0xEE, 0x3B, 0xEE, 0x3F, 0xEE,
  0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0x1E, 0x38,
  0x1C, 0x38, 0x79, 0xEF, 0x3C, 0xFF, 0x1F, 0xE1, 0xF8, 0x3E, 0x03, 0xC0,
  0x78, 0x1F, 0x83, 0xF0, 0xFF, 0x1D, 0xE7, 0x9E, 0xE3, 0xC0, 0xF0, 0xEE,
  0x3D, 0xE7, 0xBC, 0xE3, 0x9C, 0x77, 0x8E, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x73, 0xCE, 0x39, 0xE7,
  0x9E, 0x79, 0xE7, 0x3C, 0xE3, 0xC7, 0x1E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x87, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x8F, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x8F, 0x1C, 0xF7, 0x9C, 0x71, 0xC7, 0x1C, 0x71,
  0xCF, 0x38, 0xC0, 0x3C, 0x37, 0xE7, 0x7E, 0x76, 0x7F, 0xE3, 0xEE, 0x1C,
};

const GFXglyph RobotoCondensed_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 8, 1, -20 },
  { 16, 12, 19, 14, 1, -19 },
  { 45, 11, 24, 13, 1, -22 },
  { 78, 14, 19, 17, 1, -19 },
  { 112, 14, 19, 15, 1, -19 },
  { 146, 2, 7, 4, 1, -20 },
  { 148, 6, 27, 8, 2, -21 },
  { 169, 6, 27, 8, 1, -21 },
  { 190, 12, 11, 12, 0, -19 },
  { 207, 10, 13, 12, 1, -15 },
  { 224, 5, 8, 6, 0, -3 },
  { 229, 6, 3, 9, 2, -9 },
  { 232, 4, 4, 8, 2, -4 },
  { 234, 8, 21, 9, 0, -19 },
  { 255, 11, 19, 13, 1, -19 },
  { 282, 7, 19, 13, 2, -19 },
  { 299, 11, 19, 13, 1, -19 },
  { 326, 11, 19, 13, 1, -19 },
  { 353, 11, 19, 13, 1, -19 },
  { 380, 11, 19, 13, 1, -19 },
  { 407, 11, 19, 13, 1, -19 },
  { 434, 11, 19, 13, 1, -19 },
  { 461, 11, 19, 13, 1, -19 },
  { 488, 11, 19, 13, 1, -19 },
  { 515, 4, 14, 7, 2, -14 },
  { 522, 5, 19, 7, 1, -14 },
  { 534, 9, 12, 12, 1, -14 },
  { 548, 9, 8, 13, 2, -12 },
  { 557, 9, 12, 12, 2, -14 },
  { 571, 10, 19, 12, 1, -19 },
  { 595, 18, 24, 20, 1, -18 },
  { 649, 15, 19, 16, 0, -19 },
  { 685, 12, 19, 15, 1, -19 },
  { 714, 13, 19, 15, 1, -19 },
  { 745, 12, 19, 15, 1, -19 },
  { 774, 11, 19, 13, 1, -19 },
  { 801, 11, 19, 12, 1, -19 },
  { 828, 13, 19, 15, 1, -19 },
  { 859, 13, 19, 16, 1, -19 },
  { 890, 3, 19, 7, 2, -19 },
  { 898, 10, 19, 13, 1, -19 },
  { 922, 13, 19, 14, 1, -19 },
  { 953, 11, 19, 12, 1, -19 },
  { 980, 17, 19, 20, 1, -19 },
  { 1021, 13, 19, 16, 1, -19 },
  { 1052, 13, 19, 16, 1, -19 },
  { 1083, 13, 19, 15, 1, -19 },
  { 1114, 14, 22, 16, 1, -19 },
  { 1153, 12, 19, 14, 2, -19 },
  { 1182, 12, 19, 14, 1, -19 },
  { 1211, 12, 19, 14, 1, -19 },
  { 1240, 13, 19, 15, 1, -19 },
  { 1271, 15, 19, 15, 0, -19 },
  { 1307, 18, 19, 19, 1, -19 },
  { 1350, 14, 19, 15, 0, -19 },
  { 1384, 14, 19, 14, 0, -19 },
  { 1418, 12, 19, 14, 1, -19 },
  { 1447, 5, 26, 7, 1, -22 },
  { 1464, 10, 21, 10, 0, -19 },
  { 1491, 5, 26, 7, 0, -22 },
  { 1508, 9, 9, 10, 1, -19 },
  { 1519, 10, 3, 10, 0, 0 },
  { 1523, 6, 4, 9, 1, -20 },
  { 1526, 10, 14, 12, 1, -14 },
  { 1544, 11, 20, 13, 1, -20 },
  { 1572, 10, 14, 12, 1, -14 },
  { 1590, 11, 20, 13, 1, -20 },
  { 1618, 11, 14, 12, 1, -14 },
  { 1638, 8, 20, 9, 0, -20 },
  { 1658, 11, 19, 13, 1, -14 },
  { 1685, 11, 20, 13, 1, -20 },
  { 1713, 4, 20, 7, 1, -20 },
  { 1723, 6, 25, 6, -1, -20 },
  { 1742, 11, 20, 12, 1, -20 },
  { 1770, 4, 20, 7, 1, -20 },
  { 1780, 17, 14, 19, 1, -14 },
  { 1810, 11, 14, 13, 1, -14 },
  { 1830, 11, 14, 13, 1, -14 },
  { 1850, 11, 19, 13, 1, -14 },
  { 1877, 11, 19, 13, 1, -14 },
  { 1904, 7, 14, 9, 1, -14 },
  { 1917, 10, 14, 12, 1, -14 },
  { 1935, 7, 17, 8, 0, -17 },
  { 1950, 11, 14, 13, 1, -14 },
  { 1970, 11, 14, 12, 0, -14 },
  { 1990, 16, 14, 16, 0, -14 },
  { 2018, 11, 14, 12, 0, -14 },
  { 2038, 11, 19, 12, 0, -14 },
  { 2065, 10, 14, 12, 1, -14 },
  { 2083, 6, 25, 8, 1, -20 },
  { 2102, 2, 22, 7, 2, -19 },
  { 2108, 6, 25, 8, 1, -20 },
  { 2127, 12, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_Bold26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_BOLD26PT7B_H_
