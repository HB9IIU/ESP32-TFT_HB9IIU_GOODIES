#ifndef _ROBOTOCONDENSED_BOLD42PT7B_H_
#define _ROBOTOCONDENSED_BOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x38, 0xFB,
  0xFF, 0xF7, 0xC7, 0x00, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3B, 0xC7, 0x00, 0x03, 0xC7, 0x00, 0x78,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x00, 0xE3,
  0x80, 0x3C, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x71, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x3C,
  0x01, 0xC7, 0x83, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xE0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x3F, 0x1F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB,
  0xF0, 0x7D, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xE1, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xDF, 0x04, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x38, 0x3C, 0x78,
  0xF0, 0x78, 0xF1, 0xC0, 0xF1, 0xE7, 0x81, 0xE3, 0xCE, 0x03, 0xEF, 0xBC,
  0x03, 0xFE, 0x70, 0x03, 0xF9, 0xE0, 0x03, 0xE3, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xF0, 0x03, 0x9F, 0xF0,
  0x0F, 0x7D, 0xF0, 0x1C, 0xF1, 0xE0, 0x79, 0xE3, 0xC0, 0xE3, 0xC7, 0x83,
  0xC7, 0x8F, 0x07, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x18, 0x3E, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x7C, 0x1F, 0xF8, 0xF8, 0x7F, 0xF9, 0xF1,
  0xFB, 0xF3, 0xE3, 0xF3, 0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x87, 0xFE, 0x1F,
  0x07, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xC0, 0x7E, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBC, 0x00, 0x40, 0x70, 0x3C, 0x0F, 0x07,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xC0, 0x10, 0x40,
  0x18, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xC0,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83,
  0xC0, 0x60, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x38, 0x70, 0x6F, 0xDC, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0xDF, 0x03,
  0xE3, 0xE0, 0xF0, 0x78, 0x1C, 0x1C, 0x02, 0x02, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0xBE, 0x7C, 0xF3, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x30, 0x1F, 0x07, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC3, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x7C,
  0x0F, 0xDF, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0, 0xFD, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F,
  0xDF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xDF, 0x80, 0xFB, 0xF0, 0x1E, 0x7E, 0x07, 0xCF, 0xC0,
  0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7E, 0x0F,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0x38, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0x7E, 0x3F, 0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xCF, 0x83, 0xF7, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x7E, 0x7E, 0x3F,
  0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0x7E, 0xF8,
  0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x87, 0xCF, 0xC7, 0xE3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0x1F, 0x9F, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1,
  0xFB, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xF3, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x3E, 0x3F,
  0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x78, 0xF8, 0x30, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x03,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x3E, 0x07,
  0x1E, 0x07, 0xFC, 0x3C, 0xF0, 0x7F, 0xF1, 0xE7, 0x83, 0xFF, 0x87, 0x78,
  0x3E, 0x3C, 0x3B, 0xC1, 0xE1, 0xE1, 0xDE, 0x1E, 0x1E, 0x0E, 0xF0, 0xF0,
  0xF0, 0x77, 0x87, 0x87, 0x83, 0xBC, 0x7C, 0x3C, 0x1D, 0xE3, 0xE1, 0xE0,
  0xEF, 0x1F, 0x0F, 0x07, 0x78, 0xF0, 0x78, 0x3B, 0xC7, 0xC3, 0xC3, 0xDE,
  0x3E, 0x3E, 0x1C, 0xF1, 0xF1, 0xF1, 0xE7, 0x87, 0xFF, 0xDF, 0x3C, 0x3F,
  0xDF, 0xF1, 0xF0, 0xFE, 0xFF, 0x07, 0x83, 0xC3, 0xE0, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x3F,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8,
  0x0F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F, 0x07,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x83, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0xBF,
  0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x7E,
  0x0F, 0xE3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFE, 0xFE, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0x83,
  0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3D, 0xFF, 0xFF, 0x0F, 0xBF, 0xFB, 0xE1, 0xF7, 0xFF, 0x7C, 0x3E, 0xFF,
  0xEF, 0x8F, 0x9F, 0xFC, 0xF9, 0xF3, 0xFF, 0x9F, 0x3E, 0x7F, 0xF3, 0xEF,
  0x8F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8, 0xFF, 0xC7, 0xFF,
  0x1F, 0xF0, 0xFF, 0xE1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xF0,
  0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8,
  0x3E, 0x07, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xDF,
  0x0F, 0xFE, 0xFC, 0x7F, 0xF3, 0xE3, 0xFF, 0x9F, 0x9F, 0xFC, 0x7C, 0xFF,
  0xE3, 0xF7, 0xFF, 0x0F, 0xBF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x7E, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFD,
  0xFC, 0x3F, 0xBF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3F, 0x07, 0xEF,
  0xC0, 0xFC, 0x1F, 0x9F, 0x03, 0xF0, 0x7E, 0x7E, 0x1F, 0xC1, 0xF9, 0xF8,
  0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x1F, 0x87, 0xF8, 0x7C, 0x7E, 0x1F,
  0xE3, 0xF0, 0xF8, 0xFF, 0x8F, 0xC3, 0xE3, 0xFE, 0x3F, 0x0F, 0xCF, 0xF8,
  0xFC, 0x3F, 0x3F, 0xF3, 0xE0, 0xFC, 0xFF, 0xCF, 0x81, 0xF3, 0xDF, 0x7E,
  0x07, 0xDF, 0x7D, 0xF8, 0x1F, 0x7C, 0xF7, 0xE0, 0x7F, 0xF3, 0xFF, 0x81,
  0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF9,
  0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E,
  0x1F, 0x81, 0xF8, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x01, 0xFC, 0xFC,
  0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFD, 0xF8,
  0x07, 0xF7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00,
  0x7C, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xEF, 0x07, 0xBC, 0x3C,
  0xF0, 0xF3, 0xE3, 0xC7, 0x9F, 0x1E, 0x78, 0x7D, 0xE0, 0xFF, 0x83, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x3E, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xF9, 0xF0, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD,
  0xF8, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0xFC, 0x1F, 0x7E, 0x1F, 0xBF,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0xFC, 0x7F,
  0xBF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xF8, 0x7F, 0x7E, 0x0F,
  0xDF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x1F, 0x3F, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x06, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x7F,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x07, 0xC7, 0xC7,
  0xFD, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC3, 0xF7, 0xE0,
  0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7F, 0x0F, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xF3, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC6, 0x07, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x3E, 0x1F, 0xBF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0x7B, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xF7, 0xFB, 0xF9, 0xF0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3,
  0xFB, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF7, 0xF0,
  0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFE, 0xFC, 0x3F, 0x3F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x3F, 0x1F, 0xBF, 0xCF, 0xF3, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF,
  0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C,
  0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF,
  0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0,
  0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8,
  0x3E, 0x0F, 0xC0, 0xF8, 0xF8, 0x7E, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0x9F, 0xC7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7C, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7F, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0xF8, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF,
  0xE7, 0xE7, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC7,
  0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x87, 0xF7,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xEF, 0xC1, 0xF3, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0xFC, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xF7, 0xF3, 0xE1, 0xF9, 0xF0, 0x7C, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFD, 0xF8,
  0x3F, 0xFC, 0x1F, 0xBF, 0xBF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFD, 0xF8, 0x7C, 0xFC, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0xBF, 0x0F, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xF8, 0x3C, 0x1F, 0xFC, 0x1F, 0x0F,
  0xFF, 0x0F, 0x87, 0xDF, 0x8F, 0xC3, 0xE7, 0xC7, 0xE1, 0xF3, 0xE3, 0xF9,
  0xF9, 0xF1, 0xFC, 0xF8, 0xF9, 0xFE, 0x7C, 0x7E, 0xFF, 0x3E, 0x1F, 0x7F,
  0xDF, 0x0F, 0xBD, 0xEF, 0x87, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0xFF,
  0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0xFC, 0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0xC7, 0xE7, 0xC3,
  0xF7, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0x8F, 0xCF, 0xC7, 0xEF, 0xE1, 0xFF,
  0xE0, 0xFC, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x7E, 0x3E,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xEF,
  0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0xF0, 0x7C, 0x3F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x3F, 0x1F, 0x8F, 0xE3, 0xE0, 0xFC, 0x3F, 0x83, 0xE0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x1C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07,
  0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0xFC, 0x3E, 0x07, 0x01, 0x80,
  0x0F, 0x00, 0x07, 0xF8, 0x3D, 0xFF, 0x87, 0xBF, 0xF9, 0xF7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xBE, 0x1F, 0xF7, 0x81, 0xFC, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 30, 11, 2, -30 },
  { 28, 11, 11, 13, 1, -32 },
  { 44, 19, 30, 22, 2, -30 },
  { 116, 17, 38, 21, 2, -34 },
  { 197, 23, 30, 27, 2, -30 },
  { 284, 23, 30, 24, 1, -30 },
  { 371, 5, 11, 7, 1, -32 },
  { 378, 10, 42, 14, 2, -33 },
  { 431, 10, 42, 14, 1, -33 },
  { 484, 18, 18, 19, 1, -30 },
  { 525, 18, 21, 20, 1, -24 },
  { 573, 7, 13, 10, 1, -5 },
  { 585, 10, 5, 15, 2, -15 },
  { 592, 6, 6, 12, 3, -6 },
  { 597, 13, 33, 14, 0, -30 },
  { 651, 17, 30, 21, 2, -30 },
  { 715, 12, 30, 21, 3, -30 },
  { 760, 19, 30, 21, 1, -30 },
  { 832, 18, 30, 21, 1, -30 },
  { 900, 19, 30, 21, 1, -30 },
  { 972, 17, 30, 21, 2, -30 },
  { 1036, 18, 30, 21, 2, -30 },
  { 1104, 18, 30, 21, 1, -30 },
  { 1172, 17, 30, 21, 2, -30 },
  { 1236, 17, 30, 21, 2, -30 },
  { 1300, 6, 23, 11, 3, -23 },
  { 1318, 8, 31, 11, 1, -23 },
  { 1349, 15, 20, 19, 1, -23 },
  { 1387, 15, 14, 21, 3, -20 },
  { 1414, 15, 20, 19, 3, -23 },
  { 1452, 16, 30, 19, 1, -30 },
  { 1512, 29, 38, 32, 2, -29 },
  { 1650, 25, 30, 25, 0, -30 },
  { 1744, 20, 30, 24, 2, -30 },
  { 1819, 21, 30, 24, 2, -30 },
  { 1898, 20, 30, 24, 2, -30 },
  { 1973, 18, 30, 21, 2, -30 },
  { 2041, 17, 30, 20, 2, -30 },
  { 2105, 21, 30, 25, 2, -30 },
  { 2184, 21, 30, 26, 2, -30 },
  { 2263, 6, 30, 11, 3, -30 },
  { 2286, 17, 30, 21, 1, -30 },
  { 2350, 21, 30, 23, 2, -30 },
  { 2429, 17, 30, 20, 2, -30 },
  { 2493, 27, 30, 32, 2, -30 },
  { 2595, 21, 30, 26, 2, -30 },
  { 2674, 21, 30, 25, 2, -30 },
  { 2753, 20, 30, 24, 2, -30 },
  { 2828, 22, 35, 25, 2, -30 },
  { 2925, 20, 30, 23, 2, -30 },
  { 3000, 19, 30, 23, 2, -30 },
  { 3072, 21, 30, 23, 1, -30 },
  { 3151, 20, 30, 24, 2, -30 },
  { 3226, 24, 30, 24, 0, -30 },
  { 3316, 30, 30, 31, 1, -30 },
  { 3429, 22, 30, 24, 1, -30 },
  { 3512, 22, 30, 23, 0, -30 },
  { 3595, 20, 30, 22, 1, -30 },
  { 3670, 8, 42, 11, 2, -35 },
  { 3712, 17, 33, 16, 0, -30 },
  { 3783, 8, 42, 11, 1, -35 },
  { 3825, 14, 15, 16, 1, -30 },
  { 3852, 16, 5, 17, 0, 0 },
  { 3862, 11, 6, 14, 1, -31 },
  { 3871, 16, 22, 20, 2, -22 },
  { 3915, 17, 32, 21, 2, -32 },
  { 3983, 17, 22, 19, 1, -22 },
  { 4030, 18, 32, 21, 1, -32 },
  { 4102, 17, 22, 20, 2, -22 },
  { 4149, 12, 32, 14, 1, -32 },
  { 4197, 18, 31, 21, 1, -22 },
  { 4267, 17, 32, 21, 2, -32 },
  { 4335, 6, 31, 11, 2, -31 },
  { 4359, 9, 40, 10, -1, -31 },
  { 4404, 18, 32, 20, 2, -32 },
  { 4476, 6, 32, 11, 2, -32 },
  { 4500, 27, 22, 31, 2, -22 },
  { 4575, 17, 22, 21, 2, -22 },
  { 4622, 18, 22, 21, 1, -22 },
  { 4672, 17, 31, 21, 2, -22 },
  { 4738, 18, 31, 21, 1, -22 },
  { 4808, 11, 22, 14, 2, -22 },
  { 4839, 17, 22, 19, 1, -22 },
  { 4886, 12, 28, 13, 0, -28 },
  { 4928, 17, 22, 21, 2, -22 },
  { 4975, 17, 22, 19, 1, -22 },
  { 5022, 25, 22, 27, 1, -22 },
  { 5091, 17, 22, 19, 1, -22 },
  { 5138, 18, 31, 19, 0, -22 },
  { 5208, 15, 22, 19, 2, -22 },
  { 5250, 10, 40, 13, 1, -33 },
  { 5300, 3, 36, 11, 4, -30 },
  { 5314, 10, 40, 13, 1, -33 },
  { 5364, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_Bold42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_BOLD42PT7B_H_
