#ifndef _ROBOTOCONDENSED_BOLD18PT7B_H_
#define _ROBOTOCONDENSED_BOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xC3, 0x7C, 0xBB, 0xBB, 0xB0, 0x16, 0x36, 0x36,
  0xFF, 0xFF, 0x24, 0x2C, 0x2C, 0xFE, 0xFE, 0x68, 0x48, 0x48, 0x10, 0x20,
  0xF3, 0xFE, 0xFC, 0xF8, 0x38, 0x3C, 0x3C, 0x1E, 0x3E, 0x7F, 0xCF, 0x08,
  0x10, 0x70, 0x3C, 0x09, 0xB2, 0x68, 0xF6, 0x1D, 0x00, 0xC0, 0x2E, 0x1F,
  0xCD, 0xB2, 0x6C, 0x9B, 0x03, 0x80, 0x38, 0x3E, 0x1B, 0x0D, 0x86, 0xC3,
  0xC1, 0xE1, 0xF6, 0xDF, 0x67, 0xB1, 0xDF, 0xE7, 0xB8, 0xF8, 0x13, 0x26,
  0x6C, 0xCC, 0xCC, 0xCC, 0xC6, 0x62, 0x31, 0x43, 0x18, 0x63, 0x18, 0x63,
  0x18, 0xC6, 0x33, 0x18, 0xCC, 0x62, 0x00, 0x18, 0x18, 0x59, 0xFF, 0x18,
  0x3C, 0x66, 0x24, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x6D,
  0xB4, 0xFF, 0x5F, 0x80, 0x0C, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x21, 0x86,
  0x10, 0xC3, 0x00, 0x38, 0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0xBB, 0xE3, 0x80, 0x0B, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80,
  0x7D, 0xFF, 0xBE, 0x30, 0x61, 0xC3, 0x0E, 0x38, 0xE3, 0x87, 0xFF, 0xE0,
  0x79, 0xFF, 0x38, 0x30, 0xE7, 0x8F, 0x07, 0x07, 0x8F, 0xBF, 0xF7, 0x80,
  0x0C, 0x38, 0x71, 0xE3, 0xCD, 0x9B, 0x66, 0xFF, 0xFC, 0x30, 0x60, 0xC0,
  0x7E, 0xFF, 0x87, 0x0F, 0xDF, 0xC3, 0x83, 0x07, 0x8F, 0xBB, 0xE3, 0x80,
  0x1C, 0x79, 0xC7, 0x0F, 0xDF, 0xFB, 0xE3, 0xC7, 0x8F, 0xBB, 0xF3, 0xC0,
  0xFF, 0xFC, 0x18, 0x70, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC3, 0x86, 0x00,
  0x3C, 0xFF, 0xBF, 0x3E, 0xEF, 0x9F, 0x77, 0xC7, 0x8F, 0xBF, 0xF3, 0xC0,
  0x38, 0xFB, 0xBE, 0x3C, 0x78, 0xFB, 0xFF, 0x76, 0x1C, 0x73, 0xC7, 0x00,
  0x5F, 0x80, 0x02, 0xFC, 0x5F, 0x80, 0x00, 0xFF, 0x68, 0x04, 0x77, 0xFC,
  0xC3, 0xC7, 0xC7, 0x04, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC3,
  0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x3C, 0xFD, 0x9F, 0x30, 0x61, 0xC7,
  0x0C, 0x18, 0x00, 0x61, 0xC1, 0x80, 0x0F, 0x83, 0x9C, 0x60, 0x66, 0x02,
  0xC7, 0x3C, 0xFB, 0xD9, 0x99, 0x99, 0x99, 0x39, 0x93, 0xDF, 0xEC, 0xDC,
  0xC0, 0x06, 0x00, 0x3F, 0x01, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x81,
  0xB0, 0x36, 0x0E, 0xE1, 0x9C, 0x3F, 0x8F, 0xF1, 0xC7, 0x30, 0xEE, 0x0C,
  0xFC, 0xFF, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE, 0xE7, 0xE3, 0xE3, 0xE7, 0xFF,
  0xFE, 0x3E, 0x3F, 0xB8, 0xDC, 0x7C, 0x3E, 0x03, 0x01, 0x80, 0xC0, 0x71,
  0xF8, 0xCF, 0xE3, 0xE0, 0xFC, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE7, 0xFE, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0,
  0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF,
  0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xDC, 0x7C, 0x06, 0x03,
  0x3F, 0x9F, 0xC3, 0xF1, 0xF8, 0xEF, 0xF3, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xE7, 0x67, 0x7E, 0x3C, 0xE3, 0xF3, 0xBB, 0x9D, 0xCF, 0xC7, 0xC3,
  0xF1, 0xF8, 0xEE, 0x77, 0x39, 0xDC, 0xEE, 0x38, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF9, 0xFD, 0x9F, 0xD9, 0xFD, 0xB7, 0xEF, 0x7E, 0xF7, 0xEE,
  0x7E, 0xE7, 0xE6, 0x70, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9E, 0xCF, 0x77,
  0x9B, 0xCF, 0xE3, 0xF1, 0xF8, 0x7C, 0x38, 0x3E, 0x3F, 0xB8, 0xDC, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F,
  0xB9, 0xDC, 0x7E, 0x3F, 0x3B, 0xFD, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0x3E, 0x3F, 0xB8, 0xDC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1,
  0xF8, 0xCF, 0xE3, 0xF0, 0x1C, 0x04, 0xFC, 0x7F, 0xB9, 0xDC, 0x6E, 0x37,
  0x3B, 0xF9, 0xF8, 0xEE, 0x77, 0x39, 0xDC, 0xEE, 0x30, 0x3C, 0xFE, 0xE7,
  0xC7, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC7, 0xE7, 0xFE, 0x3C, 0xFF, 0xFF,
  0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7,
  0x7F, 0x3C, 0xE1, 0xD8, 0x77, 0x1D, 0xC6, 0x73, 0x8C, 0xE3, 0x30, 0xEC,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x0E, 0x00, 0xE3, 0x1B, 0x39, 0xD9, 0xCE,
  0xCE, 0x67, 0x7B, 0x3B, 0xD8, 0xFE, 0xC7, 0xBE, 0x3D, 0xF1, 0xE7, 0x0F,
  0x38, 0x79, 0xC1, 0x8E, 0x00, 0x71, 0x9C, 0xE3, 0x38, 0xFC, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x3F, 0x0F, 0xC3, 0x39, 0xCE, 0x61, 0xC0, 0xE1, 0x98,
  0xE7, 0x38, 0xCC, 0x37, 0x0F, 0x81, 0xE0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70,
  0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xFC, 0xE0,
  0xC1, 0x83, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x60, 0xE1, 0xC0,
  0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFF, 0x38, 0x70, 0xA3,
  0x66, 0xCC, 0x80, 0xFF, 0xFC, 0x71, 0x8E, 0x79, 0xFB, 0x38, 0x77, 0xFD,
  0xF3, 0xE7, 0xFE, 0xFC, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xFB, 0xE3, 0xC7,
  0x8F, 0x1F, 0x3F, 0xFB, 0x80, 0x79, 0xFB, 0x3E, 0x7C, 0x18, 0x30, 0x67,
  0xFC, 0xF0, 0x06, 0x0C, 0x18, 0x37, 0x7F, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E,
  0x7F, 0xEE, 0xC0, 0x79, 0xFB, 0xBE, 0x3F, 0xFF, 0xF0, 0x72, 0xFE, 0x78,
  0x1C, 0xF3, 0x1C, 0xFB, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x77,
  0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xF3, 0xFE, 0xEC, 0x18, 0x7F, 0xEF, 0x00,
  0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xC0, 0x5F, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x27, 0x60, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x76, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0, 0xCE, 0xCC, 0xDC, 0xF8,
  0xF8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC6, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xDD, 0xDF, 0xFF, 0xB9, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x73, 0xCE,
  0x79, 0xCC, 0xDD, 0xFF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9C, 0x79,
  0xFF, 0xBE, 0x3C, 0x78, 0xF1, 0xF7, 0xFE, 0x70, 0xDD, 0xFF, 0xBE, 0x3C,
  0x78, 0xF1, 0xF7, 0xFF, 0xBB, 0x06, 0x0C, 0x18, 0x00, 0x77, 0xFF, 0x3E,
  0x3C, 0x78, 0xF1, 0xE7, 0xFE, 0xEC, 0x18, 0x30, 0x60, 0xC0, 0xDF, 0xFF,
  0x8C, 0x63, 0x18, 0xC6, 0x00, 0x79, 0xFB, 0x37, 0x0F, 0x87, 0x83, 0x67,
  0xFC, 0xF0, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73, 0x9E, 0x70, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0xFE, 0xEC, 0xE7, 0x66, 0x66, 0x66, 0x7E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0xE6, 0x6D, 0xDD, 0xBB, 0xB7, 0x66, 0xFC,
  0xF7, 0x8E, 0xF1, 0xDE, 0x39, 0x86, 0x30, 0x67, 0x76, 0x3E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x7E, 0x76, 0x67, 0xE7, 0x66, 0x66, 0x76, 0x7E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x18, 0x18, 0x38, 0x70, 0x70, 0xFF, 0xF1, 0xC6, 0x39, 0xC6,
  0x38, 0xFF, 0xF0, 0x19, 0xCC, 0x63, 0x18, 0xDC, 0xE3, 0x8C, 0x63, 0x18,
  0xC7, 0x18, 0xFF, 0xFE, 0x43, 0x18, 0xE7, 0x38, 0xC7, 0x39, 0x9C, 0xE7,
  0x39, 0x8C, 0x40, 0x73, 0xFB, 0xDF, 0xCE,
};

const GFXglyph RobotoCondensed_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 4, 5, 6, 1, -14 },
  { 9, 8, 13, 10, 1, -13 },
  { 22, 7, 17, 9, 1, -15 },
  { 37, 10, 13, 11, 1, -13 },
  { 54, 9, 13, 10, 1, -13 },
  { 69, 1, 5, 3, 1, -14 },
  { 70, 4, 18, 6, 1, -14 },
  { 79, 5, 18, 6, 0, -14 },
  { 91, 8, 8, 8, 0, -13 },
  { 99, 7, 9, 9, 1, -10 },
  { 107, 3, 5, 4, 0, -2 },
  { 109, 4, 2, 7, 1, -6 },
  { 110, 3, 3, 5, 1, -3 },
  { 112, 6, 14, 6, 0, -13 },
  { 123, 7, 13, 9, 1, -13 },
  { 135, 5, 13, 9, 1, -13 },
  { 144, 7, 13, 9, 1, -13 },
  { 156, 7, 13, 9, 1, -13 },
  { 168, 7, 13, 9, 1, -13 },
  { 180, 7, 13, 9, 1, -13 },
  { 192, 7, 13, 9, 1, -13 },
  { 204, 7, 13, 9, 1, -13 },
  { 216, 7, 13, 9, 1, -13 },
  { 228, 7, 13, 9, 1, -13 },
  { 240, 3, 10, 5, 1, -10 },
  { 244, 3, 13, 5, 1, -10 },
  { 249, 6, 9, 8, 1, -10 },
  { 256, 7, 6, 9, 1, -9 },
  { 262, 7, 9, 8, 1, -10 },
  { 270, 7, 13, 8, 0, -13 },
  { 282, 12, 16, 14, 1, -12 },
  { 306, 11, 13, 11, 0, -13 },
  { 324, 8, 13, 10, 1, -13 },
  { 337, 9, 13, 10, 1, -13 },
  { 352, 8, 13, 10, 1, -13 },
  { 365, 7, 13, 9, 1, -13 },
  { 377, 7, 13, 9, 1, -13 },
  { 389, 9, 13, 11, 1, -13 },
  { 404, 9, 13, 11, 1, -13 },
  { 419, 3, 13, 5, 1, -13 },
  { 424, 8, 13, 9, 0, -13 },
  { 437, 9, 13, 10, 1, -13 },
  { 452, 7, 13, 9, 1, -13 },
  { 464, 12, 13, 14, 1, -13 },
  { 484, 9, 13, 11, 1, -13 },
  { 499, 9, 13, 11, 1, -13 },
  { 514, 9, 13, 10, 1, -13 },
  { 529, 9, 15, 11, 1, -13 },
  { 546, 9, 13, 10, 1, -13 },
  { 561, 8, 13, 10, 1, -13 },
  { 574, 9, 13, 10, 0, -13 },
  { 589, 8, 13, 10, 1, -13 },
  { 602, 10, 13, 10, 0, -13 },
  { 619, 13, 13, 13, 0, -13 },
  { 641, 10, 13, 10, 0, -13 },
  { 658, 10, 13, 10, 0, -13 },
  { 675, 8, 13, 10, 1, -13 },
  { 688, 3, 18, 5, 1, -15 },
  { 695, 7, 14, 7, 0, -13 },
  { 708, 4, 18, 5, 0, -15 },
  { 717, 7, 6, 7, 0, -13 },
  { 723, 7, 2, 7, 0, 0 },
  { 725, 5, 3, 6, 0, -14 },
  { 727, 7, 10, 8, 1, -10 },
  { 736, 7, 14, 9, 1, -14 },
  { 749, 7, 10, 8, 1, -10 },
  { 758, 7, 14, 9, 1, -14 },
  { 771, 7, 10, 9, 1, -10 },
  { 780, 6, 14, 6, 0, -14 },
  { 791, 7, 14, 9, 1, -10 },
  { 804, 7, 14, 9, 1, -14 },
  { 817, 3, 14, 5, 1, -14 },
  { 823, 4, 18, 4, 0, -14 },
  { 832, 8, 14, 9, 1, -14 },
  { 846, 3, 14, 5, 1, -14 },
  { 852, 11, 10, 13, 1, -10 },
  { 866, 7, 10, 9, 1, -10 },
  { 875, 7, 10, 9, 1, -10 },
  { 884, 7, 14, 9, 1, -10 },
  { 897, 7, 14, 9, 1, -10 },
  { 910, 5, 10, 6, 1, -10 },
  { 917, 7, 10, 8, 1, -10 },
  { 926, 5, 12, 6, 0, -12 },
  { 934, 7, 10, 9, 1, -10 },
  { 943, 8, 10, 8, 0, -10 },
  { 953, 11, 10, 11, 0, -10 },
  { 967, 8, 10, 8, 0, -10 },
  { 977, 8, 14, 8, 0, -10 },
  { 991, 6, 10, 8, 1, -10 },
  { 999, 5, 17, 5, 0, -14 },
  { 1010, 1, 15, 5, 2, -13 },
  { 1012, 5, 17, 5, 0, -14 },
  { 1023, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_Bold18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_BOLD18PT7B_H_
