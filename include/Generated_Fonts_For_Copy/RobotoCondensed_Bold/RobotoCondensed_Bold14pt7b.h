#ifndef _ROBOTOCONDENSED_BOLD14PT7B_H_
#define _ROBOTOCONDENSED_BOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDD, 0xDD, 0x28, 0xA6, 0xBF, 0x51, 0x4F, 0x94,
  0x53, 0x40, 0x23, 0xBF, 0xBC, 0x38, 0xE3, 0xDF, 0xDC, 0x40, 0xE1, 0x4A,
  0xA5, 0x4F, 0x03, 0xCA, 0x95, 0x4A, 0x1C, 0x38, 0x7C, 0x6C, 0x6C, 0x38,
  0x7A, 0x7E, 0x4E, 0x7E, 0x3F, 0xFF, 0x2D, 0x6D, 0x24, 0x9B, 0x26, 0x40,
  0x84, 0x62, 0x33, 0x33, 0x33, 0x26, 0x48, 0x10, 0x4F, 0xCC, 0x79, 0x20,
  0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x6D, 0x60, 0xFC, 0xF0, 0x11, 0x32,
  0x22, 0x64, 0x4C, 0xC0, 0x77, 0xF7, 0xBD, 0xEF, 0x7B, 0xFB, 0x80, 0x3F,
  0xF3, 0x33, 0x33, 0x33, 0x38, 0xF9, 0x30, 0x60, 0xC3, 0x0C, 0x18, 0x7E,
  0xFC, 0x39, 0xF6, 0xC3, 0x3C, 0xF0, 0xF3, 0x7C, 0xE0, 0x0C, 0x38, 0x71,
  0xE2, 0xCD, 0x9F, 0xFF, 0x0C, 0x18, 0xFF, 0xF1, 0xED, 0x8C, 0x3B, 0xFB,
  0x80, 0x31, 0xCC, 0x3E, 0xFB, 0x3C, 0xF2, 0xF9, 0xC0, 0xFF, 0xF0, 0xC3,
  0x18, 0x61, 0x8C, 0x30, 0xC0, 0x77, 0xF7, 0xBF, 0xFF, 0x7B, 0xFB, 0x80,
  0x77, 0xF7, 0xBD, 0xFD, 0xE3, 0x73, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B,
  0x78, 0x08, 0xDD, 0x87, 0x0C, 0x20, 0xFF, 0xC1, 0xFF, 0x80, 0x87, 0x1E,
  0x37, 0xF2, 0x00, 0x79, 0xFC, 0xC3, 0x18, 0xC3, 0x00, 0x30, 0xC0, 0x1E,
  0x31, 0x90, 0x73, 0x99, 0x6D, 0xA6, 0xD3, 0x69, 0xB5, 0xCF, 0xB0, 0x0C,
  0x03, 0xC0, 0x18, 0x1C, 0x3C, 0x3C, 0x36, 0x26, 0x7E, 0x7E, 0x63, 0xC3,
  0xFB, 0xFC, 0xF3, 0xDF, 0xEC, 0xF3, 0xFF, 0xE0, 0x79, 0xFB, 0x36, 0x3C,
  0x18, 0x30, 0x66, 0xFC, 0xF0, 0xF3, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF,
  0xC0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xFF, 0xF0, 0xFF, 0xF1, 0x8F,
  0xFF, 0x18, 0xC6, 0x00, 0x79, 0xFB, 0x16, 0x0D, 0xFB, 0xF1, 0xE3, 0xFE,
  0xF8, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xFF, 0xFF,
  0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xF3, 0x7D, 0xE0, 0xCD, 0xBB, 0x67,
  0x8F, 0x1E, 0x36, 0x6E, 0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF,
  0xC0, 0xC3, 0xF1, 0xF8, 0xFC, 0xFF, 0x7F, 0xAF, 0xF7, 0xBB, 0xD9, 0xEC,
  0xC0, 0xC7, 0x8F, 0x9F, 0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x8C, 0x79, 0xFB,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFC, 0xF0, 0xFB, 0xFC, 0xF3, 0xFF, 0xEC,
  0x30, 0xC3, 0x00, 0x79, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFC, 0xF8,
  0x38, 0x20, 0xFB, 0xFC, 0xF3, 0xFF, 0xED, 0xB7, 0xCF, 0x30, 0x3C, 0xFD,
  0x9B, 0x07, 0x83, 0x81, 0xB3, 0x7E, 0x78, 0xFF, 0xFC, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0,
  0xC3, 0x67, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0xCC, 0xDB,
  0x36, 0xED, 0xBB, 0x6E, 0x9E, 0xE7, 0xB8, 0xEE, 0x33, 0x8C, 0xE0, 0x66,
  0x66, 0x3C, 0x3C, 0x18, 0x38, 0x3C, 0x7C, 0x66, 0xE6, 0xC6, 0xCD, 0xB1,
  0x63, 0xC7, 0x06, 0x0C, 0x18, 0x30, 0xFF, 0xFC, 0x30, 0x61, 0x86, 0x0C,
  0x30, 0x7E, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x18, 0x20, 0xC3,
  0x0C, 0x18, 0x61, 0x80, 0xFD, 0xB6, 0xDB, 0x6D, 0xBF, 0xC0, 0x31, 0x9C,
  0xB4, 0x80, 0xFF, 0xC0, 0x63, 0x39, 0xF0, 0xDF, 0x6D, 0x37, 0xDF, 0xC6,
  0x31, 0xFF, 0xEF, 0x39, 0xDF, 0xFE, 0x39, 0xF4, 0xF0, 0xC1, 0x37, 0xCE,
  0x0C, 0x30, 0xDF, 0x7D, 0x3C, 0xF3, 0x4D, 0xF7, 0xC0, 0x77, 0xF7, 0x3F,
  0xE3, 0xEF, 0x37, 0x6F, 0x66, 0x66, 0x66, 0x60, 0x35, 0xF6, 0xF3, 0xCD,
  0xB7, 0xCF, 0x0D, 0xF7, 0x80, 0xC6, 0x31, 0xEF, 0xEF, 0x7B, 0xDE, 0xF6,
  0xF3, 0xFF, 0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C, 0x36,
  0xFB, 0xCE, 0x3C, 0xF3, 0x6D, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xB6,
  0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0x39,
  0xF6, 0xD1, 0x45, 0xB7, 0xCE, 0xFF, 0xF7, 0x9C, 0xEF, 0xFE, 0xC6, 0x30,
  0x7D, 0xF4, 0xF3, 0xCD, 0x37, 0xDF, 0x0C, 0x30, 0xC0, 0xFF, 0x6D, 0xB6,
  0x79, 0xF6, 0x1C, 0x3C, 0x37, 0xDE, 0x6F, 0x66, 0x66, 0x67, 0x30, 0xDE,
  0xF7, 0xBD, 0xEF, 0xFF, 0xCD, 0x36, 0x9E, 0x78, 0xE3, 0x0C, 0xC9, 0xAC,
  0x97, 0xCF, 0xE7, 0x73, 0xB9, 0xD8, 0x4C, 0x6D, 0xE7, 0x8C, 0x31, 0xE7,
  0xB3, 0xCD, 0x36, 0x9E, 0x78, 0xE3, 0x0C, 0x31, 0xC6, 0x00, 0xFF, 0xCC,
  0xC6, 0x63, 0xFF, 0x32, 0x66, 0x66, 0xC6, 0x66, 0x62, 0x30, 0xFF, 0xF0,
  0x46, 0x66, 0x66, 0x36, 0x66, 0x66, 0x40, 0xE7, 0xF9, 0x80,
};

const GFXglyph RobotoCondensed_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 4, 0, -11 },
  { 6, 6, 10, 7, 1, -10 },
  { 14, 5, 12, 7, 1, -11 },
  { 22, 7, 10, 9, 1, -10 },
  { 31, 8, 10, 8, 0, -10 },
  { 41, 2, 4, 2, 0, -11 },
  { 42, 3, 14, 5, 1, -11 },
  { 48, 4, 14, 5, 0, -11 },
  { 55, 6, 6, 6, 0, -10 },
  { 60, 6, 8, 7, 0, -9 },
  { 66, 3, 4, 3, 0, -2 },
  { 68, 3, 2, 5, 1, -5 },
  { 69, 2, 2, 4, 1, -2 },
  { 70, 4, 11, 5, 0, -10 },
  { 76, 5, 10, 7, 1, -10 },
  { 83, 4, 10, 7, 1, -10 },
  { 88, 7, 10, 7, 0, -10 },
  { 97, 6, 10, 7, 0, -10 },
  { 105, 7, 10, 7, 0, -10 },
  { 114, 5, 10, 7, 1, -10 },
  { 121, 6, 10, 7, 1, -10 },
  { 129, 6, 10, 7, 0, -10 },
  { 137, 5, 10, 7, 1, -10 },
  { 144, 5, 10, 7, 1, -10 },
  { 151, 2, 8, 4, 1, -8 },
  { 153, 3, 10, 4, 0, -8 },
  { 157, 5, 7, 6, 0, -8 },
  { 162, 5, 5, 7, 1, -7 },
  { 166, 5, 7, 6, 1, -8 },
  { 171, 6, 10, 6, 0, -10 },
  { 179, 9, 13, 11, 1, -10 },
  { 194, 8, 10, 8, 0, -10 },
  { 204, 6, 10, 8, 1, -10 },
  { 212, 7, 10, 8, 1, -10 },
  { 221, 6, 10, 8, 1, -10 },
  { 229, 6, 10, 7, 1, -10 },
  { 237, 5, 10, 7, 1, -10 },
  { 244, 7, 10, 8, 1, -10 },
  { 253, 7, 10, 9, 1, -10 },
  { 262, 2, 10, 4, 1, -10 },
  { 265, 6, 10, 7, 0, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 5, 10, 7, 1, -10 },
  { 289, 9, 10, 11, 1, -10 },
  { 301, 7, 10, 9, 1, -10 },
  { 310, 7, 10, 8, 1, -10 },
  { 319, 6, 10, 8, 1, -10 },
  { 327, 7, 12, 8, 1, -10 },
  { 338, 6, 10, 8, 1, -10 },
  { 346, 7, 10, 8, 0, -10 },
  { 355, 7, 10, 8, 0, -10 },
  { 364, 6, 10, 8, 1, -10 },
  { 372, 8, 10, 8, 0, -10 },
  { 382, 10, 10, 11, 0, -10 },
  { 395, 8, 10, 8, 0, -10 },
  { 405, 7, 10, 8, 0, -10 },
  { 414, 7, 10, 7, 0, -10 },
  { 423, 2, 14, 4, 1, -12 },
  { 427, 6, 11, 5, 0, -10 },
  { 436, 3, 14, 4, 0, -12 },
  { 442, 5, 5, 5, 0, -10 },
  { 446, 5, 2, 6, 0, 0 },
  { 448, 4, 2, 5, 0, -10 },
  { 449, 6, 8, 7, 0, -8 },
  { 455, 5, 11, 7, 1, -11 },
  { 462, 6, 8, 6, 0, -8 },
  { 468, 6, 11, 7, 0, -11 },
  { 477, 5, 8, 7, 1, -8 },
  { 482, 4, 11, 5, 0, -11 },
  { 488, 6, 11, 7, 0, -8 },
  { 497, 5, 11, 7, 1, -11 },
  { 504, 2, 11, 4, 1, -11 },
  { 507, 3, 14, 3, 0, -11 },
  { 513, 6, 11, 7, 1, -11 },
  { 522, 2, 11, 4, 1, -11 },
  { 525, 9, 8, 10, 1, -8 },
  { 534, 5, 8, 7, 1, -8 },
  { 539, 6, 8, 7, 0, -8 },
  { 545, 5, 11, 7, 1, -8 },
  { 552, 6, 11, 7, 0, -8 },
  { 561, 3, 8, 5, 1, -8 },
  { 564, 6, 8, 6, 0, -8 },
  { 570, 4, 9, 4, 0, -9 },
  { 575, 5, 8, 7, 1, -8 },
  { 580, 6, 8, 6, 0, -8 },
  { 586, 9, 8, 9, 0, -8 },
  { 595, 6, 8, 6, 0, -8 },
  { 601, 6, 11, 6, 0, -8 },
  { 610, 5, 8, 6, 1, -8 },
  { 615, 4, 13, 4, 0, -11 },
  { 622, 1, 12, 4, 1, -10 },
  { 624, 4, 13, 4, 0, -11 },
  { 631, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Bold14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_BOLD14PT7B_H_
