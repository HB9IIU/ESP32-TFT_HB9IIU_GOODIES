#ifndef _ROBOTOCONDENSED_BOLD21PT7B_H_
#define _ROBOTOCONDENSED_BOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x6C, 0x07, 0xD8, 0xDE, 0xF7, 0xB9, 0xCC, 0x1B,
  0x0D, 0x86, 0xC3, 0x6F, 0xFF, 0xFC, 0xD8, 0x6C, 0x36, 0x7F, 0xFF, 0xE4,
  0xC6, 0x43, 0x61, 0xB0, 0x08, 0x04, 0x0F, 0x8F, 0xE7, 0x77, 0x1F, 0x8E,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xEE, 0x3F, 0x1F, 0xDC, 0xFE, 0x3E, 0x04,
  0x02, 0x00, 0x70, 0x1F, 0x03, 0x32, 0x66, 0xCC, 0xD1, 0xF6, 0x1D, 0x80,
  0x30, 0x0D, 0xC1, 0xFC, 0x6C, 0x8D, 0x93, 0x32, 0x07, 0xC0, 0x70, 0x3C,
  0x0F, 0xC1, 0xDC, 0x33, 0x86, 0x70, 0xFC, 0x0F, 0x01, 0xC6, 0x7D, 0xDD,
  0xFB, 0xBF, 0x73, 0xCF, 0x78, 0xFF, 0x8F, 0x70, 0xFF, 0xF0, 0x08, 0xCE,
  0x67, 0x31, 0x8C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x63, 0x8C, 0x71, 0x84,
  0x86, 0x38, 0xC7, 0x18, 0xC6, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x33, 0x99,
  0xCC, 0x40, 0x0C, 0x06, 0x03, 0x3F, 0xF3, 0xF0, 0xE0, 0xD8, 0x66, 0x22,
  0x00, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x77, 0x77, 0x64, 0xFF, 0xC0, 0x6F, 0x60, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x1C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0x3C, 0x3F, 0x1D,
  0xDC, 0x6E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xE7, 0x73,
  0xF0, 0xF0, 0x0B, 0xFF, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x3E, 0x3F, 0xBD, 0xDC, 0xEE, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x07, 0xFF, 0xFE, 0x3C, 0x3F, 0xBD, 0xDC, 0xE0, 0x70, 0x38,
  0x78, 0x3E, 0x07, 0x01, 0xC0, 0xFC, 0x6E, 0x73, 0xF8, 0xF0, 0x0F, 0x07,
  0x87, 0xC3, 0xE3, 0xF1, 0xB9, 0xDC, 0xCE, 0xE7, 0x73, 0xBF, 0xFF, 0xF0,
  0x70, 0x38, 0x1C, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x07, 0xF3, 0xFD, 0xCE,
  0x03, 0x81, 0xC0, 0xFC, 0x7F, 0x73, 0xF8, 0xF0, 0x0E, 0x1F, 0x0F, 0x0E,
  0x06, 0x07, 0x73, 0xFD, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0x73, 0xF8,
  0x78, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x3E, 0x3F, 0xBD, 0xDC, 0xEE, 0x73,
  0xB9, 0xF8, 0xFE, 0xE7, 0x71, 0xF8, 0xFC, 0x7F, 0x73, 0xF8, 0xF8, 0x3C,
  0x3F, 0x3D, 0xDC, 0xEE, 0x37, 0x1F, 0x8F, 0xEF, 0x7F, 0x1D, 0x81, 0xC0,
  0xE3, 0xE1, 0xE0, 0xE0, 0x6F, 0x60, 0x00, 0x00, 0x6F, 0x60, 0xFD, 0x80,
  0x00, 0x6D, 0xFD, 0x80, 0x02, 0x1C, 0xFF, 0xEF, 0x1E, 0x3F, 0x1F, 0x0E,
  0x04, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F,
  0x0F, 0x3E, 0xF8, 0xE0, 0x80, 0x7C, 0xFE, 0xEE, 0xC7, 0x07, 0x0E, 0x1E,
  0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0xC0, 0x7F, 0xC3,
  0x83, 0x8C, 0x06, 0x63, 0xCD, 0x9F, 0x3C, 0xEC, 0xF3, 0x33, 0xCC, 0xCF,
  0x33, 0x3C, 0xCC, 0xF3, 0x33, 0xCC, 0xCF, 0x3F, 0xEC, 0x77, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x81, 0xD8, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x8E, 0x3F, 0xE7,
  0xFE, 0x70, 0xF7, 0x07, 0xF0, 0x70, 0xFF, 0x3F, 0xEF, 0xFB, 0x8F, 0xE1,
  0xF8, 0xEF, 0xF3, 0xFE, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE7, 0xBF, 0xEF,
  0xF0, 0x1F, 0x1F, 0xE7, 0xFF, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x1F, 0x87, 0x7F, 0xDF, 0xE1, 0xF0, 0xFE, 0x3F, 0xCF, 0xFB,
  0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xEF,
  0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD, 0xFE,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F,
  0x1F, 0xE7, 0xBF, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E,
  0x1F, 0xC7, 0x7B, 0xCF, 0xF1, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xF8, 0xEE, 0x77, 0xFB,
  0xF8, 0x78, 0xE1, 0xDC, 0x7B, 0x8E, 0x73, 0x8E, 0xF1, 0xDC, 0x3F, 0x07,
  0xF0, 0xFE, 0x1E, 0xE3, 0x9C, 0x71, 0xCE, 0x39, 0xC7, 0xB8, 0x70, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xFF, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xF3, 0xFF, 0xCD, 0xFB, 0x37, 0xED, 0xDF, 0xBF, 0x7E, 0xF9, 0xF9,
  0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x31, 0xC0, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC,
  0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x38, 0x1F, 0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xE7, 0xBC, 0x7F, 0x07,
  0xC0, 0xFF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xFF,
  0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0x07, 0xF1, 0xFF,
  0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xE7, 0xFC, 0x7F, 0x07, 0xE0, 0x0E, 0x01, 0xC0, 0x10, 0xFF, 0x3F, 0xEF,
  0xFB, 0x87, 0xE1, 0xF8, 0x7F, 0xFB, 0xFE, 0xFF, 0x39, 0xCE, 0x73, 0x8E,
  0xE3, 0xB8, 0xFE, 0x1C, 0x3E, 0x1F, 0xCF, 0x7B, 0x8E, 0xE3, 0xBC, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0xEE, 0x1B, 0x8E, 0xF7, 0x9F, 0xE3, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xDF, 0xE3,
  0xF0, 0xF0, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x38, 0xE3, 0x9C, 0x39, 0xC3,
  0x9C, 0x19, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x71, 0x8E, 0xE7, 0x1D, 0xCF, 0x3B, 0x9E, 0x77, 0x3C, 0xEE, 0x79, 0x8D,
  0xF7, 0x1F, 0xFE, 0x3E, 0xFC, 0x7C, 0xF8, 0xF9, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0x8F, 0x07, 0x0E, 0x00, 0x70, 0xEE, 0x3C, 0xE7, 0x1C, 0xE1, 0xF8,
  0x3F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xF0, 0x7E, 0x1C, 0xE3, 0x9C, 0xE3,
  0xDC, 0x38, 0xF0, 0xEE, 0x3D, 0xC7, 0x1C, 0xE3, 0xB8, 0x77, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E,
  0x0E, 0x07, 0xFF, 0xFE, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xFF, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0xFF, 0x30, 0x71, 0xE3, 0xCE, 0xD9, 0xB3, 0x80, 0xFF,
  0xFF, 0xE3, 0x8C, 0x3C, 0x7E, 0xE7, 0xE7, 0x3F, 0xFF, 0xE7, 0xE7, 0xEF,
  0xFF, 0x7F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xEE, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBB, 0xFD, 0xDC, 0x3C, 0x7E, 0xE7, 0xE7,
  0xE0, 0xE0, 0xE0, 0xE7, 0xE7, 0x7E, 0x3C, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x7F, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7, 0xFF, 0x7B, 0x3E,
  0x7F, 0xF7, 0xE3, 0xFF, 0xFF, 0xE0, 0xE0, 0xF3, 0x7F, 0x3E, 0x1E, 0x7C,
  0xE1, 0xC3, 0x9F, 0xBF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x3B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xBF, 0xCE,
  0xE0, 0x66, 0x73, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF,
  0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0xBF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3B, 0xBD, 0xDC,
  0xFC, 0x7E, 0x3F, 0x1F, 0xCE, 0xE7, 0x3B, 0x9D, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEE, 0x77, 0xFF, 0xFD, 0xEF, 0xCE, 0x3E, 0x71, 0xF3,
  0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x38, 0xF9, 0xC6, 0xEE, 0xFF, 0xF7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x3F, 0xBD, 0xDC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0x3F, 0x8F, 0x00, 0xFE, 0x7F, 0xBD,
  0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0x7F, 0xBB, 0x9C, 0x0E, 0x07,
  0x03, 0x80, 0x7B, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7, 0xFF,
  0x7F, 0x07, 0x07, 0x07, 0x07, 0xEF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x00, 0x3C, 0xFE, 0xE7, 0xE0, 0xF8, 0x7E, 0x1F, 0xC7, 0xE7, 0xFE,
  0x3C, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x3C, 0x70,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7, 0xFF, 0x7B, 0xE3,
  0xB9, 0xDC, 0xCE, 0xE3, 0x71, 0xB8, 0xF8, 0x7C, 0x1E, 0x0E, 0x07, 0x00,
  0xE7, 0x3B, 0x39, 0xDD, 0xCC, 0xEE, 0x67, 0x7F, 0x1E, 0xF8, 0xF7, 0xC7,
  0xBC, 0x3C, 0xE1, 0xC7, 0x06, 0x38, 0x73, 0xBB, 0x8F, 0xC7, 0xC1, 0xE0,
  0xE0, 0x78, 0x7C, 0x3F, 0x3B, 0x9C, 0xE0, 0xE3, 0xB9, 0xDC, 0xCE, 0xE3,
  0x71, 0xF8, 0xF8, 0x7C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0x83, 0xC1, 0xC0,
  0xFF, 0xFF, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x11,
  0xDC, 0xE7, 0x39, 0xCE, 0x67, 0x38, 0xC7, 0x39, 0xCE, 0x73, 0x8E, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x86, 0x38, 0xC6, 0x31, 0x8C, 0x71, 0xCE,
  0xE6, 0x31, 0x8C, 0x67, 0x31, 0x00, 0x30, 0xDE, 0x7F, 0xDB, 0x3E, 0xC7,
  0x00,
};

const GFXglyph RobotoCondensed_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 5, 6, 7, 1, -16 },
  { 11, 9, 15, 11, 1, -15 },
  { 28, 9, 19, 11, 1, -17 },
  { 50, 11, 15, 13, 1, -15 },
  { 71, 11, 15, 12, 1, -15 },
  { 92, 2, 6, 3, 1, -16 },
  { 94, 5, 22, 7, 1, -17 },
  { 108, 5, 22, 7, 1, -17 },
  { 122, 9, 9, 10, 0, -15 },
  { 133, 8, 11, 10, 1, -13 },
  { 144, 4, 6, 5, 0, -3 },
  { 147, 5, 2, 8, 1, -7 },
  { 149, 4, 3, 6, 1, -3 },
  { 151, 7, 16, 7, 0, -15 },
  { 165, 9, 15, 11, 1, -15 },
  { 182, 5, 15, 11, 2, -15 },
  { 192, 9, 15, 11, 1, -15 },
  { 209, 9, 15, 11, 1, -15 },
  { 226, 9, 15, 11, 1, -15 },
  { 243, 9, 15, 11, 1, -15 },
  { 260, 9, 15, 11, 1, -15 },
  { 277, 9, 15, 11, 1, -15 },
  { 294, 9, 15, 11, 1, -15 },
  { 311, 9, 15, 11, 1, -15 },
  { 328, 4, 11, 6, 1, -11 },
  { 334, 3, 14, 5, 1, -11 },
  { 340, 7, 10, 9, 1, -11 },
  { 349, 8, 6, 11, 1, -10 },
  { 355, 8, 10, 10, 1, -11 },
  { 365, 8, 15, 9, 1, -15 },
  { 380, 14, 20, 16, 1, -15 },
  { 415, 12, 15, 13, 0, -15 },
  { 438, 10, 15, 12, 1, -15 },
  { 457, 10, 15, 12, 1, -15 },
  { 476, 10, 15, 12, 1, -15 },
  { 495, 9, 15, 10, 1, -15 },
  { 512, 8, 15, 10, 1, -15 },
  { 527, 10, 15, 12, 1, -15 },
  { 546, 11, 15, 13, 1, -15 },
  { 567, 3, 15, 6, 1, -15 },
  { 573, 9, 15, 10, 0, -15 },
  { 590, 11, 15, 12, 1, -15 },
  { 611, 9, 15, 10, 1, -15 },
  { 628, 14, 15, 16, 1, -15 },
  { 655, 11, 15, 13, 1, -15 },
  { 676, 11, 15, 13, 1, -15 },
  { 697, 10, 15, 12, 1, -15 },
  { 716, 11, 18, 13, 1, -15 },
  { 741, 10, 15, 12, 1, -15 },
  { 760, 10, 15, 11, 1, -15 },
  { 779, 10, 15, 11, 1, -15 },
  { 798, 10, 15, 12, 1, -15 },
  { 817, 12, 15, 12, 0, -15 },
  { 840, 15, 15, 16, 0, -15 },
  { 869, 11, 15, 12, 0, -15 },
  { 890, 11, 15, 11, 0, -15 },
  { 911, 9, 15, 11, 1, -15 },
  { 928, 4, 20, 6, 1, -17 },
  { 938, 8, 16, 8, 0, -15 },
  { 954, 4, 20, 6, 0, -17 },
  { 964, 7, 7, 8, 1, -15 },
  { 971, 8, 2, 8, 0, 0 },
  { 973, 5, 3, 7, 1, -16 },
  { 975, 8, 11, 10, 1, -11 },
  { 986, 9, 16, 10, 1, -16 },
  { 1004, 8, 11, 10, 1, -11 },
  { 1015, 8, 16, 10, 1, -16 },
  { 1031, 8, 11, 10, 1, -11 },
  { 1042, 7, 16, 7, 0, -16 },
  { 1056, 9, 15, 11, 1, -11 },
  { 1073, 8, 16, 10, 1, -16 },
  { 1089, 3, 15, 5, 1, -15 },
  { 1095, 5, 19, 5, -1, -15 },
  { 1107, 9, 16, 10, 1, -16 },
  { 1125, 3, 16, 5, 1, -16 },
  { 1131, 13, 11, 16, 1, -11 },
  { 1149, 8, 11, 10, 1, -11 },
  { 1160, 9, 11, 10, 1, -11 },
  { 1173, 9, 15, 10, 1, -11 },
  { 1190, 8, 15, 10, 1, -11 },
  { 1205, 6, 11, 7, 1, -11 },
  { 1214, 8, 11, 10, 1, -11 },
  { 1225, 6, 14, 6, 0, -14 },
  { 1236, 8, 11, 10, 1, -11 },
  { 1247, 9, 11, 9, 0, -11 },
  { 1260, 13, 11, 13, 0, -11 },
  { 1278, 9, 11, 10, 0, -11 },
  { 1291, 9, 15, 9, 0, -11 },
  { 1308, 8, 11, 10, 1, -11 },
  { 1319, 5, 20, 6, 1, -16 },
  { 1332, 2, 18, 5, 2, -15 },
  { 1337, 5, 20, 6, 1, -16 },
  { 1350, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_Bold21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_BOLD21PT7B_H_
