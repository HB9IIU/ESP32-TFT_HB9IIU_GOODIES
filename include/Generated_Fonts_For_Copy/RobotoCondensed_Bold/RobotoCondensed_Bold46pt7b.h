#ifndef _ROBOTOCONDENSED_BOLD46PT7B_H_
#define _ROBOTOCONDENSED_BOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF, 0x80, 0x00, 0x00, 0x01,
  0xE7, 0xEF, 0xDF, 0xFF, 0x7E, 0x78, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x83,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xC3, 0x80, 0x1E, 0x3C, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1C, 0x78, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFE, 0x7F, 0x3F, 0x87, 0xF7, 0xF0, 0xFE, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF8, 0x3F, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0x9F, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x8F, 0x07, 0x07, 0x87,
  0x83, 0xC3, 0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF1, 0xE0, 0x78,
  0x78, 0xF0, 0x3E, 0x3C, 0xF0, 0x0F, 0xFE, 0x70, 0x07, 0xFE, 0x78, 0x01,
  0xFE, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3F, 0xC0, 0x07, 0xBF,
  0xF0, 0x07, 0x9F, 0xFC, 0x03, 0xDF, 0x1E, 0x03, 0xCF, 0x0F, 0x01, 0xE7,
  0x87, 0x81, 0xE3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x70,
  0x7C, 0x78, 0x18, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x9F, 0x80, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7C, 0x1F, 0xF8, 0x7C, 0x3F, 0xFC, 0x7C,
  0x7F, 0xFC, 0xFC, 0xFE, 0xFE, 0xFC, 0xFC, 0x7F, 0xFC, 0xFC, 0x7F, 0xF8,
  0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFC, 0xFE, 0x07, 0xF0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x40, 0x38, 0x0F, 0x03, 0xF0, 0x7C, 0x1F, 0x03, 0xC0,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xE0, 0x1C, 0x00, 0x80, 0x40, 0x0E, 0x01, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0x00, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F,
  0x00, 0xF0, 0xF1, 0xEF, 0xEE, 0x7E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xBE, 0x01,
  0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x0C, 0x07, 0x00, 0x40, 0x40,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F, 0xDF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFE, 0x7F, 0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD, 0xFE, 0x7F, 0xBF, 0x83,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0x9F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x7C,
  0xFC, 0x03, 0xE7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E, 0x1F, 0xC0, 0x81,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0xCF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x7E, 0xFF, 0x07, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x9F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07,
  0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xF9, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x3F, 0x9F, 0xC3, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xF0, 0xFC, 0x7F, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7, 0xE0, 0xFD, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xBF,
  0xCF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0xFF, 0x7F, 0x1F, 0x87, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x39, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1E, 0x1F, 0x8F, 0xEF, 0xF3,
  0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xCF, 0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x0F, 0xC0, 0xF1, 0xE0, 0x3F,
  0xE0, 0xF7, 0xC0, 0xFF, 0xE1, 0xEF, 0x03, 0xFF, 0xC3, 0xDE, 0x0F, 0xCF,
  0x87, 0xBC, 0x1F, 0x1F, 0x0F, 0xF8, 0x7C, 0x3E, 0x1F, 0xE0, 0xF8, 0x7C,
  0x1F, 0xC1, 0xE0, 0xF0, 0x3F, 0x87, 0xC1, 0xE0, 0x7F, 0x0F, 0x83, 0xC1,
  0xFE, 0x1F, 0x07, 0x83, 0xFC, 0x3E, 0x0F, 0x07, 0xF8, 0x7C, 0x1E, 0x0F,
  0xF0, 0xF8, 0x3C, 0x1F, 0xE1, 0xF0, 0xF8, 0x3B, 0xC3, 0xE1, 0xF0, 0xF7,
  0x87, 0xE7, 0xE3, 0xEF, 0x87, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xFE, 0x1E,
  0x0F, 0xE7, 0xF8, 0x3C, 0x0F, 0x87, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E,
  0x1F, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x07, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9,
  0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFD, 0xF8, 0x3F, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E,
  0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x7E, 0x00,
  0xFE, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7E, 0x3F, 0xF3, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x03, 0xF9, 0xF8,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xFE, 0x03, 0xF9, 0xFF, 0xBF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0x3F, 0xDF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xFB, 0xF0, 0x1F, 0xE7,
  0xE0, 0x7F, 0x8F, 0xC0, 0xFF, 0x1F, 0x83, 0xFC, 0x3F, 0x07, 0xF0, 0x7E,
  0x1F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE7,
  0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x8F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0xFC,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF, 0xC1, 0xF7, 0xFF,
  0xBE, 0x1F, 0xBF, 0xFD, 0xF8, 0xFD, 0xFF, 0xEF, 0xC7, 0xCF, 0xFF, 0x3E,
  0x3E, 0x7F, 0xF9, 0xFB, 0xF3, 0xFF, 0xCF, 0xDF, 0x1F, 0xFE, 0x7E, 0xF8,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0x7F, 0xE1, 0xFF,
  0xE1, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0x83, 0xFF, 0xC1,
  0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xF0,
  0x3F, 0xFC, 0x0F, 0x81, 0xF8, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7E, 0x3F,
  0xFE, 0xFE, 0x7F, 0xFC, 0xFC, 0xFF, 0xF9, 0xFD, 0xFF, 0xF1, 0xFB, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x0F, 0xFB, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x83,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x0F, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07,
  0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xC7, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFE, 0xFF, 0x9F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01,
  0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xE0, 0x3F, 0x7F, 0x03, 0xF0, 0x1F, 0xBF, 0x81, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0x83, 0xF9,
  0xFC, 0x3F, 0xC1, 0xF8, 0xFE, 0x1F, 0xE0, 0xFC, 0x3F, 0x0F, 0xF8, 0x7E,
  0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xC3, 0xFE, 0x3F, 0x87, 0xE3, 0xFF, 0x1F,
  0x83, 0xF1, 0xFF, 0x8F, 0xC1, 0xFC, 0xFF, 0xE7, 0xE0, 0x7E, 0x7F, 0xF3,
  0xF0, 0x3F, 0x3E, 0xF9, 0xF8, 0x1F, 0xBF, 0x7C, 0xFC, 0x0F, 0xDF, 0x3E,
  0xFC, 0x07, 0xEF, 0x9F, 0x7E, 0x03, 0xF7, 0xCF, 0xFF, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x80,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xEF,
  0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x8F, 0xEF, 0xE1, 0xFB, 0xF0, 0x7E,
  0x00, 0x1F, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xE3,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x3E, 0x3F,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x3E, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xBF, 0xE3, 0xF1, 0xF0, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF,
  0xCF, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xF3, 0xF0, 0xFF,
  0x7E, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0x9F, 0xEF, 0xE0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xF0, 0x7E, 0xFF, 0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE1, 0xFE, 0x7C, 0x1F, 0x8F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xE0,
  0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x21, 0xFE, 0x1E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC,
  0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3E, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x40, 0x3F, 0x8E, 0x0F, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF1, 0xF0, 0xFD, 0xFF, 0x3F, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x18, 0xFF, 0xFF, 0xFF, 0xEF,
  0xCF, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFC, 0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xCF,
  0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x8F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0x7E, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF3, 0xFC, 0x7F, 0x8F, 0xDF, 0xFB,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFF, 0xCF,
  0xEF, 0xE1, 0xFE, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE,
  0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83,
  0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x7E, 0x3F, 0x3F,
  0xCF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFE, 0x7F, 0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFD, 0xFC, 0x7F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFC,
  0x7C, 0x1F, 0xBF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xF3, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xE1, 0xFE, 0x7C, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x3F, 0xDF, 0xC1, 0xFB, 0xF0,
  0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xE0,
  0xFD, 0xFE, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFD,
  0xF8, 0x1F, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x7F, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xC7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF3, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F,
  0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xE0, 0x7C, 0xFC,
  0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x1F, 0x07, 0xFF, 0x83,
  0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xBE, 0x1F, 0xC3, 0xF7, 0xE3, 0xF8, 0xFC,
  0xFC, 0x7F, 0x1F, 0x9F, 0x8F, 0xE3, 0xF3, 0xF3, 0xFE, 0x7E, 0x3E, 0x7F,
  0xCF, 0xC7, 0xCF, 0xF9, 0xF0, 0xFD, 0xEF, 0x3E, 0x1F, 0xBD, 0xFF, 0xC3,
  0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC, 0x7F, 0x1F,
  0x8F, 0xC3, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E,
  0xFC, 0x1F, 0xDF, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xF0,
  0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x3F,
  0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0xC1,
  0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x7F, 0x8F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x60, 0x0F, 0x01, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x81, 0xC0, 0x30,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xE1, 0xF7,
  0xFF, 0xDF, 0xBF, 0x7F, 0xFF, 0xE1, 0xFF, 0xDF, 0x07, 0xFE, 0xF8, 0x1F,
  0xE0, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 33, 12, 3, -33 },
  { 30, 12, 12, 15, 1, -35 },
  { 48, 21, 33, 24, 2, -33 },
  { 135, 19, 42, 23, 2, -38 },
  { 235, 25, 33, 29, 2, -33 },
  { 339, 24, 33, 27, 2, -33 },
  { 438, 5, 12, 7, 1, -35 },
  { 446, 11, 46, 15, 3, -36 },
  { 510, 11, 46, 15, 1, -36 },
  { 574, 20, 20, 21, 1, -33 },
  { 624, 19, 24, 22, 1, -27 },
  { 681, 8, 14, 11, 1, -6 },
  { 695, 11, 5, 17, 3, -16 },
  { 702, 7, 7, 13, 3, -7 },
  { 709, 14, 36, 15, 0, -33 },
  { 772, 19, 33, 23, 2, -33 },
  { 851, 12, 33, 23, 4, -33 },
  { 901, 19, 33, 23, 2, -33 },
  { 980, 19, 33, 23, 2, -33 },
  { 1059, 21, 33, 23, 1, -33 },
  { 1146, 19, 33, 23, 2, -33 },
  { 1225, 20, 33, 23, 2, -33 },
  { 1308, 19, 33, 23, 2, -33 },
  { 1387, 19, 33, 23, 2, -33 },
  { 1466, 19, 33, 23, 2, -33 },
  { 1545, 7, 25, 13, 3, -25 },
  { 1567, 9, 33, 12, 1, -25 },
  { 1605, 17, 22, 21, 1, -25 },
  { 1652, 17, 15, 23, 3, -22 },
  { 1684, 16, 22, 21, 3, -25 },
  { 1728, 18, 33, 21, 1, -33 },
  { 1803, 31, 42, 35, 2, -32 },
  { 1966, 26, 33, 27, 1, -33 },
  { 2074, 21, 33, 26, 3, -33 },
  { 2161, 23, 33, 26, 2, -33 },
  { 2256, 21, 33, 26, 3, -33 },
  { 2343, 18, 33, 23, 3, -33 },
  { 2418, 18, 33, 22, 3, -33 },
  { 2493, 23, 33, 27, 2, -33 },
  { 2588, 23, 33, 28, 3, -33 },
  { 2683, 6, 33, 12, 3, -33 },
  { 2708, 19, 33, 23, 1, -33 },
  { 2787, 23, 33, 25, 3, -33 },
  { 2882, 18, 33, 22, 3, -33 },
  { 2957, 29, 33, 35, 3, -33 },
  { 3077, 23, 33, 28, 3, -33 },
  { 3172, 24, 33, 28, 2, -33 },
  { 3271, 21, 33, 26, 3, -33 },
  { 3358, 24, 39, 28, 2, -33 },
  { 3475, 22, 33, 25, 3, -33 },
  { 3566, 21, 33, 25, 2, -33 },
  { 3653, 23, 33, 25, 1, -33 },
  { 3748, 22, 33, 26, 2, -33 },
  { 3839, 26, 33, 27, 0, -33 },
  { 3947, 33, 33, 34, 1, -33 },
  { 4084, 24, 33, 26, 1, -33 },
  { 4183, 25, 33, 25, 0, -33 },
  { 4287, 21, 33, 24, 2, -33 },
  { 4374, 8, 46, 12, 3, -38 },
  { 4420, 18, 36, 18, 0, -33 },
  { 4501, 8, 46, 12, 1, -38 },
  { 4547, 16, 16, 18, 1, -33 },
  { 4579, 18, 5, 18, 0, 0 },
  { 4591, 12, 7, 15, 1, -35 },
  { 4602, 18, 24, 22, 2, -24 },
  { 4656, 19, 35, 23, 2, -35 },
  { 4740, 18, 24, 21, 2, -24 },
  { 4794, 19, 35, 23, 1, -35 },
  { 4878, 19, 24, 22, 2, -24 },
  { 4935, 14, 35, 15, 1, -35 },
  { 4997, 19, 33, 23, 2, -24 },
  { 5076, 18, 35, 23, 2, -35 },
  { 5155, 7, 34, 12, 2, -34 },
  { 5185, 10, 43, 11, -1, -34 },
  { 5239, 20, 35, 22, 2, -35 },
  { 5327, 6, 35, 12, 3, -35 },
  { 5354, 30, 24, 34, 2, -24 },
  { 5444, 18, 24, 23, 2, -24 },
  { 5498, 19, 24, 23, 2, -24 },
  { 5555, 19, 33, 23, 2, -24 },
  { 5634, 19, 33, 23, 1, -24 },
  { 5713, 12, 24, 15, 2, -24 },
  { 5749, 18, 24, 21, 1, -24 },
  { 5803, 12, 30, 14, 1, -30 },
  { 5848, 18, 24, 23, 2, -24 },
  { 5902, 19, 24, 21, 1, -24 },
  { 5959, 27, 24, 29, 1, -24 },
  { 6040, 19, 24, 21, 1, -24 },
  { 6097, 20, 33, 20, 0, -24 },
  { 6180, 17, 24, 21, 2, -24 },
  { 6231, 11, 44, 14, 1, -36 },
  { 6292, 4, 39, 12, 4, -33 },
  { 6312, 11, 44, 14, 1, -36 },
  { 6373, 21, 10, 26, 2, -18 },
};

const GFXfont RobotoCondensed_Bold46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_BOLD46PT7B_H_
