#ifndef _ROBOTOCONDENSED_BOLD72PT7B_H_
#define _ROBOTOCONDENSED_BOLD72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFF,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xF8, 0xFE, 0x07,
  0x00, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x0C, 0x00, 0x7F, 0x0F, 0xE0, 0x1E, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0xFE,
  0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE3, 0xF0, 0x00,
  0x7F, 0xFF, 0xE7, 0xE0, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x00, 0x3F, 0xFF,
  0xCF, 0xC0, 0x00, 0x1F, 0xFF, 0x8F, 0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xF9, 0xFF, 0xF8, 0x00, 0x03,
  0xF1, 0xFF, 0xFC, 0x00, 0x07, 0xF3, 0xFF, 0xFC, 0x00, 0x07, 0xE3, 0xFF,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x7F, 0x00,
  0x1F, 0x87, 0xE0, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x7F, 0x00, 0x3F, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x78, 0x07, 0xF8,
  0xFE, 0x00, 0x10, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xFD, 0xFF, 0xC7, 0xF8, 0x7F,
  0xEF, 0xFE, 0x3F, 0xC7, 0xFE, 0x3F, 0xF9, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF,
  0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xC0,
  0x7F, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x01, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x30, 0x07, 0xE0, 0x08, 0x78, 0x0F, 0xC0, 0x79, 0xFE, 0x1F, 0x87, 0xF3,
  0xFF, 0x3F, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xE0, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE3, 0xFC, 0x07, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xF1,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE,
  0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xBF, 0xF0, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0x3F, 0xF0, 0x00,
  0xFF, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xF0, 0x03,
  0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x81, 0xFF,
  0xE0, 0x7C, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xE7, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xE3, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9,
  0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F,
  0xF7, 0xFF, 0x01, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xEF, 0xFC,
  0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xF8, 0x07, 0xFF,
  0x7F, 0xE0, 0x07, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x83, 0xFC,
  0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE3, 0xFC,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xC0, 0x70, 0x07, 0xE0, 0xFF,
  0x87, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0,
  0x7F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07,
  0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xC7, 0xF0, 0x07,
  0xFF, 0xFE, 0x07, 0xE3, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xF1, 0xF8, 0x03,
  0xFE, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xBF, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFB, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFD,
  0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F,
  0x9F, 0xC0, 0xFF, 0x8F, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xDF, 0xFF,
  0xE0, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE3, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x1F,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x07,
  0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE,
  0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xFB,
  0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xFC, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xCF,
  0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xFD,
  0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFD, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xFF,
  0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xF7, 0xFC, 0x07, 0xF9, 0xFF, 0xFF,
  0xDF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFC,
  0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xF3, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xC7,
  0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFB, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFD, 0xFF,
  0x83, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xBF,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xF9, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0x80, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC, 0xFF, 0x1F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x3F, 0xC7, 0xFC, 0x03, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0x00,
  0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0xFF, 0xBF, 0xF0,
  0x07, 0xFD, 0xFF, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0x87, 0xFB, 0xFE,
  0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x7F, 0xBF,
  0xE0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xF7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F,
  0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF,
  0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0,
  0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xFC, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0xFF,
  0xCF, 0xFE, 0x07, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0x0F, 0xF9, 0xFF,
  0xF0, 0x7F, 0xC7, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0xFF,
  0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xE7, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x83, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x0F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFD,
  0xFF, 0x03, 0xFF, 0xE7, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xF3, 0xFF, 0x81,
  0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x3F, 0xF0,
  0x00, 0xE1, 0xFF, 0xE0, 0x0F, 0x87, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F,
  0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xE0, 0x7F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x10, 0x00, 0x7F,
  0xE0, 0x38, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x1F, 0x00, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xFC, 0x3F, 0xF7, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x04, 0x0F, 0xC7, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE3, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xC7,
  0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF,
  0x9F, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFE,
  0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xDF,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xF9, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xEF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0xE1, 0xFF, 0xBF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x01, 0xFF,
  0xBF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7,
  0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x3F, 0xE7, 0xFF, 0xC1,
  0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x03,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x3F, 0xFE, 0x7F, 0xC3, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x01,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xBF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0x83, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFC, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0x81, 0xFF, 0x87, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x3F,
  0xEF, 0xF8, 0x07, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xBF,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF7, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xFE, 0x1F,
  0xF0, 0xFF, 0x83, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0xF8, 0x7F, 0xC1,
  0xFF, 0x1F, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0xE1, 0xFF, 0x07, 0xFC,
  0x7F, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0xCF, 0xF8, 0x0F, 0xF3, 0xFF,
  0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0x7F, 0x3F, 0xE0, 0x3F, 0xEF, 0xEF, 0xF7,
  0xF8, 0x07, 0xFD, 0xFC, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xDF, 0xE0,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xFC,
  0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x01, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xC3, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xF0, 0x0F, 0xF3, 0xFF, 0xFC,
  0x07, 0xF1, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFE, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x87, 0xF0,
  0x07, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_Bold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 11, 52, 19, 4, -51 },
  { 73, 19, 19, 23, 2, -54 },
  { 119, 33, 51, 38, 3, -51 },
  { 330, 30, 67, 36, 3, -59 },
  { 582, 40, 53, 46, 3, -52 },
  { 847, 37, 53, 42, 3, -52 },
  { 1093, 8, 19, 12, 2, -54 },
  { 1112, 17, 73, 23, 4, -57 },
  { 1268, 18, 73, 23, 2, -57 },
  { 1433, 31, 31, 33, 1, -51 },
  { 1554, 30, 37, 34, 2, -43 },
  { 1693, 13, 22, 18, 1, -9 },
  { 1729, 17, 8, 26, 4, -26 },
  { 1746, 12, 11, 21, 4, -10 },
  { 1763, 23, 55, 24, 0, -51 },
  { 1922, 30, 53, 36, 3, -52 },
  { 2121, 19, 51, 36, 6, -51 },
  { 2243, 31, 52, 36, 3, -52 },
  { 2445, 31, 53, 36, 2, -52 },
  { 2651, 32, 51, 36, 2, -51 },
  { 2855, 30, 52, 36, 3, -51 },
  { 3050, 30, 52, 36, 4, -51 },
  { 3245, 31, 51, 36, 2, -51 },
  { 3443, 30, 53, 36, 3, -52 },
  { 3642, 30, 52, 36, 3, -52 },
  { 3837, 12, 40, 20, 4, -39 },
  { 3897, 13, 52, 18, 2, -39 },
  { 3982, 26, 34, 32, 2, -39 },
  { 4093, 26, 23, 36, 5, -34 },
  { 4168, 26, 34, 33, 4, -39 },
  { 4279, 28, 53, 32, 2, -52 },
  { 4465, 49, 66, 55, 3, -50 },
  { 4870, 41, 51, 43, 1, -51 },
  { 5132, 33, 51, 40, 4, -51 },
  { 5343, 36, 53, 41, 3, -52 },
  { 5582, 33, 51, 41, 4, -51 },
  { 5793, 30, 51, 35, 4, -51 },
  { 5985, 28, 51, 34, 4, -51 },
  { 6164, 36, 53, 42, 3, -52 },
  { 6403, 36, 51, 44, 4, -51 },
  { 6633, 10, 51, 19, 5, -51 },
  { 6697, 29, 52, 35, 2, -51 },
  { 6886, 36, 51, 40, 4, -51 },
  { 7116, 29, 51, 34, 4, -51 },
  { 7301, 46, 51, 55, 4, -51 },
  { 7595, 36, 51, 44, 4, -51 },
  { 7825, 37, 53, 43, 3, -52 },
  { 8071, 34, 51, 41, 4, -51 },
  { 8288, 37, 61, 43, 3, -52 },
  { 8571, 34, 51, 40, 4, -51 },
  { 8788, 33, 53, 39, 3, -52 },
  { 9007, 35, 51, 39, 2, -51 },
  { 9231, 33, 52, 41, 4, -51 },
  { 9446, 40, 51, 42, 1, -51 },
  { 9701, 50, 51, 54, 2, -51 },
  { 10020, 38, 51, 40, 1, -51 },
  { 10263, 38, 51, 39, 1, -51 },
  { 10506, 33, 51, 38, 3, -51 },
  { 10717, 14, 72, 19, 4, -60 },
  { 10843, 28, 55, 27, 0, -51 },
  { 11036, 14, 72, 19, 1, -60 },
  { 11162, 24, 26, 28, 2, -51 },
  { 11240, 27, 8, 29, 1, 0 },
  { 11267, 18, 11, 24, 2, -54 },
  { 11292, 29, 40, 34, 3, -39 },
  { 11437, 29, 55, 36, 4, -54 },
  { 11637, 29, 40, 33, 2, -39 },
  { 11782, 30, 55, 36, 2, -54 },
  { 11989, 29, 40, 34, 3, -39 },
  { 12134, 22, 55, 24, 1, -55 },
  { 12286, 31, 54, 36, 2, -39 },
  { 12496, 29, 54, 35, 3, -54 },
  { 12692, 10, 54, 18, 4, -54 },
  { 12760, 16, 69, 18, -2, -54 },
  { 12898, 31, 54, 34, 4, -54 },
  { 13108, 10, 54, 18, 4, -54 },
  { 13176, 46, 39, 53, 4, -39 },
  { 13401, 29, 39, 35, 3, -39 },
  { 13543, 30, 40, 36, 3, -39 },
  { 13693, 29, 54, 36, 4, -39 },
  { 13889, 30, 54, 36, 2, -39 },
  { 14092, 18, 39, 24, 4, -39 },
  { 14180, 28, 40, 33, 2, -39 },
  { 14320, 19, 48, 22, 1, -47 },
  { 14434, 29, 39, 35, 3, -38 },
  { 14576, 30, 38, 32, 1, -38 },
  { 14719, 43, 38, 46, 1, -38 },
  { 14924, 31, 38, 33, 1, -38 },
  { 15072, 30, 53, 32, 1, -38 },
  { 15271, 27, 38, 33, 3, -38 },
  { 15400, 18, 69, 21, 2, -56 },
  { 15556, 6, 61, 18, 6, -51 },
  { 15602, 17, 69, 21, 2, -56 },
  { 15749, 33, 16, 40, 4, -29 },
};

const GFXfont RobotoCondensed_Bold72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_BOLD72PT7B_H_
