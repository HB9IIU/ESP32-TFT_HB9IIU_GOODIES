#ifndef _ROBOTOCONDENSED_BOLD45PT7B_H_
#define _ROBOTOCONDENSED_BOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDE, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x0F, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0x01, 0xE3, 0xC0, 0x1E, 0x38,
  0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x07,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x78,
  0x03, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFE, 0x7F, 0x3F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0xDF, 0x81, 0xFB, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xDF, 0x83, 0xF3, 0xF8, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x08, 0x0F, 0x8F, 0x06, 0x07, 0x87, 0x87, 0x83,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE3, 0xC0, 0xF0, 0xF1, 0xE0, 0x78, 0x79, 0xE0,
  0x3E, 0x3C, 0xE0, 0x0F, 0xFE, 0xF0, 0x07, 0xFE, 0xF0, 0x01, 0xFE, 0x78,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7F, 0x80, 0x0F, 0x7F, 0xE0, 0x0F, 0x7F, 0xF0, 0x07,
  0x3C, 0x78, 0x07, 0x9E, 0x1E, 0x03, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x83,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x30, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E,
  0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0xFC, 0x7F, 0xF1,
  0xF9, 0xFF, 0xF3, 0xE7, 0xF7, 0xE7, 0xCF, 0xCF, 0xEF, 0x9F, 0x8F, 0xFF,
  0x3F, 0x0F, 0xFE, 0x7E, 0x1F, 0xF8, 0xFC, 0x1F, 0xF1, 0xFC, 0x1F, 0xC3,
  0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x80, 0x70, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xC0, 0x20, 0x40,
  0x0C, 0x01, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x38, 0x07,
  0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xC1, 0xC1, 0xBE, 0x38, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x78,
  0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0x81, 0xC0, 0x00, 0x10,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0xC3, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC3, 0xF9, 0xFC, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x1F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFE, 0x7F,
  0xBF, 0x87, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x1F, 0xE7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x81,
  0xF1, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3E, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xDF, 0xC1, 0xF9, 0xFC, 0x7F, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x3E, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0x1F, 0xDF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFC, 0x7F, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x7F,
  0x9F, 0x87, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F,
  0x3F, 0x0F, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x7E, 0x3F, 0x07, 0xEF, 0xE0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xDF, 0xC1, 0xF9,
  0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xFB, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x7F, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xF3, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xEF, 0xFF, 0xFF, 0xFE, 0x78,
  0x1E, 0x1F, 0x8F, 0xCF, 0xF3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xFB, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x7C, 0x07, 0xC0, 0xF0, 0xF0, 0x3F, 0xE0, 0xF1, 0xE0,
  0xFF, 0xE1, 0xE7, 0x81, 0xFF, 0xC3, 0xCF, 0x07, 0xC7, 0x83, 0x9E, 0x0F,
  0x0F, 0x07, 0x7C, 0x3E, 0x1E, 0x0F, 0xF0, 0x78, 0x3C, 0x1F, 0xE1, 0xF0,
  0x78, 0x3F, 0xC3, 0xE0, 0xF0, 0x7F, 0x87, 0xC1, 0xE0, 0xFF, 0x0F, 0x87,
  0xC1, 0xFE, 0x1E, 0x0F, 0x83, 0xBC, 0x3C, 0x1F, 0x07, 0x78, 0x78, 0x3C,
  0x1E, 0xF0, 0xF8, 0x78, 0x3D, 0xE1, 0xF1, 0xF0, 0x73, 0xC3, 0xF3, 0xF1,
  0xE7, 0x83, 0xFF, 0xFF, 0x8F, 0x87, 0xFF, 0xFF, 0x0F, 0x07, 0xF3, 0xFC,
  0x1E, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xC3, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0x1F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7F, 0x7E, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xE3, 0xFC,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xC7, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x3F, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F, 0xE7,
  0xF0, 0x1F, 0x9F, 0xC0, 0x7F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7F, 0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFE, 0x3F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E,
  0xFE, 0x0F, 0xDF, 0xC3, 0xF9, 0xFE, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xEF, 0xC0, 0x7F, 0x3F, 0x03, 0xFC, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F,
  0xC3, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xCF,
  0xE0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x7F, 0x03, 0xF9, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xFC,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xDF, 0xFB, 0xE0, 0x7D, 0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0xF0, 0xF9, 0xFF,
  0xDF, 0x0F, 0xBF, 0xFD, 0xF0, 0xFB, 0xFF, 0xDF, 0x9F, 0xBF, 0xFC, 0xF9,
  0xF3, 0xFF, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F,
  0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC3,
  0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xDF, 0x8F, 0xFF, 0x7E, 0x3F, 0xFC, 0xFC, 0xFF, 0xF3, 0xF3,
  0xFF, 0xC7, 0xEF, 0xFF, 0x1F, 0xBF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F,
  0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7E, 0x0F, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xDF, 0x81, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E, 0x00,
  0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E,
  0x03, 0xF3, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0,
  0xFE, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF9,
  0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xC7, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03,
  0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0x9F, 0xE3, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8,
  0x1F, 0xDF, 0xF3, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0,
  0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0,
  0x7E, 0x7E, 0x0F, 0xF0, 0xFE, 0x7E, 0x0F, 0xF0, 0xFC, 0x3F, 0x0F, 0xF0,
  0xFC, 0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8,
  0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF9, 0xF8, 0x1F, 0xBF, 0xF9,
  0xF8, 0x1F, 0xBE, 0xFD, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D,
  0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBE, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xFB, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78,
  0x3E, 0x78, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0x78, 0x3E,
  0xF8, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0x8F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFD, 0xF8, 0x3E, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x7E, 0xFF, 0x8F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0xFE, 0xFE, 0x0F, 0xDF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xEF, 0xF1, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFD, 0xFF,
  0x1F, 0x8F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x9F, 0x87, 0xFB, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0xFF, 0x7E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xF9, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xF7,
  0xE0, 0xFC, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xC7, 0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x47, 0xF0, 0x79, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF1, 0x00, 0xFC, 0x70, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xC3, 0xF7, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x10, 0xFB, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x01, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x02, 0x03, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC3, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x8F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0xEF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC7, 0xF8,
  0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xE7, 0xE0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x0F, 0x87, 0xEF, 0xF9, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xF1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1,
  0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF,
  0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81,
  0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0,
  0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x7C, 0x3F, 0x7F, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0xC1, 0xF9, 0xFC, 0x7F, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x7C,
  0x1F, 0xBF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFE, 0x3F,
  0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFB, 0xFC, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0x7F, 0xC7, 0xE3, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE1, 0xFE, 0xFC, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xFC, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFD, 0xF8,
  0x3F, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFE, 0xFC, 0x3E, 0x3F, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF8, 0x3F, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x0F,
  0x9F, 0x01, 0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0,
  0xFB, 0xF0, 0xFC, 0x3F, 0x7E, 0x1F, 0x87, 0xE7, 0xC3, 0xF0, 0xFC, 0xFC,
  0x7F, 0x1F, 0x9F, 0x9F, 0xE3, 0xE3, 0xF3, 0xFC, 0x7C, 0x3E, 0x7F, 0x9F,
  0x87, 0xCF, 0xFB, 0xF0, 0xF9, 0xFF, 0x7E, 0x1F, 0xFD, 0xEF, 0x83, 0xFF,
  0xBD, 0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x3E, 0x07, 0xE0, 0xFE, 0x0F, 0xCF, 0xC3, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0xFC,
  0x1F, 0x9F, 0x87, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xF7, 0xF0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x7F, 0x8F, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3C,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x0E, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x1F, 0x87, 0xE0, 0x7C, 0x0E, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0x9F, 0x3E, 0x7F,
  0xFB, 0xE1, 0xFF, 0xDF, 0x07, 0xFC, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 32, 12, 3, -32 },
  { 25, 12, 12, 14, 1, -34 },
  { 43, 20, 32, 24, 2, -32 },
  { 123, 19, 41, 23, 2, -37 },
  { 221, 25, 32, 29, 2, -32 },
  { 321, 23, 32, 26, 2, -32 },
  { 413, 5, 12, 7, 1, -34 },
  { 421, 10, 46, 15, 3, -36 },
  { 479, 11, 46, 15, 1, -36 },
  { 543, 19, 19, 20, 1, -32 },
  { 589, 19, 24, 21, 1, -27 },
  { 646, 7, 13, 11, 1, -5 },
  { 658, 10, 5, 16, 3, -16 },
  { 665, 7, 7, 13, 3, -7 },
  { 672, 14, 35, 15, 0, -32 },
  { 734, 19, 32, 23, 2, -32 },
  { 810, 13, 32, 23, 3, -32 },
  { 862, 19, 32, 23, 2, -32 },
  { 938, 20, 32, 23, 1, -32 },
  { 1018, 20, 32, 23, 1, -32 },
  { 1098, 19, 32, 23, 2, -32 },
  { 1174, 19, 32, 23, 2, -32 },
  { 1250, 20, 32, 23, 1, -32 },
  { 1330, 19, 32, 23, 2, -32 },
  { 1406, 18, 32, 23, 2, -32 },
  { 1478, 7, 25, 12, 3, -25 },
  { 1500, 9, 33, 11, 1, -25 },
  { 1538, 16, 21, 20, 1, -24 },
  { 1580, 17, 14, 23, 3, -21 },
  { 1610, 16, 21, 20, 3, -24 },
  { 1652, 17, 32, 20, 1, -32 },
  { 1720, 31, 41, 34, 2, -31 },
  { 1879, 26, 32, 27, 0, -32 },
  { 1983, 20, 32, 25, 3, -32 },
  { 2063, 22, 32, 26, 2, -32 },
  { 2151, 20, 32, 25, 3, -32 },
  { 2231, 18, 32, 22, 3, -32 },
  { 2303, 17, 32, 21, 3, -32 },
  { 2371, 22, 32, 26, 2, -32 },
  { 2459, 22, 32, 28, 3, -32 },
  { 2547, 6, 32, 12, 3, -32 },
  { 2571, 19, 32, 22, 1, -32 },
  { 2647, 22, 32, 25, 3, -32 },
  { 2735, 17, 32, 22, 3, -32 },
  { 2803, 28, 32, 34, 3, -32 },
  { 2915, 22, 32, 28, 3, -32 },
  { 3003, 23, 32, 27, 2, -32 },
  { 3095, 21, 32, 26, 3, -32 },
  { 3179, 23, 38, 27, 2, -32 },
  { 3289, 21, 32, 25, 3, -32 },
  { 3373, 21, 32, 24, 2, -32 },
  { 3457, 22, 32, 24, 1, -32 },
  { 3545, 21, 32, 26, 2, -32 },
  { 3629, 26, 32, 26, 0, -32 },
  { 3733, 32, 32, 34, 1, -32 },
  { 3861, 23, 32, 25, 1, -32 },
  { 3953, 24, 32, 24, 0, -32 },
  { 4049, 20, 32, 24, 2, -32 },
  { 4129, 9, 44, 12, 2, -37 },
  { 4179, 18, 35, 17, 0, -32 },
  { 4258, 8, 44, 12, 1, -37 },
  { 4302, 16, 16, 18, 1, -32 },
  { 4334, 18, 5, 18, 0, 0 },
  { 4346, 11, 7, 15, 1, -34 },
  { 4356, 18, 24, 21, 2, -24 },
  { 4410, 19, 34, 22, 2, -34 },
  { 4491, 17, 24, 21, 2, -24 },
  { 4542, 19, 34, 22, 1, -34 },
  { 4623, 18, 24, 22, 2, -24 },
  { 4677, 13, 34, 15, 1, -34 },
  { 4733, 18, 33, 23, 2, -24 },
  { 4808, 18, 34, 22, 2, -34 },
  { 4885, 7, 34, 11, 2, -34 },
  { 4915, 10, 43, 11, -1, -34 },
  { 4969, 20, 34, 22, 2, -34 },
  { 5054, 6, 34, 11, 3, -34 },
  { 5080, 29, 24, 33, 2, -24 },
  { 5167, 18, 24, 22, 2, -24 },
  { 5221, 19, 24, 22, 2, -24 },
  { 5278, 19, 33, 22, 2, -24 },
  { 5357, 19, 33, 22, 1, -24 },
  { 5436, 12, 24, 15, 2, -24 },
  { 5472, 18, 24, 20, 1, -24 },
  { 5526, 12, 30, 14, 1, -30 },
  { 5571, 18, 24, 22, 2, -24 },
  { 5625, 19, 24, 20, 1, -24 },
  { 5682, 27, 24, 29, 1, -24 },
  { 5763, 19, 24, 20, 1, -24 },
  { 5820, 20, 33, 20, 0, -24 },
  { 5903, 17, 24, 20, 2, -24 },
  { 5954, 11, 43, 13, 1, -35 },
  { 6014, 4, 38, 11, 4, -32 },
  { 6033, 11, 43, 13, 1, -35 },
  { 6093, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_Bold45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_BOLD45PT7B_H_
