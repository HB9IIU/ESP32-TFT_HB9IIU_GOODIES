#ifndef _ROBOTOCONDENSED_BOLD19PT7B_H_
#define _ROBOTOCONDENSED_BOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x99, 0x99, 0x90, 0x12, 0x16,
  0x36, 0x36, 0xFF, 0xFF, 0x34, 0x24, 0xFF, 0xFF, 0x6C, 0x6C, 0x6C, 0x68,
  0x18, 0x18, 0x3C, 0x7E, 0xE7, 0xE7, 0xE0, 0x70, 0x7C, 0x1E, 0x0E, 0x07,
  0xC7, 0xE7, 0x7E, 0x3C, 0x18, 0x18, 0x70, 0x3E, 0x0D, 0x93, 0x6C, 0xFA,
  0x1D, 0x80, 0x40, 0x30, 0x0B, 0x87, 0xF3, 0x64, 0xD9, 0x27, 0xC0, 0xE0,
  0x3C, 0x1F, 0x06, 0xE1, 0x98, 0x6E, 0x1F, 0x03, 0x81, 0xE6, 0xFD, 0xB3,
  0xEC, 0xF3, 0x9C, 0xFF, 0x9F, 0xE0, 0xFA, 0x80, 0x11, 0xCC, 0xC6, 0x33,
  0x18, 0xC6, 0x31, 0x8C, 0x31, 0x8C, 0x31, 0xC4, 0x8C, 0xC6, 0x67, 0x33,
  0x33, 0x33, 0x37, 0x66, 0xCC, 0x80, 0x08, 0x04, 0x12, 0x5F, 0xE1, 0xC1,
  0xE0, 0xD8, 0x44, 0x38, 0x70, 0xE1, 0xCF, 0xFF, 0xCE, 0x1C, 0x38, 0x70,
  0x77, 0x76, 0x64, 0xFF, 0xC0, 0x7F, 0x80, 0x0C, 0x31, 0x86, 0x18, 0x43,
  0x0C, 0x31, 0x86, 0x18, 0x63, 0x0C, 0x00, 0x3C, 0x7E, 0xE6, 0xE7, 0xE7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0xE6, 0x7E, 0x3C, 0x0C, 0xFF, 0xFF,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x3C, 0xFE, 0xEE, 0xC7,
  0x07, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x3C, 0x7E,
  0xEE, 0xC6, 0x06, 0x0E, 0x3C, 0x3E, 0x06, 0x07, 0xC7, 0xE6, 0xFE, 0x7C,
  0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x7E, 0x6E, 0xEE, 0xCE, 0xFF, 0xFF, 0x0E,
  0x0E, 0x0E, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xFC, 0xFE, 0x47, 0x07, 0x07,
  0xE7, 0xE6, 0x7E, 0x3C, 0x1C, 0x3C, 0x70, 0x60, 0xE0, 0xFC, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x0E, 0x0C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x3C, 0x7E, 0xEE, 0xE6,
  0xE6, 0x6E, 0x7C, 0x7E, 0xE6, 0xE7, 0xE7, 0xE6, 0x7E, 0x3C, 0x3C, 0x7E,
  0xEE, 0xE6, 0xC7, 0xE7, 0xE7, 0x7F, 0x7E, 0x06, 0x0E, 0x1C, 0x3C, 0x30,
  0x7F, 0x80, 0x00, 0x7D, 0x80, 0xFF, 0x80, 0x00, 0x0D, 0xBF, 0xA0, 0x04,
  0x77, 0xFC, 0xC3, 0xC7, 0xC7, 0x04, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x81, 0xC3, 0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x3C, 0x7E, 0x77, 0xE7,
  0x07, 0x06, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x18, 0x18, 0x18, 0x0F, 0x80,
  0xFF, 0x0C, 0x08, 0xC0, 0x64, 0x79, 0x67, 0xCF, 0x36, 0x7B, 0x33, 0xD9,
  0x9E, 0xCC, 0xF6, 0x65, 0xBF, 0x6C, 0xEE, 0x20, 0x01, 0x80, 0x07, 0xF0,
  0x1F, 0x00, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB0, 0x37, 0x0E, 0xE1,
  0xCC, 0x31, 0x87, 0xF9, 0xFF, 0x38, 0x66, 0x0F, 0xC1, 0xC0, 0xFE, 0x7F,
  0xB9, 0xDC, 0x7E, 0x3F, 0x1B, 0xF9, 0xFE, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF,
  0xF7, 0xF0, 0x3E, 0x3F, 0x9C, 0xFC, 0x7E, 0x1F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0xFC, 0x7F, 0x39, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xEF, 0xE7, 0xE0, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x3E, 0x3F, 0x9C, 0xFC, 0x3E, 0x07, 0x03, 0x81, 0xCF, 0xE7,
  0xF0, 0xF8, 0x6E, 0x77, 0xF9, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xE7, 0x77, 0x7E, 0x3C, 0xE3, 0xB9, 0xEE, 0x73,
  0xB8, 0xEE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3B, 0x8E, 0x73, 0x9C, 0xE3,
  0xB8, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x9F, 0xF9, 0xBF, 0xDB, 0xED, 0xBE, 0xF3, 0xEF, 0x3E, 0xF3, 0xE7, 0x3E,
  0x63, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF9, 0xFE, 0x7F, 0xDF, 0xB7, 0xEF,
  0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0x70, 0x3E, 0x1F, 0xC7, 0x3B, 0x86,
  0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x19, 0xCE, 0x7F, 0x0F,
  0x80, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFE, 0xFE, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0xB8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x19, 0xCE, 0x7F, 0x0F, 0xC0, 0x3C,
  0x04, 0xFE, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x9D, 0xFE, 0xFE, 0x77,
  0x39, 0xDC, 0xEE, 0x3F, 0x1C, 0x3C, 0x3F, 0xB9, 0xDC, 0x6E, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0x01, 0xB0, 0xFC, 0xEF, 0xF1, 0xF0, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0xE0, 0xEC, 0x19, 0xC7, 0x38,
  0xE7, 0x1C, 0x63, 0x0E, 0xE1, 0xDC, 0x1B, 0x03, 0x60, 0x7C, 0x0F, 0x80,
  0xE0, 0x1C, 0x00, 0x63, 0x1D, 0x8E, 0x76, 0x39, 0x9D, 0xE6, 0x77, 0x99,
  0xDE, 0xE3, 0x7B, 0x8D, 0xFE, 0x3E, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x1C, 0xF0, 0x71, 0xC0, 0x71, 0xDC, 0x73, 0xB8, 0xEE, 0x1F, 0x07, 0xC0,
  0xE0, 0x78, 0x1F, 0x0F, 0xC3, 0xB9, 0xCE, 0x71, 0xDC, 0x70, 0xE1, 0xDC,
  0x77, 0x38, 0xCE, 0x3B, 0x0F, 0xC1, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEF, 0xF0, 0xE0, 0xC1, 0xC3, 0x83, 0x06, 0x0E, 0x1C, 0x18,
  0x38, 0x70, 0x60, 0xE1, 0xC1, 0x80, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x7F, 0xF0, 0x18, 0x70, 0xE1, 0x66, 0xCC, 0x99, 0x80, 0xFF,
  0xFC, 0x71, 0x86, 0x7D, 0xFF, 0xB8, 0x77, 0xFF, 0xF3, 0xE7, 0xFE, 0xEC,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFE, 0xDC, 0x7D, 0xFF, 0xBE, 0x3C, 0x18, 0x31, 0xF7, 0xFE, 0xF0, 0x06,
  0x0C, 0x18, 0x37, 0x7F, 0xF9, 0xE3, 0xC7, 0x8F, 0x1F, 0x3F, 0xEE, 0xC0,
  0x3C, 0x7E, 0xE6, 0xC6, 0xFF, 0xFF, 0xC0, 0xE2, 0x7E, 0x3C, 0x1C, 0xF3,
  0x0C, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7F, 0xFF, 0xE7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x07, 0x46, 0x7E, 0x7C, 0xE1,
  0xC3, 0x87, 0x0F, 0xDF, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xC0,
  0xDF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x31, 0xCC, 0x03, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x73, 0x00, 0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xEE,
  0xFC, 0xF8, 0xF8, 0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xDC, 0xEF, 0xFF, 0xEF, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xDD, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCC, 0x3C, 0x7E, 0xE6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C,
  0xDC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0,
  0xE0, 0xE0, 0x77, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xF3, 0xFE, 0xEC, 0x18,
  0x30, 0x60, 0xC0, 0xDF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x79, 0xFB,
  0x3F, 0x0F, 0x87, 0x83, 0xE7, 0xFE, 0xF8, 0x73, 0x9D, 0xFF, 0xB9, 0xCE,
  0x73, 0x9C, 0x73, 0x80, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF7, 0xFE,
  0xEC, 0xE7, 0x67, 0x67, 0x76, 0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0x1C, 0xE6,
  0x76, 0x66, 0x6F, 0x66, 0xF6, 0x7F, 0xE7, 0xFE, 0x39, 0xC3, 0x9C, 0x39,
  0xC3, 0x9C, 0x67, 0x76, 0x3E, 0x3C, 0x1C, 0x1C, 0x3E, 0x3E, 0x77, 0x67,
  0xE7, 0x67, 0x67, 0x76, 0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0x1C, 0x18, 0x38,
  0x78, 0x70, 0xFF, 0xFC, 0x70, 0xE3, 0x86, 0x1C, 0x70, 0xFF, 0xFC, 0x13,
  0x66, 0x66, 0x66, 0xCC, 0x66, 0x66, 0x66, 0x31, 0xFF, 0xFF, 0x80, 0x43,
  0x1C, 0xE3, 0x18, 0xC6, 0x39, 0xCC, 0x63, 0x18, 0xCE, 0xE2, 0x00, 0x71,
  0xFD, 0xF7, 0xD8, 0xC0,
};

const GFXglyph RobotoCondensed_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 4, 5, 6, 1, -14 },
  { 10, 8, 14, 10, 1, -14 },
  { 24, 8, 18, 10, 1, -16 },
  { 42, 10, 14, 12, 1, -14 },
  { 60, 10, 14, 11, 1, -14 },
  { 78, 2, 5, 3, 1, -14 },
  { 80, 5, 19, 6, 1, -15 },
  { 92, 4, 19, 6, 1, -15 },
  { 102, 9, 8, 9, 0, -14 },
  { 111, 7, 10, 9, 1, -11 },
  { 120, 4, 6, 5, 0, -2 },
  { 123, 5, 2, 7, 1, -7 },
  { 125, 3, 3, 6, 1, -3 },
  { 127, 6, 15, 6, 0, -14 },
  { 139, 8, 14, 10, 1, -14 },
  { 153, 6, 14, 10, 1, -14 },
  { 164, 8, 14, 10, 1, -14 },
  { 178, 8, 14, 10, 1, -14 },
  { 192, 8, 14, 10, 1, -14 },
  { 206, 8, 14, 10, 1, -14 },
  { 220, 8, 14, 10, 1, -14 },
  { 234, 8, 14, 10, 1, -14 },
  { 248, 8, 14, 10, 1, -14 },
  { 262, 8, 14, 10, 1, -14 },
  { 276, 3, 11, 5, 1, -11 },
  { 281, 3, 15, 5, 1, -11 },
  { 287, 6, 9, 8, 1, -10 },
  { 294, 7, 6, 10, 1, -9 },
  { 300, 7, 9, 9, 1, -10 },
  { 308, 8, 14, 9, 0, -14 },
  { 322, 13, 17, 15, 1, -13 },
  { 350, 11, 14, 11, 0, -14 },
  { 370, 9, 14, 11, 1, -14 },
  { 386, 9, 14, 11, 1, -14 },
  { 402, 9, 14, 11, 1, -14 },
  { 418, 8, 14, 9, 1, -14 },
  { 432, 8, 14, 9, 1, -14 },
  { 446, 9, 14, 11, 1, -14 },
  { 462, 10, 14, 12, 1, -14 },
  { 480, 3, 14, 5, 1, -14 },
  { 486, 8, 14, 9, 0, -14 },
  { 500, 10, 14, 11, 1, -14 },
  { 518, 8, 14, 9, 1, -14 },
  { 532, 12, 14, 14, 1, -14 },
  { 553, 10, 14, 12, 1, -14 },
  { 571, 10, 14, 11, 1, -14 },
  { 589, 9, 14, 11, 1, -14 },
  { 605, 10, 16, 11, 1, -14 },
  { 625, 9, 14, 11, 1, -14 },
  { 641, 9, 14, 10, 1, -14 },
  { 657, 10, 14, 10, 0, -14 },
  { 675, 9, 14, 11, 1, -14 },
  { 691, 11, 14, 11, 0, -14 },
  { 711, 14, 14, 14, 0, -14 },
  { 736, 10, 14, 11, 0, -14 },
  { 754, 10, 14, 10, 0, -14 },
  { 772, 8, 14, 10, 1, -14 },
  { 786, 4, 19, 5, 1, -16 },
  { 796, 7, 15, 7, 0, -14 },
  { 810, 4, 19, 5, 0, -16 },
  { 820, 7, 7, 7, 0, -14 },
  { 827, 7, 2, 8, 0, 0 },
  { 829, 5, 3, 6, 0, -14 },
  { 831, 7, 10, 9, 1, -10 },
  { 840, 8, 14, 9, 1, -14 },
  { 854, 7, 10, 9, 1, -10 },
  { 863, 7, 14, 9, 1, -14 },
  { 876, 8, 10, 9, 1, -10 },
  { 886, 6, 14, 6, 0, -14 },
  { 897, 8, 14, 10, 1, -10 },
  { 911, 7, 14, 9, 1, -14 },
  { 924, 3, 14, 5, 1, -14 },
  { 930, 5, 18, 5, -1, -14 },
  { 942, 8, 14, 9, 1, -14 },
  { 956, 3, 14, 5, 1, -14 },
  { 962, 12, 10, 14, 1, -10 },
  { 977, 7, 10, 9, 1, -10 },
  { 986, 8, 10, 9, 1, -10 },
  { 996, 8, 14, 9, 1, -10 },
  { 1010, 7, 14, 9, 1, -10 },
  { 1023, 5, 10, 6, 1, -10 },
  { 1030, 7, 10, 9, 1, -10 },
  { 1039, 5, 13, 6, 0, -13 },
  { 1048, 7, 10, 9, 1, -10 },
  { 1057, 8, 10, 9, 0, -10 },
  { 1067, 12, 10, 12, 0, -10 },
  { 1082, 8, 10, 9, 0, -10 },
  { 1092, 8, 14, 8, 0, -10 },
  { 1106, 7, 10, 9, 1, -10 },
  { 1115, 4, 18, 6, 1, -15 },
  { 1124, 1, 17, 5, 2, -14 },
  { 1127, 5, 18, 6, 0, -15 },
  { 1139, 9, 4, 11, 1, -7 },
};

const GFXfont RobotoCondensed_Bold19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_BOLD19PT7B_H_
