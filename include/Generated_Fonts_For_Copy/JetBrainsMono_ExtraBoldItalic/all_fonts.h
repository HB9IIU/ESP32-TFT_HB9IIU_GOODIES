#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_ExtraBoldItalic
// Headers: 67

#include "JetBrainsMono_ExtraBoldItalic6pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic7pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic8pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic9pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic10pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic11pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic12pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic13pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic14pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic15pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic16pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic17pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic18pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic19pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic20pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic21pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic22pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic23pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic24pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic25pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic26pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic27pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic28pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic29pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic30pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic31pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic32pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic33pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic34pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic35pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic36pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic37pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic38pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic39pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic40pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic41pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic42pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic43pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic44pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic45pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic46pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic47pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic48pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic49pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic50pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic51pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic52pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic53pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic54pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic55pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic56pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic57pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic58pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic59pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic60pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic61pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic62pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic63pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic64pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic65pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic66pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic67pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic68pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic69pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic70pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic71pt7b.h"
#include "JetBrainsMono_ExtraBoldItalic72pt7b.h"
