#ifndef _JETBRAINSMONO_EXTRABOLDITALIC58PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0x83,
  0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFD, 0xE7, 0xFE, 0x07, 0xFC, 0x78,
  0xFF, 0x81, 0xFF, 0x1E, 0x3F, 0xE0, 0x7F, 0x87, 0x8F, 0xF8, 0x1F, 0xE1,
  0xC0, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x03, 0xFF, 0x3C, 0x00, 0x00, 0xFF,
  0xCF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xE0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x03,
  0xC3, 0xFE, 0x00, 0x00, 0xF0, 0xFF, 0x87, 0xFC, 0x38, 0x3F, 0xC1, 0xFF,
  0x1E, 0x1F, 0xF0, 0x7F, 0xC7, 0x87, 0xFC, 0x1F, 0xF9, 0xE3, 0xFE, 0x07,
  0xFF, 0x7B, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x20, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xFF, 0xE7, 0xE0, 0x00, 0x01, 0xFF,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x9F,
  0x80, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x00, 0x03, 0xF3,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0x87,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x03, 0xFC, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x8F, 0xF9,
  0xFF, 0x3F, 0xC3, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF3, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x0C, 0x03, 0xF0, 0x0E, 0x1F, 0x83, 0xF0, 0x3E, 0x1F, 0xC3, 0xE0,
  0xFE, 0x3F, 0xE1, 0xE3, 0xFE, 0x3F, 0xF9, 0xC7, 0xFF, 0x7F, 0xFD, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x07, 0xC0, 0xFF,
  0x8F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3,
  0xFF, 0x0F, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0,
  0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE7,
  0xE3, 0xFE, 0x1F, 0xE7, 0xF3, 0xFC, 0x3F, 0xEF, 0xF3, 0xFC, 0x3F, 0xCF,
  0xF3, 0xFC, 0x3F, 0xCF, 0xF3, 0xFC, 0x3F, 0xCF, 0xF3, 0xFC, 0x3F, 0xC7,
  0xE3, 0xFC, 0x3F, 0xC3, 0xC7, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0x81,
  0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x07, 0x00, 0xFF, 0x80, 0x30, 0x07, 0xFC,
  0x01, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0x87, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x0F, 0xF3,
  0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x3F, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xCF, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF1, 0xFF,
  0x00, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x1E, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x7E, 0x0F, 0xE0, 0x3F,
  0xF3, 0xF0, 0x7F, 0x03, 0xFF, 0xDF, 0x83, 0xF8, 0x3F, 0xFE, 0xFC, 0x1F,
  0xC1, 0xFE, 0x3F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0xFE, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0xFD, 0xF8, 0x3F, 0x81,
  0xFF, 0xCF, 0xC1, 0xFC, 0x07, 0xFC, 0xFE, 0x0F, 0xE0, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x03,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF,
  0xFC, 0x1F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFE, 0x1F, 0x7F, 0x01, 0xFD, 0xF0, 0xFB, 0xF8, 0x0F, 0xEF, 0x8F, 0xDF,
  0xC0, 0x7F, 0x7C, 0x7D, 0xFE, 0x07, 0xFB, 0xE7, 0xEF, 0xE0, 0x3F, 0x9F,
  0x3E, 0x7F, 0x01, 0xFC, 0xF9, 0xF3, 0xF8, 0x0F, 0xE7, 0xDF, 0xBF, 0xC0,
  0x7F, 0x3E, 0xF9, 0xFE, 0x03, 0xF9, 0xFF, 0xCF, 0xF0, 0x3F, 0xC7, 0xFC,
  0x7F, 0x01, 0xFE, 0x3F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x8F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0xF0, 0x0F, 0xE0, 0x3F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xC0, 0x7F, 0x7E, 0x07, 0xF0, 0x1F, 0xEF, 0xC0, 0xFE, 0x03, 0xFD, 0xF8,
  0x3F, 0xC0, 0x7F, 0x3F, 0x87, 0xF8, 0x0F, 0xE7, 0xF0, 0xFF, 0x01, 0xFC,
  0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xC3, 0xFC, 0x0F, 0xF1, 0xF8, 0x7F, 0x01,
  0xFE, 0x3F, 0x0F, 0xE0, 0x3F, 0xC7, 0xF3, 0xFC, 0x07, 0xF8, 0xFE, 0x7F,
  0x80, 0xFF, 0x1F, 0xCF, 0xF0, 0x1F, 0xC1, 0xF9, 0xFE, 0x03, 0xF8, 0x3F,
  0x3F, 0x80, 0xFF, 0x07, 0xE7, 0xF0, 0x1F, 0xE0, 0xFE, 0xFE, 0x03, 0xFC,
  0x1F, 0xDF, 0xC0, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xE0, 0x3F, 0x7F, 0x01,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF,
  0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xF0, 0x07,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x1F, 0x81, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xE0, 0xFE, 0x3F, 0x83, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0xE1, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0xC1, 0xFC, 0x3F, 0x87, 0xBC, 0x1F, 0xC3, 0xF8, 0x7B, 0xC3, 0xF8, 0x3F,
  0x87, 0xBC, 0x3F, 0x83, 0xF8, 0xFB, 0xC3, 0xF8, 0x3F, 0x0F, 0x3C, 0x3F,
  0x83, 0xF0, 0xF3, 0xC3, 0xF0, 0x3F, 0x0F, 0x3C, 0x7F, 0x03, 0xF1, 0xF3,
  0xC7, 0xF0, 0x7F, 0x1E, 0x3C, 0x7F, 0x07, 0xF1, 0xE3, 0xC7, 0xE0, 0x7F,
  0x1E, 0x3C, 0xFE, 0x07, 0xF3, 0xE3, 0xCF, 0xE0, 0x7F, 0x3C, 0x7C, 0xFC,
  0x07, 0xF3, 0xC7, 0xCF, 0xC0, 0x7F, 0x7C, 0x7D, 0xFC, 0x07, 0xF7, 0xC7,
  0xDF, 0xC0, 0x7E, 0x78, 0x7D, 0xF8, 0x07, 0xE7, 0x87, 0x9F, 0x80, 0x7E,
  0xF8, 0x79, 0xF8, 0x07, 0xEF, 0x07, 0xBF, 0x80, 0x7E, 0xF0, 0x7B, 0xF0,
  0x07, 0xEF, 0x07, 0xBF, 0x00, 0x7F, 0xF0, 0x7B, 0xF0, 0x07, 0xFE, 0x07,
  0xBF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC3, 0xF8,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0xE7,
  0xF8, 0x1F, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0xFF, 0x03, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xCF,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xF0, 0x07, 0xF9, 0xFF,
  0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xBF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF,
  0x80, 0x7F, 0x9F, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xFE, 0x3F, 0xC0, 0x1F,
  0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x7F, 0x80, 0x7F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0xE3,
  0xFC, 0x07, 0xFF, 0xEF, 0xF8, 0x1F, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF,
  0x7F, 0x80, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xF3, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xF0,
  0x07, 0xFD, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xF3, 0xF0,
  0x7F, 0x01, 0xFD, 0xFE, 0x3F, 0xE0, 0x7E, 0xFF, 0x9F, 0xF8, 0x3F, 0xBF,
  0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF,
  0x0F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7E, 0x0F, 0xE1, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x87, 0xE0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x7F, 0x87, 0xF0, 0x7E, 0x1F, 0xE1, 0xFC, 0x1F, 0x87,
  0xF8, 0xFF, 0x0F, 0xC1, 0xFE, 0x3F, 0xC3, 0xF0, 0x7F, 0x0F, 0xF0, 0xFC,
  0x1F, 0xC3, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC3, 0xFC, 0x3F, 0x83,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0xC7, 0xF8, 0x7E, 0x0F, 0xE1, 0xFE,
  0x1F, 0x83, 0xF8, 0x7F, 0x87, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x87,
  0xF0, 0x7E, 0x1F, 0xE1, 0xFC, 0x1F, 0x87, 0xF8, 0xFF, 0x0F, 0xC1, 0xFC,
  0x3F, 0xC3, 0xF0, 0x7F, 0x0F, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xF0, 0x07, 0xF9, 0xFF,
  0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x3F,
  0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFE,
  0x03, 0xFD, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0x3F, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x1F,
  0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0xFF, 0x03,
  0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xCF, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC,
  0x7F, 0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xF8,
  0x03, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x40,
  0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07,
  0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x81, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xC0, 0xFE, 0xFE, 0x0F,
  0xF0, 0x3F, 0x3F, 0x83, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x07, 0xF3, 0xF8,
  0x3B, 0xC1, 0xF8, 0xFE, 0x1E, 0xF0, 0xFE, 0x3F, 0x87, 0xBC, 0x3F, 0x8F,
  0xE1, 0xEF, 0x0F, 0xE3, 0xF8, 0xF3, 0xC3, 0xF0, 0xFE, 0x3C, 0xF1, 0xFC,
  0x3F, 0x8F, 0x3C, 0x7F, 0x0F, 0xE7, 0x8F, 0x1F, 0x83, 0xF9, 0xE3, 0xCF,
  0xE0, 0xFE, 0x78, 0xF3, 0xF8, 0x3F, 0xBE, 0x3C, 0xFC, 0x0F, 0xCF, 0x0F,
  0x7F, 0x03, 0xF3, 0xC3, 0xDF, 0xC0, 0xFC, 0xF1, 0xF7, 0xE0, 0x3F, 0x78,
  0x7D, 0xF8, 0x0F, 0xDE, 0x1F, 0xFE, 0x03, 0xF7, 0x87, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF,
  0xBF, 0xC0, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x80, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0xC0,
  0x7F, 0x3F, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F, 0x07, 0xFF,
  0xFC, 0x7E, 0x03, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 42, 35, 10, -42 },
  { 85, 24, 17, 35, 9, -42 },
  { 136, 36, 42, 35, 0, -42 },
  { 325, 34, 58, 35, 1, -50 },
  { 572, 43, 43, 35, -3, -43 },
  { 804, 34, 44, 35, 0, -43 },
  { 991, 11, 17, 35, 15, -42 },
  { 1015, 25, 56, 35, 8, -49 },
  { 1190, 25, 56, 35, 3, -49 },
  { 1365, 32, 30, 35, 2, -35 },
  { 1485, 30, 28, 35, 3, -33 },
  { 1590, 18, 18, 35, 4, -9 },
  { 1631, 22, 8, 35, 7, -23 },
  { 1653, 13, 12, 35, 9, -11 },
  { 1673, 38, 54, 35, -1, -48 },
  { 1930, 32, 44, 35, 2, -43 },
  { 2106, 29, 42, 35, 2, -42 },
  { 2259, 32, 43, 35, 2, -43 },
  { 2431, 32, 43, 35, 2, -42 },
  { 2603, 31, 42, 35, 2, -42 },
  { 2766, 32, 43, 35, 2, -42 },
  { 2938, 30, 43, 35, 2, -42 },
  { 3100, 31, 42, 35, 5, -42 },
  { 3263, 33, 44, 35, 1, -43 },
  { 3445, 31, 43, 35, 4, -43 },
  { 3612, 16, 33, 35, 9, -32 },
  { 3678, 21, 41, 35, 4, -32 },
  { 3786, 30, 32, 35, 4, -35 },
  { 3906, 29, 22, 35, 3, -30 },
  { 3986, 30, 32, 35, 2, -35 },
  { 4106, 26, 42, 35, 7, -42 },
  { 4243, 37, 53, 35, -1, -43 },
  { 4489, 32, 42, 35, -1, -42 },
  { 4657, 34, 42, 35, 1, -42 },
  { 4836, 33, 44, 35, 2, -43 },
  { 5018, 34, 42, 35, 1, -42 },
  { 5197, 33, 42, 35, 2, -42 },
  { 5371, 34, 42, 35, 2, -42 },
  { 5550, 33, 44, 35, 2, -43 },
  { 5732, 34, 42, 35, 1, -42 },
  { 5911, 32, 42, 35, 2, -42 },
  { 6079, 34, 43, 35, 0, -42 },
  { 6262, 36, 42, 35, 1, -42 },
  { 6451, 27, 42, 35, 3, -42 },
  { 6593, 37, 42, 35, 0, -42 },
  { 6788, 35, 42, 35, 1, -42 },
  { 6972, 32, 44, 35, 2, -43 },
  { 7148, 35, 42, 35, 1, -42 },
  { 7332, 32, 53, 35, 2, -43 },
  { 7544, 34, 42, 35, 1, -42 },
  { 7723, 34, 44, 35, 1, -43 },
  { 7910, 32, 42, 35, 5, -42 },
  { 8078, 34, 43, 35, 2, -42 },
  { 8261, 32, 42, 35, 6, -42 },
  { 8429, 36, 42, 35, 2, -42 },
  { 8618, 38, 42, 35, -1, -42 },
  { 8818, 33, 42, 35, 5, -42 },
  { 8992, 32, 42, 35, 2, -42 },
  { 9160, 27, 54, 35, 6, -48 },
  { 9343, 20, 54, 35, 8, -48 },
  { 9478, 26, 54, 35, 4, -48 },
  { 9654, 28, 22, 35, 4, -42 },
  { 9731, 30, 9, 35, -1, 1 },
  { 9765, 14, 9, 35, 14, -46 },
  { 9781, 31, 33, 35, 2, -32 },
  { 9909, 32, 43, 35, 1, -42 },
  { 10081, 31, 33, 35, 2, -32 },
  { 10209, 33, 43, 35, 2, -42 },
  { 10387, 31, 33, 35, 2, -32 },
  { 10515, 39, 52, 35, -3, -42 },
  { 10769, 31, 42, 35, 2, -32 },
  { 10932, 32, 42, 35, 1, -42 },
  { 11100, 29, 46, 35, 2, -46 },
  { 11267, 32, 56, 35, 0, -46 },
  { 11491, 35, 42, 35, 1, -42 },
  { 11675, 27, 42, 35, 4, -42 },
  { 11817, 34, 32, 35, 0, -32 },
  { 11953, 32, 32, 35, 1, -32 },
  { 12081, 31, 33, 35, 2, -32 },
  { 12209, 33, 42, 35, 0, -32 },
  { 12383, 31, 42, 35, 2, -32 },
  { 12546, 33, 32, 35, 2, -32 },
  { 12678, 32, 33, 35, 1, -32 },
  { 12810, 31, 41, 35, 3, -41 },
  { 12969, 32, 33, 35, 2, -32 },
  { 13101, 32, 32, 35, 4, -32 },
  { 13229, 34, 32, 35, 3, -32 },
  { 13365, 36, 32, 35, -1, -32 },
  { 13509, 31, 42, 35, 2, -32 },
  { 13672, 31, 32, 35, 2, -32 },
  { 13796, 32, 54, 35, 4, -48 },
  { 14012, 17, 54, 35, 10, -48 },
  { 14127, 31, 54, 35, 1, -48 },
  { 14337, 32, 15, 35, 2, -28 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC58PT7B_H_
