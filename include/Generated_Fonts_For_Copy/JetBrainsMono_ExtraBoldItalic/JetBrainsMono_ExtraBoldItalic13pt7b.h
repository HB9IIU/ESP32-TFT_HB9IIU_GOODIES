#ifndef _JETBRAINSMONO_EXTRABOLDITALIC13PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x66, 0x66, 0x04, 0xE0, 0xDE, 0xF6, 0x1B, 0x12, 0x7F, 0x36,
  0x24, 0xFE, 0xFE, 0x48, 0xD8, 0x0C, 0x0C, 0x3E, 0x6B, 0x68, 0x78, 0x3E,
  0x16, 0xD6, 0xFE, 0x7C, 0x10, 0x10, 0x18, 0x4F, 0x22, 0xD0, 0xA8, 0x3C,
  0x03, 0x01, 0xF0, 0xD6, 0x2D, 0x31, 0xC0, 0x0C, 0x3E, 0x36, 0x30, 0x30,
  0x7B, 0xDE, 0xCC, 0xFC, 0x7E, 0x6B, 0x00, 0x09, 0xDC, 0xCC, 0x63, 0x18,
  0xC6, 0x38, 0xE1, 0x00, 0x23, 0x8E, 0x31, 0x8C, 0x63, 0x19, 0xB9, 0x88,
  0x00, 0x10, 0x23, 0x7F, 0xE7, 0x1B, 0x12, 0x00, 0x30, 0xCF, 0xFF, 0x30,
  0xC0, 0x76, 0x6C, 0xFF, 0x5F, 0x80, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x0C, 0x3E, 0x63, 0x62, 0x7E, 0x7E,
  0x66, 0x46, 0x7C, 0x78, 0x1C, 0x79, 0x30, 0x60, 0xC3, 0x06, 0x3F, 0xFE,
  0x0C, 0x3E, 0x77, 0x06, 0x06, 0x0C, 0x18, 0x70, 0x7E, 0xFE, 0x3F, 0x06,
  0x0C, 0x1C, 0x1E, 0x06, 0xC6, 0x7C, 0x7C, 0x0E, 0x38, 0x61, 0x86, 0x6C,
  0xDF, 0xC2, 0x0C, 0x3F, 0x30, 0x60, 0x7E, 0x66, 0x06, 0x06, 0x7C, 0x7C,
  0x0E, 0x30, 0xC3, 0xE7, 0xEC, 0xF1, 0xBF, 0x7C, 0xFF, 0x8F, 0x30, 0xE1,
  0x86, 0x0C, 0x30, 0xE0, 0x0C, 0x3E, 0x63, 0x66, 0x3E, 0x3C, 0x66, 0xC6,
  0x7E, 0x7C, 0x18, 0xFB, 0x1E, 0x3C, 0xDF, 0x86, 0x1C, 0x31, 0xC0, 0x76,
  0x00, 0x0E, 0xE0, 0x39, 0x80, 0x00, 0x39, 0x8C, 0xC0, 0x02, 0x39, 0xE6,
  0x0E, 0x07, 0x03, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x40, 0xF0, 0x78, 0x31,
  0xEF, 0x30, 0x00, 0xF8, 0xC6, 0xFF, 0x60, 0x18, 0xC0, 0x0C, 0x3F, 0x63,
  0x43, 0x5D, 0xDB, 0xD3, 0xD2, 0xDE, 0xC0, 0xC0, 0x70, 0x1C, 0x28, 0xD1,
  0xA2, 0x6F, 0xDF, 0xE3, 0xC6, 0x3E, 0x63, 0x62, 0x7E, 0x7E, 0x66, 0x66,
  0x7E, 0xFC, 0x0C, 0x3E, 0x73, 0x60, 0x60, 0x60, 0x60, 0x66, 0x7E, 0x7C,
  0x3E, 0x67, 0x63, 0x62, 0x66, 0x66, 0x66, 0xFC, 0xF8, 0x3F, 0x30, 0x60,
  0x7E, 0x7E, 0x60, 0x60, 0x7E, 0xFC, 0x3F, 0x20, 0x60, 0x7E, 0x7E, 0x60,
  0x60, 0x60, 0xC0, 0x0C, 0x3E, 0x73, 0x60, 0x60, 0x6E, 0x66, 0x66, 0x7E,
  0x7C, 0x33, 0x63, 0x66, 0x7E, 0x7E, 0x66, 0x66, 0x46, 0xCC, 0x3F, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x7C, 0xFC, 0x1F, 0x06, 0x06, 0x06, 0x06,
  0x06, 0xC6, 0xFC, 0x78, 0x33, 0x66, 0x6E, 0x7C, 0x7C, 0x6C, 0x6C, 0x4C,
  0xC6, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x3F, 0xFC, 0x73, 0x77, 0x77, 0x7B,
  0x5A, 0x46, 0xC6, 0xC6, 0xC6, 0x33, 0x73, 0x7A, 0x7A, 0x7E, 0x4E, 0x4E,
  0xCE, 0xCE, 0x0C, 0x3E, 0x73, 0x62, 0x66, 0x66, 0x66, 0x66, 0x7C, 0x78,
  0x3E, 0x63, 0x63, 0x67, 0x7E, 0x78, 0x60, 0x40, 0xC0, 0x0C, 0x3E, 0x77,
  0x62, 0x66, 0x66, 0x66, 0x66, 0x7C, 0x7C, 0x18, 0x0C, 0x3E, 0x67, 0x63,
  0x66, 0x7E, 0x6C, 0x6C, 0x4C, 0xC6, 0x0C, 0x3E, 0x63, 0x60, 0x78, 0x3E,
  0x06, 0xC6, 0xFE, 0x7C, 0xFE, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60,
  0x33, 0x63, 0x62, 0x66, 0x66, 0x66, 0x66, 0x7C, 0x7C, 0xC7, 0x8D, 0x32,
  0x66, 0x8F, 0x1E, 0x38, 0x70, 0x6D, 0xAA, 0x96, 0xCB, 0x65, 0xA3, 0x51,
  0xB8, 0xDC, 0xEC, 0x00, 0x73, 0x36, 0x3C, 0x1C, 0x18, 0x3C, 0x6C, 0x6C,
  0xC6, 0xC7, 0x6C, 0x6C, 0x78, 0x38, 0x30, 0x30, 0x30, 0x60, 0x3F, 0x06,
  0x0C, 0x1C, 0x18, 0x30, 0x60, 0x7E, 0xFC, 0x3C, 0xF3, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x86, 0x3E, 0xCC, 0xCC, 0x66, 0x66, 0x33, 0x33, 0x3D, 0xF1,
  0x86, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x3C, 0x38, 0xA6, 0xD3, 0xCC, 0xFF,
  0xF0, 0xEC, 0x3F, 0x76, 0x66, 0x66, 0x66, 0x7E, 0x7C, 0x30, 0xC1, 0xFB,
  0xB6, 0x6C, 0xD9, 0xBF, 0xDC, 0x3E, 0xED, 0x83, 0x06, 0x6F, 0xDF, 0x00,
  0x03, 0x03, 0x3E, 0x76, 0x66, 0x66, 0x66, 0x7E, 0x7C, 0x3E, 0xCD, 0x9B,
  0xF4, 0x0D, 0xDE, 0x00, 0x07, 0x86, 0x03, 0x27, 0xE0, 0xC0, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x3C, 0x00, 0x3F, 0x76, 0x66, 0x66, 0x66, 0x7E, 0x24,
  0x0C, 0x7C, 0x30, 0xC1, 0xBB, 0xB6, 0x6C, 0xD9, 0xA3, 0xCC, 0x0C, 0x18,
  0x01, 0xE3, 0xC1, 0x06, 0x0C, 0x7F, 0xFC, 0x06, 0x0C, 0x01, 0xF3, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x67, 0xC0, 0x30, 0x20, 0x67, 0x66, 0x6C, 0x78,
  0x6C, 0x6C, 0xC6, 0xF0, 0xC3, 0x0C, 0x30, 0x86, 0x1F, 0x3C, 0x7F, 0x6B,
  0x5A, 0x5A, 0xD6, 0xD6, 0xD6, 0x6E, 0xED, 0x9B, 0x36, 0x68, 0xF3, 0x00,
  0x3E, 0xED, 0x9B, 0x36, 0x6F, 0x9E, 0x00, 0x7E, 0xED, 0x9B, 0x36, 0x6F,
  0xF7, 0x60, 0xC0, 0x3B, 0x76, 0x66, 0x66, 0x66, 0x7E, 0x74, 0x0C, 0x0C,
  0x2E, 0x77, 0x67, 0x60, 0x60, 0x60, 0xE0, 0x3E, 0xCD, 0x81, 0xF0, 0x7C,
  0xDF, 0x00, 0x30, 0x67, 0xF7, 0xE6, 0x0C, 0x18, 0x3E, 0x38, 0x67, 0x66,
  0x66, 0x66, 0x66, 0x7C, 0x78, 0xC7, 0x9B, 0x32, 0xC7, 0x8E, 0x1C, 0x00,
  0x93, 0x6E, 0xD5, 0xAD, 0xDB, 0xB6, 0x00, 0x67, 0x3E, 0x3C, 0x18, 0x3C,
  0x6C, 0xC6, 0x66, 0xCD, 0x9B, 0x36, 0xEE, 0xC3, 0x06, 0x78, 0x7E, 0xFC,
  0x30, 0xC7, 0x0F, 0xFF, 0x00, 0x06, 0x3C, 0x60, 0xC1, 0x9F, 0x3C, 0x18,
  0x30, 0x60, 0xC1, 0xC0, 0x33, 0x32, 0x66, 0x66, 0x66, 0xCC, 0x30, 0x70,
  0x60, 0xC1, 0x83, 0xC7, 0x9C, 0x30, 0x60, 0xC7, 0x00, 0x73, 0x5A, 0xCE,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 3, 8, 2, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 8, 13, 8, 0, -11 },
  { 30, 10, 10, 8, -1, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 3, 3, 8, 3, -9 },
  { 55, 5, 13, 8, 2, -11 },
  { 64, 5, 13, 8, 1, -11 },
  { 73, 7, 7, 8, 1, -8 },
  { 80, 6, 6, 8, 1, -7 },
  { 85, 4, 4, 8, 1, -2 },
  { 87, 4, 2, 8, 2, -5 },
  { 88, 3, 3, 8, 2, -3 },
  { 90, 8, 12, 8, 0, -11 },
  { 102, 8, 10, 8, 0, -10 },
  { 112, 7, 9, 8, 0, -9 },
  { 120, 8, 10, 8, 0, -10 },
  { 130, 8, 9, 8, 0, -9 },
  { 139, 7, 9, 8, 0, -9 },
  { 147, 8, 9, 8, 0, -9 },
  { 156, 7, 9, 8, 0, -9 },
  { 164, 7, 9, 8, 1, -9 },
  { 172, 8, 10, 8, 0, -10 },
  { 182, 7, 10, 8, 1, -10 },
  { 191, 4, 7, 8, 2, -7 },
  { 195, 5, 9, 8, 1, -7 },
  { 201, 7, 7, 8, 1, -8 },
  { 208, 6, 5, 8, 1, -7 },
  { 212, 7, 7, 8, 0, -8 },
  { 219, 5, 9, 8, 2, -9 },
  { 225, 8, 12, 8, 0, -10 },
  { 237, 7, 9, 8, 0, -9 },
  { 245, 8, 9, 8, 0, -9 },
  { 254, 8, 10, 8, 0, -10 },
  { 264, 8, 9, 8, 0, -9 },
  { 273, 8, 9, 8, 0, -9 },
  { 282, 8, 9, 8, 0, -9 },
  { 291, 8, 10, 8, 0, -10 },
  { 301, 8, 9, 8, 0, -9 },
  { 310, 8, 9, 8, 0, -9 },
  { 319, 8, 9, 8, 0, -9 },
  { 328, 8, 9, 8, 0, -9 },
  { 337, 6, 9, 8, 1, -9 },
  { 344, 8, 9, 8, 0, -9 },
  { 353, 8, 9, 8, 0, -9 },
  { 362, 8, 10, 8, 0, -10 },
  { 372, 8, 9, 8, 0, -9 },
  { 381, 8, 12, 8, 0, -10 },
  { 393, 8, 9, 8, 0, -9 },
  { 402, 8, 10, 8, 0, -10 },
  { 412, 7, 9, 8, 1, -9 },
  { 420, 8, 9, 8, 0, -9 },
  { 429, 7, 9, 8, 1, -9 },
  { 437, 9, 9, 8, 0, -9 },
  { 448, 8, 9, 8, 0, -9 },
  { 457, 8, 9, 8, 1, -9 },
  { 466, 8, 9, 8, 0, -9 },
  { 475, 6, 12, 8, 1, -11 },
  { 484, 4, 12, 8, 2, -11 },
  { 490, 6, 12, 8, 1, -11 },
  { 499, 6, 5, 8, 1, -9 },
  { 503, 6, 2, 8, 0, 0 },
  { 505, 3, 2, 8, 3, -10 },
  { 506, 8, 7, 8, 0, -7 },
  { 513, 7, 9, 8, 0, -9 },
  { 521, 7, 7, 8, 0, -7 },
  { 528, 8, 9, 8, 0, -9 },
  { 537, 7, 7, 8, 0, -7 },
  { 544, 9, 11, 8, -1, -9 },
  { 557, 8, 9, 8, 0, -7 },
  { 566, 7, 9, 8, 0, -9 },
  { 574, 7, 10, 8, 0, -10 },
  { 583, 7, 12, 8, 0, -10 },
  { 594, 8, 9, 8, 0, -9 },
  { 603, 6, 9, 8, 1, -9 },
  { 610, 8, 7, 8, 0, -7 },
  { 617, 7, 7, 8, 0, -7 },
  { 624, 7, 7, 8, 0, -7 },
  { 631, 7, 9, 8, 0, -7 },
  { 639, 8, 9, 8, 0, -7 },
  { 648, 8, 7, 8, 0, -7 },
  { 655, 7, 7, 8, 0, -7 },
  { 662, 7, 9, 8, 1, -9 },
  { 670, 8, 7, 8, 0, -7 },
  { 677, 7, 7, 8, 1, -7 },
  { 684, 7, 7, 8, 1, -7 },
  { 691, 8, 7, 8, 0, -7 },
  { 698, 7, 9, 8, 0, -7 },
  { 706, 7, 7, 8, 0, -7 },
  { 713, 7, 12, 8, 1, -11 },
  { 724, 4, 12, 8, 2, -11 },
  { 730, 7, 12, 8, 0, -11 },
  { 741, 8, 3, 8, 0, -6 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC13PT7B_H_
