#ifndef _JETBRAINSMONO_EXTRABOLDITALIC12PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x82, 0xC0, 0xDE, 0xF5, 0x20, 0x12, 0x12, 0x7F, 0x24,
  0x24, 0x68, 0xFE, 0x48, 0xD0, 0x08, 0x38, 0xFB, 0x77, 0x07, 0x87, 0x0B,
  0xFC, 0xF0, 0x81, 0x00, 0x18, 0x94, 0x8A, 0x87, 0x80, 0xC0, 0xF8, 0xF4,
  0x52, 0xCE, 0x00, 0x1C, 0x7C, 0x81, 0x07, 0x1B, 0xF7, 0x6E, 0x7C, 0x7F,
  0x19, 0xD9, 0x8C, 0x63, 0x18, 0xC7, 0x18, 0x20, 0x63, 0x8E, 0x31, 0x8C,
  0x46, 0x37, 0x31, 0x00, 0x18, 0xB7, 0xB8, 0xC6, 0xC9, 0x00, 0x30, 0xCF,
  0xFF, 0x21, 0x80, 0x76, 0xCC, 0x7F, 0xC0, 0xD8, 0x07, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x1C, 0x7D, 0x9B, 0x37, 0xE8,
  0xD1, 0x36, 0x78, 0x1C, 0xF6, 0x92, 0x18, 0x61, 0x9F, 0xFC, 0x1C, 0x7D,
  0x98, 0x30, 0xC3, 0x0C, 0x3E, 0xFC, 0x3E, 0x7C, 0x30, 0xC1, 0xC0, 0x81,
  0x76, 0x78, 0x06, 0x18, 0x61, 0x86, 0x68, 0x9F, 0x46, 0x0C, 0x3E, 0x7D,
  0x83, 0x67, 0xC0, 0xC1, 0x36, 0x78, 0x0C, 0x30, 0xC1, 0x87, 0xCC, 0xF1,
  0xB6, 0x78, 0xFF, 0xFC, 0xC6, 0x18, 0xC2, 0x18, 0xC0, 0x1C, 0x7D, 0x9B,
  0x33, 0x8D, 0xB1, 0x76, 0x78, 0x39, 0xFC, 0xF3, 0xFD, 0xE3, 0x08, 0xE0,
  0x6C, 0x01, 0xB0, 0x33, 0x00, 0x07, 0x6C, 0xC0, 0x0C, 0xEE, 0x30, 0x78,
  0x60, 0xFC, 0x00, 0x3E, 0x60, 0x70, 0x38, 0x67, 0x9C, 0x00, 0x71, 0xF0,
  0xC6, 0x79, 0x80, 0x10, 0xE0, 0x1C, 0x36, 0x42, 0x5E, 0xD2, 0xD2, 0xF6,
  0x9E, 0x80, 0xC0, 0x70, 0x1C, 0x73, 0xCF, 0x2D, 0xB7, 0xF3, 0xC4, 0x3C,
  0xFD, 0x9B, 0x37, 0x8C, 0xD1, 0xA6, 0xF8, 0x1C, 0x7D, 0x9B, 0x06, 0x0C,
  0x11, 0x36, 0x78, 0x3C, 0xFD, 0x9B, 0x36, 0x6C, 0xD1, 0x7E, 0xF8, 0x3E,
  0x7D, 0x83, 0x07, 0xCC, 0x18, 0x3E, 0xFC, 0x3E, 0x7D, 0x83, 0x07, 0xCF,
  0x98, 0x20, 0xC0, 0x1C, 0x7D, 0x9B, 0x06, 0xEF, 0xD1, 0x36, 0x78, 0x26,
  0xCD, 0x9B, 0x37, 0xEC, 0x93, 0x26, 0xCC, 0x3E, 0x7C, 0x60, 0xC1, 0x83,
  0x04, 0x3E, 0xFC, 0x1E, 0x3C, 0x18, 0x30, 0x41, 0xB3, 0x6E, 0x78, 0x23,
  0x66, 0x6C, 0x6C, 0x78, 0x68, 0x4C, 0xCC, 0xCC, 0x63, 0x11, 0x8C, 0x63,
  0x1F, 0xF8, 0x67, 0x76, 0x5E, 0x5A, 0x5E, 0x46, 0xC6, 0xC4, 0xC4, 0x32,
  0xE5, 0xDB, 0xB5, 0x6B, 0xD7, 0x66, 0xCC, 0x1C, 0x7D, 0x9B, 0x36, 0x6C,
  0xD1, 0x36, 0x78, 0x3C, 0xFD, 0x9B, 0x37, 0xEF, 0x10, 0x20, 0xC0, 0x1C,
  0x7D, 0x9B, 0x36, 0x6C, 0xD1, 0x36, 0x78, 0x30, 0x30, 0x3C, 0xFD, 0x9B,
  0x37, 0xCF, 0x12, 0x66, 0xCC, 0x1C, 0x7D, 0x9B, 0x03, 0xC1, 0x81, 0xF6,
  0x78, 0xFF, 0xF8, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0x22, 0xCD, 0x9B,
  0x36, 0x6C, 0xD1, 0x36, 0x78, 0xC7, 0x9B, 0x36, 0x45, 0x8B, 0x14, 0x38,
  0x60, 0x4B, 0x5B, 0x5A, 0x5A, 0x5E, 0x6E, 0x6C, 0x6C, 0xCC, 0x67, 0x36,
  0x3C, 0x38, 0x18, 0x38, 0x6C, 0x6C, 0xCC, 0xC7, 0x99, 0x33, 0xC7, 0x06,
  0x08, 0x30, 0x60, 0x3E, 0x7C, 0x30, 0xE1, 0x86, 0x18, 0x3E, 0xFC, 0x3C,
  0xF3, 0x08, 0x61, 0x86, 0x18, 0x61, 0x0F, 0x00, 0xCC, 0xCC, 0x46, 0x66,
  0x62, 0x30, 0x7B, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0xBC, 0x30, 0xE7, 0x92,
  0xCC, 0xFF, 0xF0, 0xE0, 0x36, 0xFD, 0x9B, 0x24, 0xCD, 0x9F, 0x00, 0x20,
  0xC1, 0xB3, 0xF6, 0x6C, 0xD1, 0x36, 0xF8, 0x18, 0xFD, 0x9B, 0x04, 0x0D,
  0x9E, 0x00, 0x06, 0x0C, 0xDB, 0xF6, 0x6C, 0x93, 0x36, 0x7C, 0x18, 0xF9,
  0x9B, 0xF4, 0x0D, 0x9E, 0x00, 0x07, 0x0F, 0x0C, 0x3F, 0x3F, 0x18, 0x18,
  0x18, 0x18, 0x30, 0xF0, 0x36, 0xFD, 0x9B, 0x24, 0xCF, 0x8B, 0x06, 0x78,
  0x20, 0xC1, 0xB3, 0xF6, 0x6C, 0x91, 0x26, 0xCC, 0x08, 0x30, 0x0E, 0x78,
  0x61, 0x86, 0x7F, 0xF0, 0x04, 0x1C, 0x01, 0xE3, 0xC1, 0x83, 0x06, 0x08,
  0x33, 0xE7, 0x80, 0x20, 0xC1, 0x9B, 0x36, 0xCF, 0x1E, 0x26, 0xCC, 0xF3,
  0xC3, 0x08, 0x21, 0x86, 0x1F, 0x38, 0x56, 0xFD, 0x5A, 0xBD, 0x7A, 0xBD,
  0x00, 0x6C, 0xFD, 0x9B, 0x24, 0x49, 0xB3, 0x00, 0x18, 0xF9, 0x9B, 0x34,
  0x4D, 0x9E, 0x00, 0x6C, 0xFD, 0x9B, 0x34, 0x4D, 0xBE, 0x60, 0xC0, 0x36,
  0xFD, 0x9B, 0x24, 0xCD, 0x9F, 0x06, 0x0C, 0x6C, 0xFD, 0x9B, 0x06, 0x08,
  0x30, 0x00, 0x1C, 0xFD, 0x83, 0xE0, 0xD9, 0x9F, 0x00, 0x33, 0xFF, 0xD8,
  0x61, 0x87, 0x9E, 0x66, 0xCD, 0x9B, 0x24, 0x4D, 0x9E, 0x00, 0xCF, 0x3C,
  0xB6, 0x51, 0xC6, 0x00, 0xB7, 0x6A, 0xD6, 0xED, 0x9B, 0x36, 0x00, 0x66,
  0x58, 0xF0, 0xC3, 0x8D, 0xB3, 0x00, 0x66, 0xCD, 0x9B, 0x24, 0xCF, 0x8B,
  0x06, 0x78, 0x7E, 0xFC, 0x30, 0xC3, 0x0F, 0xBF, 0x00, 0x0C, 0x71, 0x84,
  0x33, 0x8F, 0x0C, 0x30, 0xC3, 0x80, 0x32, 0x66, 0x66, 0x64, 0xCC, 0xC0,
  0x30, 0x70, 0x60, 0x81, 0x03, 0xCF, 0x18, 0x30, 0x63, 0x80, 0x30, 0xEF,
  0x78,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 5, 4, 7, 2, -9 },
  { 8, 8, 9, 7, 0, -9 },
  { 17, 7, 12, 7, 0, -10 },
  { 28, 9, 9, 7, -1, -9 },
  { 39, 7, 9, 7, 0, -9 },
  { 47, 2, 4, 7, 3, -9 },
  { 48, 5, 12, 7, 2, -10 },
  { 56, 5, 12, 7, 1, -10 },
  { 64, 7, 6, 7, 0, -7 },
  { 70, 6, 6, 7, 1, -7 },
  { 75, 4, 4, 7, 1, -2 },
  { 77, 5, 2, 7, 1, -5 },
  { 79, 3, 2, 7, 2, -2 },
  { 80, 8, 11, 7, 0, -10 },
  { 91, 7, 9, 7, 0, -9 },
  { 99, 6, 9, 7, 0, -9 },
  { 106, 7, 9, 7, 0, -9 },
  { 114, 7, 9, 7, 0, -9 },
  { 122, 7, 9, 7, 0, -9 },
  { 130, 7, 9, 7, 0, -9 },
  { 138, 7, 9, 7, 0, -9 },
  { 146, 6, 9, 7, 1, -9 },
  { 153, 7, 9, 7, 0, -9 },
  { 161, 6, 9, 7, 1, -9 },
  { 168, 3, 7, 7, 2, -7 },
  { 171, 4, 9, 7, 1, -7 },
  { 176, 6, 6, 7, 1, -7 },
  { 181, 6, 4, 7, 1, -6 },
  { 184, 7, 6, 7, 0, -7 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 8, 11, 7, 0, -9 },
  { 208, 6, 9, 7, 0, -9 },
  { 215, 7, 9, 7, 0, -9 },
  { 223, 7, 9, 7, 0, -9 },
  { 231, 7, 9, 7, 0, -9 },
  { 239, 7, 9, 7, 0, -9 },
  { 247, 7, 9, 7, 0, -9 },
  { 255, 7, 9, 7, 0, -9 },
  { 263, 7, 9, 7, 0, -9 },
  { 271, 7, 9, 7, 0, -9 },
  { 279, 7, 9, 7, 0, -9 },
  { 287, 8, 9, 7, 0, -9 },
  { 296, 5, 9, 7, 1, -9 },
  { 302, 8, 9, 7, 0, -9 },
  { 311, 7, 9, 7, 0, -9 },
  { 319, 7, 9, 7, 0, -9 },
  { 327, 7, 9, 7, 0, -9 },
  { 335, 7, 11, 7, 0, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 7, 9, 7, 0, -9 },
  { 361, 7, 9, 7, 1, -9 },
  { 369, 7, 9, 7, 0, -9 },
  { 377, 7, 9, 7, 1, -9 },
  { 385, 8, 9, 7, 0, -9 },
  { 394, 8, 9, 7, 0, -9 },
  { 403, 7, 9, 7, 1, -9 },
  { 411, 7, 9, 7, 0, -9 },
  { 419, 6, 11, 7, 1, -10 },
  { 428, 4, 11, 7, 2, -10 },
  { 434, 5, 11, 7, 1, -10 },
  { 441, 6, 5, 7, 1, -9 },
  { 445, 6, 2, 7, 0, 0 },
  { 447, 3, 1, 7, 3, -9 },
  { 448, 7, 7, 7, 0, -7 },
  { 455, 7, 9, 7, 0, -9 },
  { 463, 7, 7, 7, 0, -7 },
  { 470, 7, 9, 7, 0, -9 },
  { 478, 7, 7, 7, 0, -7 },
  { 485, 8, 11, 7, -1, -9 },
  { 496, 7, 9, 7, 0, -7 },
  { 504, 7, 9, 7, 0, -9 },
  { 512, 6, 10, 7, 0, -10 },
  { 520, 7, 12, 7, 0, -10 },
  { 531, 7, 9, 7, 0, -9 },
  { 539, 6, 9, 7, 1, -9 },
  { 546, 7, 7, 7, 0, -7 },
  { 553, 7, 7, 7, 0, -7 },
  { 560, 7, 7, 7, 0, -7 },
  { 567, 7, 9, 7, 0, -7 },
  { 575, 7, 9, 7, 0, -7 },
  { 583, 7, 7, 7, 0, -7 },
  { 590, 7, 7, 7, 0, -7 },
  { 597, 6, 8, 7, 1, -8 },
  { 603, 7, 7, 7, 0, -7 },
  { 610, 6, 7, 7, 1, -7 },
  { 616, 7, 7, 7, 1, -7 },
  { 623, 7, 7, 7, 0, -7 },
  { 630, 7, 9, 7, 0, -7 },
  { 638, 7, 7, 7, 0, -7 },
  { 645, 6, 11, 7, 1, -10 },
  { 654, 4, 11, 7, 2, -10 },
  { 660, 7, 11, 7, 0, -10 },
  { 670, 7, 3, 7, 0, -6 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC12PT7B_H_
