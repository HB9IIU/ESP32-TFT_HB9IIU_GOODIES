#ifndef _JETBRAINSMONO_EXTRABOLDITALIC64PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF3, 0xFF,
  0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xF7, 0xFF, 0x80, 0xFF,
  0xE7, 0x8F, 0xFC, 0x07, 0xFE, 0x3C, 0x7F, 0xE0, 0x3F, 0xE1, 0xE1, 0xFF,
  0x03, 0xFF, 0x0F, 0x0F, 0xF8, 0x1F, 0xF8, 0xF8, 0x00, 0x00, 0xFF, 0xC7,
  0x80, 0x00, 0x07, 0xFE, 0x3C, 0x00, 0x00, 0x3F, 0xF9, 0xE0, 0x00, 0x01,
  0xFF, 0xEF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xCF, 0xFF, 0x00,
  0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0x87,
  0xFE, 0x00, 0x00, 0x78, 0x3F, 0xF0, 0xFF, 0xC3, 0xC1, 0xFF, 0x87, 0xFE,
  0x1E, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xFF, 0xC1, 0xFF, 0xC7, 0x8F, 0xFE,
  0x0F, 0xFF, 0x7C, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xCF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x7F, 0x80,
  0x00, 0x07, 0xF3, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0xFF, 0xCF, 0xF8, 0x3F, 0xE1, 0xFF, 0x3F, 0xE0,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0xFF, 0xCF, 0xFC,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x01, 0xFC, 0x01,
  0x83, 0xE0, 0x3F, 0x01, 0xF0, 0xFF, 0x07, 0xE0, 0xFF, 0x1F, 0xF0, 0xF8,
  0x7F, 0xE7, 0xFF, 0x1F, 0x1F, 0xFC, 0xFF, 0xF9, 0xCF, 0xFF, 0xBF, 0xFF,
  0xBB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x7F,
  0xE3, 0xFF, 0x8F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x7F,
  0xF9, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFF, 0x0F, 0x07, 0xFC, 0x1F, 0xF3, 0xFC, 0x7F, 0xC1, 0xFF, 0x3F,
  0xC7, 0xFC, 0x1F, 0xF3, 0xFC, 0x7F, 0xC1, 0xFF, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF3, 0xFC, 0xFF, 0x83, 0xFE, 0x3F, 0xCF, 0xF8, 0x3F, 0xE3, 0xF8, 0xFF,
  0x83, 0xFE, 0x0F, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x03,
  0xF8, 0x3F, 0xE0, 0x07, 0xE0, 0x7F, 0xE0, 0x07, 0xC0, 0x7F, 0xE0, 0x07,
  0x00, 0x7F, 0xE0, 0x06, 0x00, 0x7F, 0xE0, 0x04, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0x1F, 0xF3, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFF,
  0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xFB, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xEF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC,
  0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0x87, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x7F,
  0x07, 0xF8, 0x07, 0xFF, 0x3F, 0x83, 0xFC, 0x07, 0xFF, 0x9F, 0xC1, 0xFE,
  0x07, 0xFF, 0xEF, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0xF0, 0x3F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xE1,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xE7, 0xE0, 0x7F, 0x81,
  0xFF, 0xF3, 0xF0, 0x3F, 0x80, 0x7F, 0xF3, 0xF8, 0x1F, 0xC0, 0x1F, 0xE1,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xF0, 0x7F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0xFE, 0x03, 0xFB,
  0xE0, 0x7F, 0xFE, 0x03, 0xFB, 0xE0, 0x7D, 0xFE, 0x07, 0xFB, 0xE0, 0xFD,
  0xFE, 0x07, 0xFB, 0xF0, 0xFD, 0xFC, 0x07, 0xFB, 0xF1, 0xFB, 0xFC, 0x07,
  0xFB, 0xF1, 0xFB, 0xFC, 0x07, 0xFB, 0xF3, 0xF3, 0xFC, 0x07, 0xFB, 0xF3,
  0xF3, 0xFC, 0x07, 0xFB, 0xF3, 0xF7, 0xFC, 0x0F, 0xF9, 0xF7, 0xE7, 0xF8,
  0x0F, 0xF1, 0xF7, 0xE7, 0xF8, 0x0F, 0xF1, 0xF7, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFF, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0xCF, 0xF8, 0x0F, 0xF1, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0x1F, 0xEF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xBF, 0x81, 0xFF, 0x01, 0xFE, 0xFE, 0x07, 0xFC,
  0x07, 0xFB, 0xF8, 0x1F, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0x80, 0x7F, 0x9F,
  0xC1, 0xFE, 0x03, 0xFE, 0x7F, 0x07, 0xF8, 0x0F, 0xF1, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC7, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F,
  0x8F, 0xF8, 0x0F, 0xF0, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xF8, 0xFF, 0x01,
  0xFF, 0x0F, 0xE3, 0xFC, 0x07, 0xFC, 0x3F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0xFF, 0x01, 0xFE, 0x07, 0xF7, 0xF8, 0x0F,
  0xF8, 0x1F, 0xDF, 0xE0, 0x3F, 0xE0, 0x7F, 0x7F, 0x80, 0xFF, 0x81, 0xFD,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x81, 0xFE, 0x1F, 0xC0, 0xF7, 0x81, 0xFE,
  0x1F, 0xC0, 0xF7, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xC1,
  0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0xC1, 0xEF, 0x83,
  0xF8, 0x3F, 0xC3, 0xEF, 0x87, 0xF8, 0x3F, 0xC3, 0xEF, 0x87, 0xF8, 0x3F,
  0xC3, 0xEF, 0x87, 0xF0, 0x3F, 0xC3, 0xCF, 0x87, 0xF0, 0x3F, 0x87, 0xCF,
  0x8F, 0xF0, 0x3F, 0x87, 0xCF, 0x8F, 0xF0, 0x3F, 0x87, 0xCF, 0x8F, 0xE0,
  0x3F, 0x87, 0x8F, 0x0F, 0xE0, 0x3F, 0x8F, 0x8F, 0x0F, 0xE0, 0x3F, 0x8F,
  0x8F, 0x1F, 0xE0, 0x3F, 0x8F, 0x8F, 0x1F, 0xC0, 0x3F, 0x9F, 0x0F, 0x1F,
  0xC0, 0x3F, 0x9F, 0x1F, 0x1F, 0xC0, 0x3F, 0x9F, 0x1F, 0x3F, 0xC0, 0x7F,
  0x9E, 0x1F, 0x3F, 0x80, 0x7F, 0xBE, 0x1F, 0x3F, 0x80, 0x7F, 0x3E, 0x1F,
  0x3F, 0x80, 0x7F, 0x3E, 0x1F, 0x7F, 0x80, 0x7F, 0x3C, 0x1F, 0x7F, 0x00,
  0x7F, 0x7C, 0x1F, 0x7F, 0x00, 0x7F, 0x7C, 0x1F, 0x7F, 0x00, 0x7F, 0x7C,
  0x1F, 0x7F, 0x00, 0x7F, 0x78, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7E,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00,
  0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFC,
  0x01, 0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xF7,
  0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF,
  0xFB, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F,
  0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x81,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0xFF,
  0x9F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xBF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xF8, 0x07, 0xFC, 0xFF,
  0xFE, 0x00, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF,
  0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xBF,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00,
  0x7F, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xF7, 0xFC,
  0x07, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFB,
  0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF,
  0xF8, 0x07, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xE0, 0x07, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0x9F,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xBF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x04, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x1F, 0xE7, 0xF8, 0x7F, 0x80, 0x7F, 0xBF, 0xE3,
  0xFF, 0x01, 0xFE, 0xFF, 0xDF, 0xFE, 0x07, 0xF7, 0xFF, 0x7F, 0xF8, 0x1F,
  0xDF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF8, 0x7F, 0xC1, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x07, 0xFC, 0x3F, 0xE0,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xF0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE,
  0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0xF8,
  0x03, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xF8, 0x03, 0xFE,
  0x7F, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xDF,
  0xF0, 0x3F, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF,
  0xBF, 0xE0, 0x3F, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0x80, 0x3F,
  0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xE0, 0x03, 0xFE, 0x3F,
  0xFF, 0x00, 0x3F, 0xEF, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F,
  0xDF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xC0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0x07, 0xF3, 0xFC,
  0x0F, 0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFF, 0x03,
  0xF8, 0xFF, 0x07, 0xBC, 0x1F, 0xE3, 0xFC, 0x1E, 0xF0, 0x7F, 0x8F, 0xF0,
  0xFB, 0xC1, 0xFC, 0x3F, 0xC3, 0xCF, 0x07, 0xF0, 0xFF, 0x0F, 0x3C, 0x3F,
  0xC3, 0xFC, 0x7C, 0xF0, 0xFE, 0x0F, 0xF1, 0xE3, 0xC3, 0xF8, 0x3F, 0xC7,
  0x8F, 0x1F, 0xE0, 0xFF, 0x3E, 0x3C, 0x7F, 0x03, 0xFC, 0xF9, 0xF1, 0xFC,
  0x0F, 0xF3, 0xC7, 0xCF, 0xF0, 0x3F, 0x9F, 0x1F, 0x3F, 0xC0, 0xFE, 0x7C,
  0x7C, 0xFE, 0x03, 0xF9, 0xE1, 0xF3, 0xF8, 0x0F, 0xE7, 0x87, 0xDF, 0xE0,
  0x3F, 0xBE, 0x1F, 0x7F, 0x00, 0xFE, 0xF8, 0x7D, 0xFC, 0x03, 0xFB, 0xC1,
  0xF7, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x7F, 0xC0,
  0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF3, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0x00, 0xFE,
  0x1F, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0xFF, 0xF8,
  0x1F, 0xE3, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0x87, 0xFE, 0x3F, 0xE7, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xFF, 0xF8,
  0x7F, 0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 18, 47, 38, 11, -47 },
  { 107, 27, 19, 38, 9, -47 },
  { 172, 40, 47, 38, 0, -47 },
  { 407, 37, 65, 38, 1, -56 },
  { 708, 48, 47, 38, -4, -47 },
  { 990, 38, 48, 38, 0, -47 },
  { 1218, 12, 19, 38, 17, -47 },
  { 1247, 29, 62, 38, 8, -54 },
  { 1472, 28, 62, 38, 3, -54 },
  { 1689, 35, 34, 38, 3, -39 },
  { 1838, 33, 30, 38, 3, -36 },
  { 1962, 19, 20, 38, 5, -10 },
  { 2010, 24, 9, 38, 8, -26 },
  { 2037, 14, 13, 38, 10, -12 },
  { 2060, 42, 60, 38, -1, -53 },
  { 2375, 36, 48, 38, 2, -47 },
  { 2591, 32, 47, 38, 2, -47 },
  { 2779, 35, 47, 38, 2, -47 },
  { 2985, 35, 48, 38, 2, -47 },
  { 3195, 35, 47, 38, 2, -47 },
  { 3401, 35, 48, 38, 2, -47 },
  { 3611, 34, 48, 38, 2, -47 },
  { 3815, 35, 47, 38, 5, -47 },
  { 4021, 36, 48, 38, 2, -47 },
  { 4237, 33, 47, 38, 5, -47 },
  { 4431, 18, 37, 38, 10, -36 },
  { 4515, 23, 46, 38, 5, -36 },
  { 4648, 33, 36, 38, 4, -39 },
  { 4797, 32, 25, 38, 4, -34 },
  { 4897, 33, 36, 38, 2, -39 },
  { 5046, 29, 47, 38, 7, -47 },
  { 5217, 41, 58, 38, -1, -47 },
  { 5515, 35, 47, 38, -1, -47 },
  { 5721, 37, 47, 38, 1, -47 },
  { 5939, 36, 48, 38, 2, -47 },
  { 6155, 37, 47, 38, 1, -47 },
  { 6373, 37, 47, 38, 2, -47 },
  { 6591, 37, 47, 38, 2, -47 },
  { 6809, 36, 48, 38, 2, -47 },
  { 7025, 38, 47, 38, 1, -47 },
  { 7249, 36, 47, 38, 2, -47 },
  { 7461, 38, 48, 38, 0, -47 },
  { 7689, 40, 47, 38, 1, -47 },
  { 7924, 30, 47, 38, 3, -47 },
  { 8101, 40, 47, 38, 0, -47 },
  { 8336, 38, 47, 38, 1, -47 },
  { 8560, 36, 48, 38, 2, -47 },
  { 8776, 38, 47, 38, 1, -47 },
  { 9000, 36, 59, 38, 2, -47 },
  { 9266, 38, 47, 38, 1, -47 },
  { 9490, 37, 48, 38, 1, -47 },
  { 9712, 34, 47, 38, 6, -47 },
  { 9912, 37, 48, 38, 2, -47 },
  { 10134, 35, 47, 38, 6, -47 },
  { 10340, 40, 47, 38, 2, -47 },
  { 10575, 43, 47, 38, -2, -47 },
  { 10828, 36, 47, 38, 6, -47 },
  { 11040, 36, 47, 38, 2, -47 },
  { 11252, 29, 60, 38, 7, -53 },
  { 11470, 22, 60, 38, 9, -53 },
  { 11635, 29, 60, 38, 4, -53 },
  { 11853, 31, 25, 38, 4, -47 },
  { 11950, 32, 9, 38, -1, 2 },
  { 11986, 15, 9, 38, 15, -50 },
  { 12003, 35, 37, 38, 2, -36 },
  { 12165, 35, 48, 38, 1, -47 },
  { 12375, 34, 37, 38, 2, -36 },
  { 12533, 37, 48, 38, 2, -47 },
  { 12755, 34, 37, 38, 2, -36 },
  { 12913, 44, 59, 38, -4, -47 },
  { 13238, 35, 48, 38, 2, -36 },
  { 13448, 35, 47, 38, 1, -47 },
  { 13654, 32, 51, 38, 2, -51 },
  { 13858, 36, 63, 38, 0, -51 },
  { 14142, 38, 47, 38, 2, -47 },
  { 14366, 30, 47, 38, 5, -47 },
  { 14543, 38, 36, 38, 0, -36 },
  { 14714, 35, 36, 38, 1, -36 },
  { 14872, 34, 37, 38, 2, -36 },
  { 15030, 36, 48, 38, 0, -36 },
  { 15246, 35, 48, 38, 2, -36 },
  { 15456, 36, 36, 38, 2, -36 },
  { 15618, 36, 37, 38, 1, -36 },
  { 15785, 33, 45, 38, 4, -45 },
  { 15971, 35, 36, 38, 2, -35 },
  { 16129, 35, 35, 38, 4, -35 },
  { 16283, 38, 35, 38, 3, -35 },
  { 16450, 40, 35, 38, -1, -35 },
  { 16625, 34, 47, 38, 2, -35 },
  { 16825, 34, 35, 38, 2, -35 },
  { 16974, 34, 60, 38, 5, -53 },
  { 17229, 20, 60, 38, 10, -53 },
  { 17379, 34, 60, 38, 1, -53 },
  { 17634, 36, 17, 38, 2, -31 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC64PT7B_H_
