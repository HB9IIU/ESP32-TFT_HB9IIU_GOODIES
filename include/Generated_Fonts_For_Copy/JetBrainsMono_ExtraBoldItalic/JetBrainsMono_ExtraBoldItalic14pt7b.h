#ifndef _JETBRAINSMONO_EXTRABOLDITALIC14PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x26, 0x60, 0x6E, 0xEF, 0x3D, 0xB6, 0x19, 0x0D, 0x9F,
  0xEF, 0xF3, 0x61, 0x33, 0xFD, 0xFC, 0x4C, 0x64, 0x00, 0x04, 0x04, 0x1F,
  0x3F, 0x6B, 0x78, 0x3E, 0x1E, 0x0F, 0xF7, 0x7E, 0x7C, 0x10, 0x10, 0x3C,
  0x64, 0x90, 0x94, 0x1D, 0x00, 0x40, 0x1E, 0x07, 0xE1, 0xA4, 0x65, 0x98,
  0xE0, 0x1E, 0x37, 0x30, 0x30, 0x78, 0x7B, 0xCE, 0xCE, 0xFE, 0x7F, 0xFF,
  0x04, 0x73, 0x9C, 0x61, 0x8E, 0x30, 0xC3, 0x0E, 0x1C, 0x70, 0x40, 0x20,
  0xC3, 0x87, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x3C, 0xE2, 0x00, 0x18, 0x32,
  0x4F, 0xF1, 0x0F, 0x33, 0x24, 0x18, 0x33, 0xFF, 0xF3, 0x06, 0x0C, 0x00,
  0x36, 0x6C, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x00, 0x3E, 0xDF,
  0x1E, 0x3F, 0x7A, 0xF1, 0x66, 0xFD, 0xF0, 0x1E, 0x3E, 0x2C, 0x4C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x7F, 0xFE, 0x1F, 0x3F, 0x63, 0x03, 0x06, 0x0C, 0x38,
  0x70, 0x7E, 0xFE, 0x3F, 0x3F, 0x0E, 0x1C, 0x1E, 0x07, 0x06, 0x66, 0x7E,
  0x7C, 0x07, 0x0E, 0x1C, 0x38, 0x33, 0x66, 0x7E, 0xFE, 0x06, 0x06, 0x3F,
  0x3F, 0x30, 0x3C, 0x7E, 0x07, 0x06, 0x66, 0x7E, 0x7C, 0x0E, 0x0C, 0x18,
  0x30, 0x7E, 0x67, 0x63, 0xE6, 0x7E, 0x7C, 0x7F, 0xFE, 0xC6, 0x0C, 0x0C,
  0x18, 0x38, 0x30, 0x60, 0xE0, 0x1F, 0x37, 0x73, 0x37, 0x3E, 0x3E, 0x67,
  0xE6, 0x7E, 0x7C, 0x3E, 0xCF, 0x1E, 0x3F, 0xEF, 0x87, 0x0C, 0x30, 0xC0,
  0x37, 0x20, 0x00, 0xEE, 0x19, 0xC4, 0x00, 0x00, 0xCC, 0x66, 0x00, 0x02,
  0x0C, 0xFF, 0x8C, 0x1E, 0x0F, 0x06, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x40,
  0x30, 0x7C, 0x0F, 0x07, 0x1E, 0x78, 0xC0, 0xFB, 0xF0, 0xC7, 0x79, 0xCC,
  0x00, 0xC3, 0x00, 0x1F, 0x19, 0xD8, 0x69, 0xB5, 0xB6, 0xCB, 0x6D, 0xB6,
  0xDF, 0x60, 0x30, 0x0F, 0x01, 0x80, 0x0E, 0x3C, 0x79, 0xB3, 0x66, 0xDF,
  0xBF, 0xC7, 0x8C, 0x3F, 0x37, 0x33, 0x63, 0x7C, 0x7E, 0x63, 0x67, 0x7E,
  0xFC, 0x3E, 0xFF, 0x9E, 0x0C, 0x18, 0x30, 0x67, 0xFD, 0xF0, 0x3E, 0x3F,
  0x73, 0x63, 0x63, 0x63, 0x63, 0x66, 0x7E, 0xFC, 0x3F, 0x3F, 0x30, 0x30,
  0x7E, 0x7E, 0x60, 0x60, 0x7E, 0xFE, 0x3F, 0x9F, 0x8C, 0x0C, 0x07, 0xF3,
  0xF1, 0x80, 0xC0, 0x60, 0x70, 0x00, 0x3E, 0xFF, 0x9E, 0x0D, 0xFB, 0xF1,
  0xE6, 0xFD, 0xF0, 0x33, 0x33, 0x33, 0x63, 0x7F, 0x7F, 0x66, 0x66, 0x66,
  0xC6, 0x3F, 0x3F, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x7E, 0xFE, 0x0F,
  0x0F, 0x03, 0x03, 0x07, 0x06, 0x06, 0xC6, 0xFE, 0x7C, 0x33, 0x99, 0x9D,
  0x8D, 0xC7, 0xC3, 0xE1, 0xB0, 0xCC, 0x66, 0x63, 0x00, 0x61, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xFF, 0xF0, 0x73, 0xB9, 0xDD, 0x4E, 0xE7, 0xF3, 0xD9,
  0x0D, 0x86, 0xC2, 0x63, 0x00, 0x31, 0x9D, 0x9E, 0xCF, 0x66, 0xB3, 0x59,
  0xA8, 0x9C, 0xCE, 0x67, 0x00, 0x3E, 0xFF, 0x9E, 0x3C, 0x78, 0xF3, 0x66,
  0xFD, 0xF0, 0x3F, 0x1F, 0x8C, 0xEC, 0x67, 0xF3, 0xF1, 0x80, 0xC0, 0x60,
  0x60, 0x00, 0x3E, 0xFF, 0x9E, 0x3C, 0x78, 0xF3, 0x66, 0xFD, 0xF0, 0x60,
  0xC0, 0xC0, 0x3F, 0x3F, 0x73, 0x63, 0x7F, 0x7E, 0x6C, 0x6C, 0x66, 0xC6,
  0x1F, 0x37, 0x63, 0x70, 0x3C, 0x1E, 0x07, 0xE7, 0x7E, 0x7C, 0xFF, 0xFF,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x33, 0x99, 0x9C, 0xCC,
  0x66, 0x33, 0x19, 0x9C, 0xCC, 0x7E, 0x3E, 0x00, 0xE3, 0x66, 0x66, 0x66,
  0x6C, 0x6C, 0x78, 0x78, 0x78, 0x70, 0x6D, 0xB6, 0xDB, 0x6E, 0xA5, 0x72,
  0xB9, 0x5C, 0xCC, 0x66, 0x77, 0x00, 0x73, 0x99, 0x8F, 0x83, 0x81, 0xC0,
  0xE0, 0xF0, 0xFC, 0x66, 0x63, 0x80, 0xE3, 0x66, 0x6E, 0x6C, 0x38, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x3F, 0x3F, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x70,
  0x7E, 0xFE, 0x3D, 0xF6, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xF3,
  0xC0, 0xC6, 0x30, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63, 0x8C, 0x3C, 0xF0,
  0xC3, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x8C, 0xF3, 0xC0, 0x18, 0x78, 0xB3,
  0x6C, 0x60, 0xFF, 0xFC, 0xE7, 0x1B, 0x3F, 0x67, 0x67, 0x66, 0x66, 0x7E,
  0x76, 0x30, 0x30, 0x3E, 0x7F, 0x63, 0x63, 0x66, 0x66, 0x7E, 0xDC, 0x3C,
  0xFF, 0x1E, 0x0C, 0x19, 0xBF, 0x7C, 0x03, 0x03, 0x1B, 0x3F, 0x67, 0x67,
  0x66, 0x66, 0x7E, 0x76, 0x38, 0xFB, 0x1F, 0xFF, 0xD8, 0x37, 0x7C, 0x07,
  0xC1, 0xE0, 0xC0, 0xFE, 0x3F, 0x83, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x83, 0xC0, 0xC0, 0x00, 0x36, 0xFF, 0x3E, 0x7C, 0xD9, 0xBF, 0x36, 0x1D,
  0xF3, 0x00, 0x30, 0x30, 0x3E, 0x7F, 0x67, 0x63, 0x66, 0x66, 0x66, 0xC6,
  0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x0C, 0x0C, 0x0C, 0x18, 0x7F, 0xFE, 0x07,
  0x07, 0x00, 0x3E, 0x3E, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0xF8,
  0xE0, 0x30, 0x18, 0x0C, 0xEC, 0xE6, 0x63, 0xE1, 0xF0, 0xD8, 0x66, 0x73,
  0x00, 0xF9, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3E, 0x78, 0x7B, 0x7F,
  0x6B, 0x4B, 0x5B, 0xDB, 0xDA, 0xD6, 0x7E, 0x7F, 0x67, 0x63, 0x66, 0x66,
  0x66, 0xC6, 0x38, 0xFB, 0x1E, 0x3C, 0xD9, 0xBF, 0x7C, 0x7E, 0x7F, 0x63,
  0x63, 0x66, 0x66, 0x7E, 0xDC, 0xC0, 0xC0, 0xC0, 0x1B, 0x3F, 0x67, 0x67,
  0x66, 0x66, 0x7E, 0x76, 0x06, 0x06, 0x0C, 0x6C, 0xFF, 0x9E, 0x3C, 0x18,
  0x30, 0x60, 0x1E, 0x3F, 0x60, 0x7C, 0x3E, 0x06, 0xFE, 0x7C, 0x38, 0x63,
  0xFF, 0xF3, 0x06, 0x1C, 0x30, 0x7C, 0x78, 0xE7, 0x8F, 0x1E, 0x7C, 0xD9,
  0xBF, 0x7C, 0xC7, 0xC6, 0xCE, 0x6C, 0x6C, 0x78, 0x78, 0x70, 0x9B, 0x9A,
  0xAA, 0xAE, 0xBE, 0xD4, 0xDC, 0xDC, 0x73, 0x36, 0x3E, 0x1C, 0x1C, 0x3C,
  0x6E, 0xE6, 0xE7, 0x8F, 0x1E, 0x6C, 0xDB, 0xBF, 0x06, 0x1D, 0xF3, 0x00,
  0x3F, 0x7F, 0x06, 0x0C, 0x38, 0x70, 0x7E, 0xFE, 0x07, 0x0E, 0x0C, 0x1C,
  0x18, 0x18, 0xF8, 0xF8, 0x18, 0x18, 0x30, 0x38, 0x3C, 0x08, 0x33, 0x33,
  0x33, 0x76, 0x66, 0x66, 0xEC, 0x30, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x1F,
  0x1E, 0x38, 0x30, 0x30, 0x30, 0xF0, 0xC0, 0x30, 0x7B, 0x4F, 0x8E,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 6, 4, 8, 2, -10 },
  { 9, 9, 10, 8, 0, -10 },
  { 21, 8, 14, 8, 0, -12 },
  { 35, 11, 10, 8, -1, -10 },
  { 49, 8, 10, 8, 0, -10 },
  { 59, 2, 4, 8, 4, -10 },
  { 60, 6, 14, 8, 2, -12 },
  { 71, 6, 14, 8, 1, -12 },
  { 82, 7, 8, 8, 1, -9 },
  { 89, 7, 7, 8, 1, -8 },
  { 96, 4, 4, 8, 1, -2 },
  { 98, 5, 2, 8, 2, -6 },
  { 100, 3, 3, 8, 2, -3 },
  { 102, 9, 14, 8, 0, -12 },
  { 118, 7, 10, 8, 1, -10 },
  { 127, 8, 10, 8, 0, -10 },
  { 137, 8, 10, 8, 0, -10 },
  { 147, 8, 10, 8, 0, -10 },
  { 157, 8, 10, 8, 0, -10 },
  { 167, 8, 10, 8, 0, -10 },
  { 177, 8, 10, 8, 0, -10 },
  { 187, 8, 10, 8, 1, -10 },
  { 197, 8, 10, 8, 0, -10 },
  { 207, 7, 10, 8, 1, -10 },
  { 216, 4, 8, 8, 2, -8 },
  { 220, 5, 10, 8, 1, -8 },
  { 227, 7, 8, 8, 1, -9 },
  { 234, 7, 5, 8, 1, -7 },
  { 239, 8, 8, 8, 0, -9 },
  { 247, 6, 10, 8, 2, -10 },
  { 255, 9, 13, 8, 0, -10 },
  { 270, 7, 10, 8, 0, -10 },
  { 279, 8, 10, 8, 0, -10 },
  { 289, 7, 10, 8, 1, -10 },
  { 298, 8, 10, 8, 0, -10 },
  { 308, 8, 10, 8, 0, -10 },
  { 318, 9, 10, 8, 0, -10 },
  { 330, 7, 10, 8, 1, -10 },
  { 339, 8, 10, 8, 0, -10 },
  { 349, 8, 10, 8, 0, -10 },
  { 359, 8, 10, 8, 0, -10 },
  { 369, 9, 10, 8, 0, -10 },
  { 381, 6, 10, 8, 1, -10 },
  { 389, 9, 10, 8, 0, -10 },
  { 401, 9, 10, 8, 0, -10 },
  { 413, 7, 10, 8, 1, -10 },
  { 422, 9, 10, 8, 0, -10 },
  { 434, 7, 13, 8, 1, -10 },
  { 446, 8, 10, 8, 0, -10 },
  { 456, 8, 10, 8, 0, -10 },
  { 466, 8, 10, 8, 1, -10 },
  { 476, 9, 10, 8, 0, -10 },
  { 488, 8, 10, 8, 1, -10 },
  { 498, 9, 10, 8, 0, -10 },
  { 510, 9, 10, 8, 0, -10 },
  { 522, 8, 10, 8, 1, -10 },
  { 532, 8, 10, 8, 0, -10 },
  { 542, 6, 14, 8, 2, -12 },
  { 553, 5, 14, 8, 2, -12 },
  { 562, 6, 14, 8, 1, -12 },
  { 573, 7, 5, 8, 1, -10 },
  { 578, 7, 2, 8, 0, 0 },
  { 580, 4, 2, 8, 3, -11 },
  { 581, 8, 8, 8, 0, -8 },
  { 589, 8, 10, 8, 0, -10 },
  { 599, 7, 8, 8, 1, -8 },
  { 606, 8, 10, 8, 0, -10 },
  { 616, 7, 8, 8, 1, -8 },
  { 623, 10, 13, 8, -1, -10 },
  { 640, 7, 11, 8, 1, -8 },
  { 650, 8, 10, 8, 0, -10 },
  { 660, 8, 11, 8, 0, -11 },
  { 671, 8, 14, 8, 0, -11 },
  { 685, 9, 10, 8, 0, -10 },
  { 697, 7, 10, 8, 1, -10 },
  { 706, 8, 8, 8, 0, -8 },
  { 714, 8, 8, 8, 0, -8 },
  { 722, 7, 8, 8, 1, -8 },
  { 729, 8, 11, 8, 0, -8 },
  { 740, 8, 11, 8, 0, -8 },
  { 751, 7, 8, 8, 1, -8 },
  { 758, 8, 8, 8, 0, -8 },
  { 766, 7, 10, 8, 1, -10 },
  { 775, 7, 8, 8, 1, -8 },
  { 782, 8, 8, 8, 1, -8 },
  { 790, 8, 8, 8, 1, -8 },
  { 798, 8, 8, 8, 0, -8 },
  { 806, 7, 11, 8, 1, -8 },
  { 816, 8, 8, 8, 0, -8 },
  { 824, 8, 14, 8, 1, -12 },
  { 838, 4, 14, 8, 2, -12 },
  { 845, 8, 14, 8, 0, -12 },
  { 859, 8, 4, 8, 0, -7 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC14PT7B_H_
