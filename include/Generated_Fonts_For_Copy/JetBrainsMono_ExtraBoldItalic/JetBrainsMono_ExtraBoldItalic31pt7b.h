#ifndef _JETBRAINSMONO_EXTRABOLDITALIC31PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87,
  0xC7, 0xE1, 0xE0, 0x78, 0xFF, 0x8F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1F,
  0xF1, 0xEF, 0x1E, 0xF1, 0xEE, 0x1E, 0x00, 0xF1, 0xE0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0xF1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF1,
  0xE0, 0x1C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF0, 0xF1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0xC0,
  0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0x6F, 0x9F, 0x37, 0xCF, 0xB0,
  0x07, 0xD8, 0x03, 0xEC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x6F, 0xC0, 0x33, 0xE0, 0x19, 0xF7, 0xCC, 0xFB,
  0xE6, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x0E, 0x0F, 0xE0,
  0x38, 0x1F, 0xE0, 0xE0, 0x71, 0xC3, 0xC0, 0xE3, 0x8F, 0x01, 0xC7, 0x1C,
  0x03, 0x8E, 0x70, 0x0F, 0x3D, 0xC0, 0x0F, 0xF7, 0x00, 0x1F, 0xDC, 0x00,
  0x04, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0xFC, 0x00,
  0x3B, 0xF8, 0x00, 0xEF, 0x78, 0x03, 0x9C, 0x70, 0x0E, 0x78, 0xE0, 0x38,
  0xE1, 0xC0, 0xF1, 0xC7, 0x03, 0xC3, 0xFE, 0x0F, 0x03, 0xF8, 0x3C, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x07,
  0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE7, 0xDF, 0x7D, 0xE7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0x7E, 0x1E, 0x1F, 0x8F, 0x87, 0xC1, 0xF7, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0xF8, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0xBC,
  0xF3, 0xC0, 0x00, 0x0C, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01,
  0xFC, 0x03, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x87,
  0xF8, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x03, 0x0E, 0x1B, 0xE6, 0x3D, 0xFB, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFC, 0x01, 0xE0, 0x01, 0xDC, 0x01, 0xEF, 0x01, 0xE7, 0x81,
  0xF3, 0xE1, 0xF0, 0xF0, 0x30, 0x60, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFB, 0xFF, 0xEF, 0xCF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9,
  0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x47, 0xDF, 0x7B,
  0xCF, 0xFD, 0xE7, 0xDE, 0xF3, 0xC6, 0x79, 0xE0, 0x7C, 0xF0, 0x3E, 0xF8,
  0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1E, 0x78, 0x1C, 0xF8, 0x30, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF1, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC7, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xC0, 0xF1, 0xE0, 0x79, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x78, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x78,
  0x3E, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xC0, 0xF9, 0xE0, 0x7D, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1,
  0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x0F, 0xDF,
  0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xF0, 0xF8, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C,
  0x0F, 0x9F, 0x9F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0, 0xFB, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x1F, 0x8F, 0xC7, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0,
  0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x3F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC0, 0x10, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0x87, 0xFF, 0x1F, 0xFE,
  0x7F, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE3, 0xF1, 0xF0, 0x1E, 0x3C, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x7D, 0xE7, 0x1F, 0xDD, 0xE3, 0xCF,
  0xBC, 0xF1, 0xE7, 0x9E, 0x1C, 0xF3, 0xC7, 0x9C, 0x78, 0xF3, 0x8E, 0x1E,
  0xF3, 0xC3, 0xDE, 0x78, 0x73, 0xCF, 0x9E, 0x78, 0xFD, 0xCF, 0x1F, 0x79,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xEF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF8, 0x7C,
  0x7C, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0x81, 0xE7,
  0xC0, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1E, 0x1F, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07,
  0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0x78, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0xC3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x8F, 0x83, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F,
  0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7,
  0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x78, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x09, 0xF3, 0xFC, 0x7C, 0xFF, 0x1F, 0x3F, 0xC7,
  0xCF, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0xC3, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC0,
  0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0xC3, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x7C, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1D, 0x8F, 0xE1, 0xD8, 0xFE, 0x1D, 0x9D, 0xE3, 0xDD,
  0xDC, 0x3D, 0xDB, 0xC3, 0xDF, 0xBC, 0x3D, 0xFB, 0xC3, 0xDF, 0x3C, 0x3D,
  0xF7, 0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xE1, 0xF8, 0x3C, 0x3F, 0x07, 0x87, 0xE1,
  0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3,
  0xC3, 0xDC, 0xF8, 0xFB, 0x9E, 0x1E, 0x73, 0xC3, 0xCF, 0x78, 0x79, 0xEF,
  0x0F, 0x1D, 0xE1, 0xE3, 0xBC, 0x3C, 0x77, 0x0F, 0x0F, 0xE1, 0xE1, 0xFC,
  0x3C, 0x3F, 0x87, 0x83, 0xF0, 0xF0, 0x7E, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0xDF, 0x03, 0xCF, 0x81, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x03, 0xE3, 0xC3, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1,
  0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x9E, 0x07,
  0xDF, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF8, 0x1E, 0x7C, 0x1F, 0x3F, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1E, 0x3F, 0x8F, 0x83, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E,
  0x0F, 0x8F, 0x03, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xCF, 0x01, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x8F, 0x03, 0xE0, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x1F, 0x8F, 0x83, 0xE3, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x3E,
  0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x8F, 0x03,
  0xE7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xE0, 0x7C, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0xC3, 0xE1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xDF, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xEF, 0x81,
  0xF7, 0x80, 0xFB, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x70, 0xF7, 0x8F, 0x1E,
  0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x9F, 0x3C, 0x79, 0xB3,
  0xC7, 0x9B, 0x3C, 0x7B, 0xB3, 0x87, 0xBB, 0x38, 0x73, 0x37, 0x87, 0x37,
  0x78, 0x77, 0x77, 0x07, 0x67, 0x70, 0x76, 0x7F, 0x07, 0x67, 0xF0, 0xFE,
  0x6E, 0x0F, 0xC6, 0xE0, 0xFC, 0x6E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xDE, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF8,
  0x3E, 0x07, 0xC3, 0xF0, 0x3F, 0x00, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xCF, 0x03, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0x79, 0xF0, 0x3C,
  0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x8F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0xF8,
  0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x1E, 0x3E, 0x3C, 0x78,
  0x79, 0xF0, 0xFF, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x07, 0xEF, 0x8F, 0xF7, 0xC7, 0xFF, 0xC7,
  0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0x78, 0x3F, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFB, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0x87, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x1E, 0x3C, 0x1F, 0x3F, 0x0F, 0x9F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xBF, 0xC3, 0xCF, 0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x79, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x5F, 0x03, 0xCF, 0xC3, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0xF8,
  0x7F, 0xBE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xEF, 0x03, 0xF3, 0xC0,
  0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F,
  0x7C, 0x0F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0x8F, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3,
  0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F,
  0x1E, 0x0F, 0x8F, 0x8F, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFE, 0xF8, 0x3E,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF0, 0x3C, 0x00, 0x10, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x1F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xC3, 0xE0, 0xF1,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x78, 0xF8,
  0x1E, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x1D, 0xE7,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xF3,
  0xCE, 0x3D, 0xE3, 0x9F, 0x78, 0xE7, 0x9E, 0x39, 0xE7, 0x9E, 0x79, 0xE7,
  0x1E, 0x79, 0xC7, 0xBE, 0x71, 0xEF, 0x1C, 0xF3, 0xC7, 0x3C, 0xF3, 0xCF,
  0x00, 0x3E, 0xFC, 0x3F, 0xFE, 0x3D, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x3C, 0x03,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFC,
  0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x1F, 0x7E, 0x07,
  0xFF, 0xC1, 0xEF, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C,
  0x7E, 0x1F, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xEF, 0xF0, 0x79, 0xF8, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xEF, 0x8F, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xE1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x3E, 0x07,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0x78, 0x3F,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x1E, 0x7E, 0x07, 0xBF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xE3, 0xE3, 0xC0, 0xF1, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xEF, 0x81, 0xE7, 0xE3, 0xF3, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE3, 0xC0,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x07, 0xC7, 0xC3, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7,
  0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C,
  0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0x70, 0xE1, 0xEE, 0x3C, 0x39, 0xC7, 0x8F, 0x38,
  0xF1, 0xE7, 0x1E, 0x38, 0xE6, 0xCF, 0x1C, 0xD9, 0xE3, 0x9B, 0x38, 0x77,
  0x6F, 0x1E, 0xCD, 0xE3, 0xD9, 0xB8, 0x7F, 0x37, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xF0,
  0xF8, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE0,
  0xF8, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x1E, 0x3C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x8F, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFE, 0xF0,
  0x1C, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xC3, 0xDF, 0xF1, 0xEF, 0xFC,
  0xF7, 0x1F, 0xFF, 0x8F, 0xFB, 0xC3, 0xF8, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 23, 19, 5, -23 },
  { 27, 12, 10, 19, 5, -23 },
  { 42, 19, 23, 19, 0, -23 },
  { 97, 17, 31, 19, 1, -27 },
  { 163, 23, 23, 19, -2, -23 },
  { 230, 18, 23, 19, 0, -23 },
  { 282, 6, 10, 19, 8, -23 },
  { 290, 14, 30, 19, 4, -26 },
  { 343, 13, 30, 19, 2, -26 },
  { 392, 17, 16, 19, 1, -19 },
  { 426, 15, 15, 19, 2, -18 },
  { 455, 10, 10, 19, 2, -5 },
  { 468, 11, 4, 19, 4, -12 },
  { 474, 7, 6, 19, 5, -6 },
  { 480, 20, 29, 19, 0, -26 },
  { 553, 17, 23, 19, 1, -23 },
  { 602, 16, 23, 19, 1, -23 },
  { 648, 17, 23, 19, 1, -23 },
  { 697, 17, 23, 19, 1, -23 },
  { 746, 17, 23, 19, 1, -23 },
  { 795, 17, 23, 19, 1, -23 },
  { 844, 16, 23, 19, 1, -23 },
  { 890, 17, 23, 19, 2, -23 },
  { 939, 17, 23, 19, 1, -23 },
  { 988, 17, 23, 19, 2, -23 },
  { 1037, 9, 17, 19, 5, -17 },
  { 1057, 12, 22, 19, 2, -17 },
  { 1090, 16, 17, 19, 2, -19 },
  { 1124, 15, 12, 19, 2, -16 },
  { 1147, 16, 17, 19, 1, -19 },
  { 1181, 14, 23, 19, 4, -23 },
  { 1222, 19, 29, 19, 0, -23 },
  { 1291, 17, 23, 19, -1, -23 },
  { 1340, 18, 23, 19, 1, -23 },
  { 1392, 18, 23, 19, 1, -23 },
  { 1444, 18, 23, 19, 1, -23 },
  { 1496, 18, 23, 19, 1, -23 },
  { 1548, 18, 23, 19, 1, -23 },
  { 1600, 18, 23, 19, 1, -23 },
  { 1652, 18, 23, 19, 1, -23 },
  { 1704, 17, 23, 19, 1, -23 },
  { 1753, 18, 23, 19, 0, -23 },
  { 1805, 19, 23, 19, 1, -23 },
  { 1860, 14, 23, 19, 2, -23 },
  { 1901, 20, 23, 19, 0, -23 },
  { 1959, 19, 23, 19, 0, -23 },
  { 2014, 17, 23, 19, 1, -23 },
  { 2063, 18, 23, 19, 1, -23 },
  { 2115, 17, 29, 19, 1, -23 },
  { 2177, 18, 23, 19, 1, -23 },
  { 2229, 18, 23, 19, 1, -23 },
  { 2281, 17, 23, 19, 3, -23 },
  { 2330, 18, 23, 19, 1, -23 },
  { 2382, 17, 23, 19, 3, -23 },
  { 2431, 20, 23, 19, 1, -23 },
  { 2489, 21, 23, 19, -1, -23 },
  { 2550, 17, 23, 19, 3, -23 },
  { 2599, 17, 23, 19, 1, -23 },
  { 2648, 14, 29, 19, 3, -26 },
  { 2699, 11, 29, 19, 4, -26 },
  { 2739, 14, 29, 19, 2, -26 },
  { 2790, 15, 12, 19, 2, -23 },
  { 2813, 15, 4, 19, 0, 1 },
  { 2821, 8, 4, 19, 7, -24 },
  { 2825, 17, 17, 19, 1, -17 },
  { 2862, 17, 23, 19, 1, -23 },
  { 2911, 17, 17, 19, 1, -17 },
  { 2948, 18, 23, 19, 1, -23 },
  { 3000, 16, 17, 19, 1, -17 },
  { 3034, 21, 29, 19, -2, -23 },
  { 3111, 17, 23, 19, 1, -17 },
  { 3160, 16, 23, 19, 1, -23 },
  { 3206, 16, 25, 19, 1, -25 },
  { 3256, 17, 31, 19, 0, -25 },
  { 3322, 18, 23, 19, 1, -23 },
  { 3374, 15, 23, 19, 2, -23 },
  { 3418, 18, 17, 19, 0, -17 },
  { 3457, 16, 17, 19, 1, -17 },
  { 3491, 16, 17, 19, 1, -17 },
  { 3525, 18, 23, 19, 0, -17 },
  { 3577, 17, 23, 19, 1, -17 },
  { 3626, 18, 17, 19, 1, -17 },
  { 3665, 17, 17, 19, 1, -17 },
  { 3702, 16, 22, 19, 2, -22 },
  { 3746, 17, 17, 19, 1, -17 },
  { 3783, 17, 17, 19, 2, -17 },
  { 3820, 19, 17, 19, 1, -17 },
  { 3861, 20, 17, 19, -1, -17 },
  { 3904, 17, 23, 19, 1, -17 },
  { 3953, 16, 17, 19, 1, -17 },
  { 3987, 17, 29, 19, 2, -26 },
  { 4049, 9, 29, 19, 5, -26 },
  { 4082, 17, 29, 19, 0, -26 },
  { 4144, 17, 8, 19, 1, -15 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC31PT7B_H_
