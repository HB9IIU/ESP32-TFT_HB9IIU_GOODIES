#ifndef _JETBRAINSMONO_EXTRABOLDITALIC33PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF0, 0x7C, 0x7D, 0xF3, 0xE7, 0x8F, 0xBE, 0x3E, 0xF8,
  0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xC0, 0x00, 0x70,
  0xF0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x1E, 0x1C, 0x00,
  0xE0, 0xE4, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1C, 0x3C,
  0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x00, 0x38,
  0x38, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0x0F, 0x00,
  0x78, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x1E,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xEE,
  0xF8, 0xF9, 0x9F, 0x1F, 0x30, 0x03, 0xE6, 0x00, 0x7E, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0x0D, 0xF8, 0x03, 0x9F, 0x3E, 0x63, 0xE7, 0xCC, 0xFC, 0xFD, 0xBF,
  0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF0,
  0x07, 0x83, 0xFC, 0x07, 0x01, 0xFF, 0x07, 0x01, 0xE3, 0x87, 0x80, 0xE1,
  0xC7, 0x80, 0x71, 0xE7, 0x80, 0x38, 0xF7, 0x80, 0x1C, 0x73, 0x80, 0x0F,
  0xFB, 0x80, 0x07, 0xFB, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xDF, 0xC0, 0x03, 0xDF, 0xF0,
  0x01, 0xDE, 0x38, 0x01, 0xCE, 0x1C, 0x01, 0xC7, 0x0E, 0x01, 0xE3, 0x8F,
  0x01, 0xE1, 0xC7, 0x81, 0xE0, 0xFF, 0x81, 0xE0, 0x7F, 0x81, 0xE0, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x78,
  0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x3E, 0xFB, 0xE7, 0x9F, 0x3F,
  0xF3, 0xE7, 0xFC, 0x7C, 0x7F, 0x8F, 0x0F, 0xE1, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x3E, 0x7D, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBC, 0xF3, 0xC0, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x04, 0x00, 0x1C, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x30,
  0xF0, 0xCF, 0x38, 0xF7, 0xEE, 0xFF, 0xFD, 0x7F, 0x3F, 0xFF, 0x80, 0x38,
  0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x1F, 0x7C, 0x07, 0x8F, 0x87, 0xE3, 0xE0,
  0xF0, 0xF0, 0x18, 0x18, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x01, 0xF3, 0xDE, 0x7D, 0xF7, 0xDE, 0x7D, 0xF7, 0x9F, 0x3B, 0xE7, 0xC0,
  0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xCF, 0x81, 0xF1, 0xF0, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7E, 0x00,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0x71, 0xF0,
  0x30, 0xF8, 0x20, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x07, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x8F, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBE, 0x07, 0xCF, 0x81,
  0xF3, 0xF0, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0xF8, 0xFC, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x38, 0x0F, 0xBF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xCF, 0x81,
  0xF3, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xDE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x1F, 0x0F, 0x87, 0xE7, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xE1, 0xF1, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x81, 0xF3, 0xF0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x7D, 0xE0, 0x1E, 0x78, 0x0F, 0x9F,
  0x03, 0xE7, 0xE3, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xEF, 0x80, 0x67,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x10, 0x00, 0x0E, 0x00, 0x07,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x81, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x7E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x1F, 0x78, 0x78, 0xFF, 0xE3, 0xC7,
  0xFF, 0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F,
  0x0F, 0x3C, 0x3C, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1F, 0x1E,
  0x3F, 0xF8, 0x78, 0xFE, 0xE1, 0xE1, 0xF7, 0x87, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F,
  0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x03, 0xE3, 0xC0, 0x7C,
  0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x00,
  0xF7, 0xE0, 0x1F, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F,
  0x87, 0xC7, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x7E,
  0x7C, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x81, 0xF3, 0xF0, 0x7C, 0x3E, 0x1F, 0x87,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x3F, 0xE7, 0xC7, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x7C, 0x3E, 0x1F, 0x87,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0x83, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E,
  0x3E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3B, 0xC3, 0xF9, 0xDE, 0x3D, 0xDD, 0xE1,
  0xE6, 0xEF, 0x0F, 0x37, 0x78, 0x79, 0xF3, 0xC3, 0xCF, 0xBE, 0x1E, 0x79,
  0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1E,
  0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xE3, 0xF0, 0x3C, 0x7F, 0x0F, 0x8F, 0xE1,
  0xF1, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0x70, 0xF1, 0xEE, 0x1E, 0x3D, 0xE7,
  0xC7, 0xBC, 0xF8, 0xF7, 0x9F, 0x1E, 0xF3, 0xC7, 0xCE, 0x78, 0xF9, 0xCF,
  0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78, 0xF7, 0x8F, 0x0F, 0xE3, 0xE1, 0xFC,
  0x7C, 0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0xFE, 0x3C, 0x1F, 0xC7, 0x81, 0xF0,
  0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xC7,
  0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x07, 0xCF, 0xC1, 0xF1, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0xFE, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xCF, 0xC1, 0xF1, 0xF0, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0xFC, 0x3E,
  0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xE3,
  0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x78,
  0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3C, 0x78, 0x79, 0xE3, 0xC7, 0x8E, 0x1E, 0x3C, 0xF1, 0xF1,
  0xE7, 0x8D, 0x8F, 0x3C, 0x6C, 0xF1, 0xE3, 0xE7, 0x8F, 0x3F, 0x3C, 0x79,
  0xB9, 0xE3, 0xCD, 0xCE, 0x1E, 0xEE, 0xF0, 0xF7, 0x77, 0x87, 0xB3, 0xBC,
  0x3D, 0x99, 0xC1, 0xDC, 0xDE, 0x0E, 0xE6, 0xF0, 0x76, 0x37, 0x83, 0xB1,
  0xB8, 0x3F, 0x8D, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03,
  0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0xF8,
  0x07, 0xFF, 0x01, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7B,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0xBC, 0x0F,
  0x3C, 0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1F, 0x7C, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1F, 0x07, 0xE7, 0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3E,
  0x1F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7, 0xFF, 0xF1,
  0xFF, 0x7C, 0x7F, 0xDE, 0x0F, 0xEF, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE7, 0xE0, 0xFB,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xC7,
  0xC1, 0xF3, 0xF0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xBF, 0xC3, 0xEF,
  0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F,
  0x8F, 0x83, 0xE7, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x02, 0xFC, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x81, 0xF9, 0xF0, 0x7F,
  0xBE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xBE, 0x1F, 0xF7,
  0x81, 0xFD, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7C, 0x7E,
  0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x07, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xC3, 0xFD, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3E, 0x1F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7E, 0x7F,
  0x1F, 0xFF, 0xC7, 0xFD, 0xF0, 0xFF, 0x7C, 0x1F, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE7, 0xE0, 0xFB, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC1, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F,
  0xC7, 0xC3, 0xF0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xFC,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x83, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFE,
  0x1E, 0xF3, 0xE1, 0xDF, 0x7E, 0x3F, 0xFF, 0xE3, 0xE7, 0x9E, 0x3C, 0x71,
  0xE3, 0xC7, 0x1E, 0x3C, 0x71, 0xE3, 0xCF, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF,
  0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x7C, 0xF9,
  0xE7, 0xCF, 0x9E, 0x78, 0xF1, 0xC7, 0x8F, 0x1C, 0x78, 0x3E, 0x7E, 0x0F,
  0xBF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E,
  0x0F, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E,
  0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0xFC, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0x3F, 0x03, 0xEF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7D, 0xFE, 0x0F,
  0xBF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE7, 0xC3, 0xFD, 0xF1, 0xFF, 0x7C, 0xFF,
  0xFE, 0x3E, 0x1F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7,
  0xFF, 0xF1, 0xFF, 0x7C, 0x7F, 0xDE, 0x0F, 0xEF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x7F,
  0x03, 0xDF, 0xF0, 0x7B, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFE, 0x7F, 0x3E, 0x07, 0xCF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBE, 0x07,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x07, 0xDF, 0x03, 0xF7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E, 0x7C,
  0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF1, 0xE1, 0xFE,
  0x3C, 0x3B, 0xC7, 0x8F, 0x79, 0xF1, 0xEF, 0x36, 0x39, 0xE6, 0xCF, 0x39,
  0xD9, 0xE7, 0x3B, 0x3C, 0xE6, 0x6F, 0x1C, 0xCD, 0xE3, 0xB9, 0xBC, 0x76,
  0x37, 0x0E, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xC7, 0xE0, 0xF8,
  0xFC, 0x1F, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x3E, 0x1F, 0x81, 0xF1, 0xF8,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F,
  0xC7, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFD, 0xF0, 0xFE, 0x78, 0x06, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x0F, 0xF0, 0xF3, 0xFE, 0x3D, 0xFF, 0x8F, 0x79, 0xF3, 0xDC, 0x3F, 0xEF,
  0x0F, 0xFB, 0xC1, 0xFC, 0x00, 0x08, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 6, -24 },
  { 28, 14, 10, 20, 5, -24 },
  { 46, 21, 24, 20, 0, -24 },
  { 109, 19, 34, 20, 1, -29 },
  { 190, 25, 24, 20, -2, -24 },
  { 265, 19, 24, 20, 0, -24 },
  { 322, 6, 10, 20, 9, -24 },
  { 330, 15, 32, 20, 4, -28 },
  { 390, 14, 32, 20, 2, -28 },
  { 446, 18, 17, 20, 1, -20 },
  { 485, 17, 16, 20, 2, -19 },
  { 519, 11, 10, 20, 2, -5 },
  { 533, 12, 4, 20, 4, -13 },
  { 539, 8, 6, 20, 5, -6 },
  { 545, 21, 31, 20, 0, -27 },
  { 627, 18, 24, 20, 1, -24 },
  { 681, 17, 24, 20, 1, -24 },
  { 732, 18, 24, 20, 1, -24 },
  { 786, 18, 24, 20, 1, -24 },
  { 840, 18, 24, 20, 1, -24 },
  { 894, 18, 24, 20, 1, -24 },
  { 948, 17, 24, 20, 1, -24 },
  { 999, 18, 24, 20, 3, -24 },
  { 1053, 18, 24, 20, 1, -24 },
  { 1107, 18, 24, 20, 2, -24 },
  { 1161, 9, 18, 20, 5, -18 },
  { 1182, 11, 23, 20, 3, -18 },
  { 1214, 17, 18, 20, 2, -20 },
  { 1253, 16, 13, 20, 2, -17 },
  { 1279, 17, 18, 20, 1, -20 },
  { 1318, 15, 24, 20, 4, -24 },
  { 1363, 22, 30, 20, -1, -24 },
  { 1446, 19, 24, 20, -1, -24 },
  { 1503, 19, 24, 20, 1, -24 },
  { 1560, 19, 24, 20, 1, -24 },
  { 1617, 19, 24, 20, 1, -24 },
  { 1674, 19, 24, 20, 1, -24 },
  { 1731, 19, 24, 20, 1, -24 },
  { 1788, 19, 24, 20, 1, -24 },
  { 1845, 19, 24, 20, 1, -24 },
  { 1902, 19, 24, 20, 1, -24 },
  { 1959, 20, 24, 20, 0, -24 },
  { 2019, 20, 24, 20, 1, -24 },
  { 2079, 15, 24, 20, 2, -24 },
  { 2124, 21, 24, 20, 0, -24 },
  { 2187, 19, 24, 20, 1, -24 },
  { 2244, 18, 24, 20, 1, -24 },
  { 2298, 19, 24, 20, 1, -24 },
  { 2355, 18, 30, 20, 1, -24 },
  { 2423, 19, 24, 20, 1, -24 },
  { 2480, 19, 24, 20, 1, -24 },
  { 2537, 18, 24, 20, 3, -24 },
  { 2591, 19, 24, 20, 1, -24 },
  { 2648, 18, 24, 20, 3, -24 },
  { 2702, 21, 24, 20, 1, -24 },
  { 2765, 22, 24, 20, -1, -24 },
  { 2831, 19, 24, 20, 3, -24 },
  { 2888, 18, 24, 20, 1, -24 },
  { 2942, 15, 31, 20, 4, -27 },
  { 3001, 12, 31, 20, 4, -27 },
  { 3048, 15, 31, 20, 2, -27 },
  { 3107, 16, 13, 20, 2, -24 },
  { 3133, 16, 4, 20, 0, 1 },
  { 3141, 8, 5, 20, 8, -26 },
  { 3146, 18, 18, 20, 1, -18 },
  { 3187, 18, 24, 20, 1, -24 },
  { 3241, 18, 18, 20, 1, -18 },
  { 3282, 19, 24, 20, 1, -24 },
  { 3339, 18, 18, 20, 1, -18 },
  { 3380, 22, 30, 20, -2, -24 },
  { 3463, 18, 24, 20, 1, -18 },
  { 3517, 18, 24, 20, 1, -24 },
  { 3571, 17, 26, 20, 1, -26 },
  { 3627, 18, 32, 20, 0, -26 },
  { 3699, 19, 24, 20, 1, -24 },
  { 3756, 16, 24, 20, 2, -24 },
  { 3804, 20, 18, 20, 0, -18 },
  { 3849, 18, 18, 20, 1, -18 },
  { 3890, 18, 18, 20, 1, -18 },
  { 3931, 19, 24, 20, 0, -18 },
  { 3988, 18, 24, 20, 1, -18 },
  { 4042, 19, 18, 20, 1, -18 },
  { 4085, 18, 18, 20, 1, -18 },
  { 4126, 17, 23, 20, 2, -23 },
  { 4175, 18, 18, 20, 1, -18 },
  { 4216, 18, 18, 20, 2, -18 },
  { 4257, 19, 18, 20, 2, -18 },
  { 4300, 21, 18, 20, -1, -18 },
  { 4348, 18, 24, 20, 1, -18 },
  { 4402, 18, 18, 20, 1, -18 },
  { 4443, 17, 31, 20, 3, -27 },
  { 4509, 10, 31, 20, 5, -27 },
  { 4548, 18, 31, 20, 0, -27 },
  { 4618, 18, 9, 20, 1, -16 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC33PT7B_H_
