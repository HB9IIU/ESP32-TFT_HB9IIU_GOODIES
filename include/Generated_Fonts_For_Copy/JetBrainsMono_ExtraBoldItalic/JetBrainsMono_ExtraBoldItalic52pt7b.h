#ifndef _JETBRAINSMONO_EXTRABOLDITALIC52PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x87, 0xFB, 0xFC,
  0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xFB,
  0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x9E, 0x7F, 0x83,
  0xFC, 0x71, 0xFE, 0x0F, 0xF1, 0xC3, 0xF8, 0x3F, 0xC7, 0x10, 0x00, 0xFF,
  0x1C, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x77, 0xFE, 0x00,
  0x01, 0xCF, 0xF8, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x3C, 0x7F, 0x80, 0x00,
  0xE1, 0xFE, 0x1F, 0xE3, 0x87, 0xF8, 0x7F, 0x8E, 0x1F, 0xE1, 0xFE, 0x38,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0x81, 0xF8, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xFC,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE3, 0xF0, 0x00,
  0x1F, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFE,
  0xFC, 0x00, 0x00, 0xFF, 0xF9, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xC0, 0x00,
  0x00, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0xF9, 0xFF, 0x80, 0x00, 0x03,
  0xE7, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xFF, 0x80, 0x00, 0x3E, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0xF8, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x7C, 0x00, 0x0F,
  0xC7, 0xC0, 0xF8, 0x00, 0x3F, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x07,
  0xE0, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x1F,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0xFC, 0x3F, 0xC7, 0xFB, 0xFC,
  0x7F, 0x0F, 0xE3, 0xFD, 0xFC, 0x1F, 0xC7, 0xFB, 0xF8, 0x3F, 0x87, 0xFF,
  0xE0, 0xFF, 0x07, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0x03, 0xF8, 0x0F, 0xFC,
  0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0xFE, 0x00,
  0xFF, 0xC1, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xF3, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF1, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0xF8, 0x0C, 0x3F, 0x07, 0xC3, 0xF1, 0xFC,
  0x3C, 0x7F, 0x9F, 0xF9, 0xE7, 0xFC, 0xFF, 0xEE, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xC0, 0x18, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0F, 0x81, 0xFE, 0x3F,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0xE1, 0xFC, 0x3F, 0xDF, 0x8F, 0xE1, 0xFC, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF3, 0xF8, 0x7F, 0x3F, 0xBF, 0xC3, 0xF9, 0xFD, 0xFE, 0x3F, 0xC7,
  0xCF, 0xE1, 0xFE, 0x08, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xF8, 0x3F, 0xC0, 0x3C, 0x0F, 0xE0, 0x0C, 0x07, 0xF8, 0x02, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0,
  0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE7, 0xFE,
  0x01, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xE0, 0x07, 0xFB, 0xFF,
  0x80, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF7, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFE, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xF0, 0x3F, 0xFB, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x1E, 0x1F, 0x83, 0xF0, 0x1F, 0xE7, 0xE0, 0xFC,
  0x0F, 0xFD, 0xF8, 0x3F, 0x07, 0xFF, 0x7C, 0x1F, 0xC3, 0xFF, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0x81, 0xFC,
  0x1F, 0x87, 0xE0, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0x7E, 0x07,
  0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xE0, 0xFF, 0x3F, 0xC1, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7E, 0x07, 0xFE, 0xFC, 0x1F, 0x81, 0xFF, 0x3F, 0x07,
  0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0x9F, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xE0,
  0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x83, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0x81,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xFF,
  0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xC3, 0xF8, 0x3F, 0xFE, 0x3F,
  0xC3, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0x7E, 0x07, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xBF, 0x03, 0xF7, 0xC7, 0xDF, 0x81, 0xFB,
  0xE3, 0xCF, 0xC0, 0xFC, 0xF3, 0xEF, 0xE0, 0x7E, 0x79, 0xF7, 0xF0, 0x3F,
  0x3D, 0xF3, 0xF0, 0x3F, 0x9E, 0xF9, 0xF8, 0x1F, 0xCF, 0xF9, 0xFC, 0x0F,
  0xE7, 0xFC, 0xFE, 0x07, 0xF3, 0xFE, 0x7F, 0x03, 0xF9, 0xFE, 0x3F, 0x81,
  0xFC, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xF8,
  0x03, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xE0,
  0x3F, 0x81, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x0F, 0xFF, 0x01,
  0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x3F, 0x7E, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F,
  0xC0, 0xFD, 0xF8, 0x3F, 0x81, 0xFB, 0xF0, 0x7F, 0x03, 0xF3, 0xE0, 0xFE,
  0x0F, 0xE7, 0xE3, 0xF8, 0x1F, 0xCF, 0xC7, 0xF0, 0x3F, 0x9F, 0x8F, 0xE0,
  0x7F, 0x3F, 0x1F, 0xC0, 0xFE, 0x3E, 0x3F, 0x81, 0xF8, 0x7E, 0x7F, 0x07,
  0xF0, 0xFC, 0xFC, 0x0F, 0xE1, 0xF9, 0xF8, 0x1F, 0xC3, 0xF3, 0xF0, 0x3F,
  0x87, 0xEF, 0xE0, 0x7F, 0x07, 0xDF, 0xC0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8,
  0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0xFC, 0x03,
  0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x7F, 0x3F,
  0x07, 0xF0, 0x7F, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x7E, 0x3F,
  0x07, 0xF0, 0xFE, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F,
  0x0E, 0xF0, 0xFC, 0x3F, 0x1E, 0xF0, 0xFC, 0x7F, 0x1E, 0xF1, 0xF8, 0x7E,
  0x1E, 0xF1, 0xF8, 0x7E, 0x1E, 0xF1, 0xF8, 0x7E, 0x3C, 0xF1, 0xF8, 0x7E,
  0x3C, 0xF3, 0xF0, 0x7E, 0x3C, 0xE3, 0xF0, 0x7E, 0x38, 0xE3, 0xF0, 0x7E,
  0x78, 0xE3, 0xF0, 0x7E, 0x78, 0xE3, 0xE0, 0x7E, 0x79, 0xE7, 0xE0, 0x7E,
  0xF1, 0xE7, 0xE0, 0x7E, 0xF1, 0xE7, 0xE0, 0x7E, 0xF1, 0xE7, 0xC0, 0x7C,
  0xF1, 0xEF, 0xC0, 0x7D, 0xE1, 0xEF, 0xC0, 0x7D, 0xE1, 0xEF, 0xC0, 0xFD,
  0xE1, 0xEF, 0x80, 0xFD, 0xE1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFC,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0,
  0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF,
  0x03, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF, 0xE0, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0xFF, 0x01, 0xFF, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x7F, 0xFC, 0x0F, 0xF7, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F,
  0xC0, 0x7F, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xF7, 0xFF,
  0xF0, 0x7F, 0x7F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0xFF, 0x3F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0xFF, 0x00, 0xFF, 0xFB,
  0xFC, 0x07, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xBF, 0x80, 0xFF, 0xFE, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFD, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xC0, 0x1F, 0xFC, 0xFF, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xF7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF, 0x03, 0xFF,
  0xEF, 0xF0, 0x7F, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0xCF, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x7F, 0xFC, 0x0F, 0xF7,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xE0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xE7, 0xC1, 0xF0, 0x1F, 0x9F, 0xC7, 0xF0, 0x3F, 0x7F, 0x9F, 0xF0,
  0x7E, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0x3F, 0x87,
  0xF0, 0xFC, 0x7F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0xC3, 0xE1, 0xFC, 0x3F,
  0x87, 0xC3, 0xF8, 0x7F, 0x0F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8,
  0x7E, 0x1F, 0x87, 0xF0, 0xF8, 0x3F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0xC3,
  0xE1, 0xFC, 0x3F, 0x87, 0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xF8, 0x7F, 0x0F, 0xE1, 0xF0,
  0xFE, 0x1F, 0xC3, 0xE1, 0xFC, 0x3F, 0x07, 0xC3, 0xF8, 0x7E, 0x1F, 0x87,
  0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7C, 0x3F, 0x87, 0xF0, 0xF8, 0x7F,
  0x0F, 0xE1, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x1F, 0xF8,
  0x0F, 0xF7, 0xFF, 0xC0, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFE,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F,
  0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80,
  0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0x81, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x9F, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x01,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xFE,
  0x01, 0xFE, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0x81,
  0xFD, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xC0, 0xFF, 0x3F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0xC0, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF, 0x03, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE,
  0xFF, 0x0F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0x01, 0xFF, 0xCF,
  0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x9F, 0xFE, 0x03, 0xF9, 0xFF, 0xF8, 0x1F,
  0xDF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF9,
  0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xC1, 0xFD,
  0xF8, 0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xCF,
  0xC3, 0xFC, 0x3F, 0x1F, 0x87, 0xF8, 0x7E, 0x3F, 0x0E, 0xF0, 0xFC, 0x7E,
  0x1D, 0xE3, 0xF0, 0xFC, 0x7B, 0xC7, 0xE1, 0xF8, 0xF7, 0x8F, 0xC3, 0xF1,
  0xCE, 0x1F, 0x87, 0xE7, 0x9C, 0x7E, 0x0F, 0xCF, 0x38, 0xFC, 0x1F, 0x9C,
  0x71, 0xF8, 0x3F, 0x78, 0xE7, 0xE0, 0x7E, 0xF1, 0xCF, 0xC0, 0xF9, 0xE3,
  0x9F, 0x81, 0xF7, 0x87, 0x7E, 0x07, 0xEF, 0x0E, 0xFC, 0x0F, 0xDE, 0x1D,
  0xF8, 0x1F, 0xB8, 0x3B, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF,
  0x7F, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFC, 0xFF, 0x01, 0xFF, 0x8F, 0xF0,
  0x07, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x10, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x47,
  0xFF, 0x80, 0xFC, 0x7F, 0xFE, 0x07, 0xE3, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF,
  0xC1, 0xF9, 0xF8, 0xFF, 0x1F, 0xCF, 0xC3, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF,
  0xE7, 0xE0, 0x7F, 0xFF, 0x3F, 0x01, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 38, 31, 9, -38 },
  { 68, 21, 16, 31, 8, -38 },
  { 110, 33, 38, 31, 0, -38 },
  { 267, 30, 52, 31, 1, -45 },
  { 462, 39, 38, 31, -3, -38 },
  { 648, 31, 39, 31, 0, -38 },
  { 800, 9, 16, 31, 14, -38 },
  { 818, 23, 51, 31, 7, -44 },
  { 965, 22, 51, 31, 3, -44 },
  { 1106, 29, 28, 31, 2, -32 },
  { 1208, 26, 25, 31, 3, -30 },
  { 1290, 16, 16, 31, 4, -8 },
  { 1322, 20, 7, 31, 6, -21 },
  { 1340, 12, 11, 31, 8, -10 },
  { 1357, 34, 49, 31, -1, -43 },
  { 1566, 29, 39, 31, 2, -38 },
  { 1708, 26, 38, 31, 2, -38 },
  { 1832, 29, 38, 31, 1, -38 },
  { 1970, 28, 39, 31, 2, -38 },
  { 2107, 28, 38, 31, 2, -38 },
  { 2240, 28, 39, 31, 2, -38 },
  { 2377, 28, 39, 31, 1, -38 },
  { 2514, 28, 38, 31, 4, -38 },
  { 2647, 30, 39, 31, 1, -38 },
  { 2794, 27, 38, 31, 4, -38 },
  { 2923, 15, 30, 31, 8, -29 },
  { 2980, 19, 37, 31, 4, -29 },
  { 3068, 27, 29, 31, 3, -32 },
  { 3166, 26, 20, 31, 3, -27 },
  { 3231, 27, 29, 31, 2, -32 },
  { 3329, 24, 38, 31, 6, -38 },
  { 3443, 34, 47, 31, -1, -38 },
  { 3643, 29, 38, 31, -1, -38 },
  { 3781, 30, 38, 31, 1, -38 },
  { 3924, 29, 39, 31, 2, -38 },
  { 4066, 30, 38, 31, 1, -38 },
  { 4209, 29, 38, 31, 2, -38 },
  { 4347, 31, 38, 31, 1, -38 },
  { 4495, 29, 39, 31, 2, -38 },
  { 4637, 31, 38, 31, 1, -38 },
  { 4785, 29, 38, 31, 2, -38 },
  { 4923, 31, 39, 31, 0, -38 },
  { 5075, 32, 38, 31, 1, -38 },
  { 5227, 24, 38, 31, 3, -38 },
  { 5341, 33, 38, 31, 0, -38 },
  { 5498, 31, 38, 31, 1, -38 },
  { 5646, 29, 39, 31, 2, -38 },
  { 5788, 31, 38, 31, 1, -38 },
  { 5936, 29, 47, 31, 2, -38 },
  { 6107, 30, 38, 31, 1, -38 },
  { 6250, 30, 39, 31, 1, -38 },
  { 6397, 28, 38, 31, 5, -38 },
  { 6530, 30, 39, 31, 2, -38 },
  { 6677, 29, 38, 31, 5, -38 },
  { 6815, 32, 38, 31, 2, -38 },
  { 6967, 34, 38, 31, -1, -38 },
  { 7129, 29, 38, 31, 5, -38 },
  { 7267, 28, 38, 31, 2, -38 },
  { 7400, 23, 49, 31, 6, -43 },
  { 7541, 18, 49, 31, 7, -43 },
  { 7652, 24, 49, 31, 3, -43 },
  { 7799, 25, 20, 31, 4, -38 },
  { 7862, 27, 8, 31, -1, 1 },
  { 7889, 13, 7, 31, 12, -41 },
  { 7901, 28, 30, 31, 2, -29 },
  { 8006, 28, 39, 31, 1, -38 },
  { 8143, 28, 30, 31, 2, -29 },
  { 8248, 30, 39, 31, 2, -38 },
  { 8395, 27, 30, 31, 2, -29 },
  { 8497, 35, 47, 31, -3, -38 },
  { 8703, 28, 38, 31, 2, -29 },
  { 8836, 28, 38, 31, 1, -38 },
  { 8969, 27, 41, 31, 1, -41 },
  { 9108, 29, 50, 31, 0, -41 },
  { 9290, 31, 38, 31, 1, -38 },
  { 9438, 24, 38, 31, 4, -38 },
  { 9552, 31, 29, 31, 0, -29 },
  { 9665, 28, 29, 31, 1, -29 },
  { 9767, 27, 30, 31, 2, -29 },
  { 9869, 29, 38, 31, 0, -29 },
  { 10007, 28, 38, 31, 2, -29 },
  { 10140, 29, 29, 31, 2, -29 },
  { 10246, 29, 30, 31, 1, -29 },
  { 10355, 27, 36, 31, 3, -36 },
  { 10477, 28, 30, 31, 2, -29 },
  { 10582, 28, 29, 31, 4, -29 },
  { 10684, 31, 29, 31, 2, -29 },
  { 10797, 32, 29, 31, -1, -29 },
  { 10913, 28, 38, 31, 2, -29 },
  { 11046, 28, 29, 31, 1, -29 },
  { 11148, 28, 49, 31, 4, -43 },
  { 11320, 15, 49, 31, 9, -43 },
  { 11412, 28, 49, 31, 1, -43 },
  { 11584, 29, 13, 31, 2, -25 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC52PT7B_H_
