#ifndef _JETBRAINSMONO_EXTRABOLDITALIC61PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0,
  0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F,
  0xE0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7,
  0xFC, 0x1F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xBC, 0xFF, 0xE0, 0x7F, 0xE7, 0x8F, 0xFC,
  0x1F, 0xF8, 0xF1, 0xFF, 0x83, 0xFE, 0x1E, 0x3F, 0xF0, 0x7F, 0xC3, 0xC0,
  0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x01, 0xFF, 0x1E, 0x00, 0x00, 0x3F, 0xF3,
  0xC0, 0x00, 0x07, 0xFE, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x7F, 0xF0, 0x00,
  0x03, 0xC7, 0xFE, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x0F, 0x0F, 0xF8,
  0x00, 0x03, 0xC1, 0xFF, 0x0F, 0xF8, 0x78, 0x3F, 0xE1, 0xFF, 0x0F, 0x0F,
  0xFC, 0x3F, 0xF1, 0xE1, 0xFF, 0x07, 0xFF, 0x3C, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x83,
  0xF9, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xCF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x83, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xE7, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF9, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xCF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x0F, 0xE0, 0x00,
  0x03, 0xF9, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x7E, 0x00, 0x00,
  0xFE, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xE1, 0xFF, 0x7F, 0xC3, 0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F,
  0xEF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x20, 0x07, 0xF0, 0x04, 0x1E, 0x03, 0xF0,
  0x1F, 0x1F, 0xC1, 0xF8, 0x3F, 0x8F, 0xF0, 0xF8, 0x3F, 0xCF, 0xFC, 0x7C,
  0x7F, 0xE7, 0xFF, 0x9C, 0xFF, 0xF7, 0xFF, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x03, 0x80, 0xFF, 0x0F, 0xFC, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8,
  0x7F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x0C, 0x0F, 0xF0, 0x7F, 0xCF, 0xC3, 0xFC, 0x1F, 0xE7, 0xF8, 0xFF, 0x07,
  0xF9, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x9F, 0xF0, 0xFF, 0x9F, 0xE7, 0xFC,
  0x3F, 0xE7, 0xF9, 0xFF, 0x0F, 0xF8, 0xFC, 0x7F, 0x83, 0xFC, 0x1E, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x07, 0xFC,
  0x00, 0xF8, 0x1F, 0xF8, 0x01, 0xE0, 0x3F, 0xE0, 0x03, 0x00, 0x7F, 0xC0,
  0x04, 0x00, 0xFF, 0x80, 0x10, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0x07, 0xFC,
  0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x07,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF,
  0xDF, 0xF8, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x01, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x03,
  0xF8, 0xFE, 0x0F, 0xF0, 0x1F, 0xF9, 0xFC, 0x1F, 0xE0, 0x7F, 0xFB, 0xF8,
  0x3F, 0x81, 0xFF, 0xF3, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F,
  0xF8, 0xFF, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFE,
  0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x83,
  0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x3F,
  0x83, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xC0, 0xFF, 0xFB, 0xF8, 0x3F, 0x80, 0xFF, 0xE7, 0xF0, 0x7F,
  0x00, 0xFF, 0x8F, 0xC0, 0xFE, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x87, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0xFF, 0xF8,
  0x0F, 0xDF, 0x03, 0xEF, 0xE0, 0x7F, 0x7C, 0x1F, 0xBF, 0x81, 0xFD, 0xF8,
  0x7F, 0xFE, 0x07, 0xF7, 0xE1, 0xF7, 0xF8, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0,
  0x7F, 0x7E, 0x3E, 0x7F, 0x01, 0xFC, 0xF9, 0xFB, 0xFC, 0x0F, 0xF3, 0xE7,
  0xCF, 0xF0, 0x3F, 0xCF, 0xBF, 0x3F, 0xC0, 0xFF, 0x3E, 0xFC, 0xFF, 0x03,
  0xFC, 0xFB, 0xE3, 0xF8, 0x0F, 0xF3, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0xC7, 0xF8, 0x1F,
  0xE1, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F,
  0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFE, 0x01, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xC0, 0x7F, 0x7F, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x7F,
  0x7F, 0x03, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F, 0xC0, 0xFF, 0x3F, 0x83, 0xFC,
  0x0F, 0xF3, 0xF8, 0x7F, 0x80, 0xFF, 0x3F, 0x87, 0xF8, 0x0F, 0xF3, 0xF8,
  0x7F, 0x80, 0xFF, 0x1F, 0x87, 0xF8, 0x0F, 0xF1, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xC7, 0xF0,
  0x1F, 0xE1, 0xFC, 0xFF, 0x01, 0xFE, 0x0F, 0xCF, 0xF0, 0x1F, 0xE0, 0xFE,
  0xFF, 0x03, 0xFE, 0x0F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFE, 0xFF, 0x03, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFE, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xC0, 0x7F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x3F,
  0xC7, 0xF0, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xF0, 0x7F, 0x87, 0xF0, 0x7B, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xC3, 0xFC, 0x3F, 0x83, 0xDF, 0x0F, 0xE0,
  0xFE, 0x0F, 0x7C, 0x3F, 0x83, 0xF8, 0x7D, 0xF0, 0xFE, 0x0F, 0xE1, 0xF7,
  0x87, 0xF0, 0x3F, 0x87, 0x9E, 0x1F, 0xC0, 0xFE, 0x3E, 0x78, 0x7F, 0x03,
  0xF8, 0xF9, 0xE1, 0xFC, 0x0F, 0xE3, 0xE7, 0x8F, 0xE0, 0x3F, 0x8F, 0x1E,
  0x3F, 0x80, 0xFE, 0x7C, 0x78, 0xFE, 0x03, 0xF1, 0xF1, 0xE3, 0xF8, 0x1F,
  0xC7, 0x87, 0x8F, 0xC0, 0x7F, 0x1E, 0x3E, 0x7F, 0x01, 0xFC, 0xF8, 0xF9,
  0xFC, 0x07, 0xF3, 0xE3, 0xE7, 0xF0, 0x1F, 0xCF, 0x0F, 0x9F, 0x80, 0x7F,
  0x3C, 0x3E, 0xFE, 0x01, 0xFD, 0xF0, 0xFB, 0xF8, 0x07, 0xF7, 0xC3, 0xEF,
  0xE0, 0x1F, 0xDE, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0xF7, 0xF0, 0x07, 0xEF, 0x03, 0xDF, 0xC0, 0x1F, 0xBC, 0x0F, 0x7E,
  0x00, 0x7F, 0xF0, 0x3D, 0xF8, 0x01, 0xFF, 0xC0, 0xF7, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0,
  0x3F, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xBF, 0xE0, 0x0F,
  0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0x00,
  0x7F, 0xDF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xDF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xF8, 0x07, 0xFD,
  0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x07, 0xFF,
  0x8F, 0xF8, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0x3F, 0xE0, 0x1F,
  0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x7F,
  0xC0, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF,
  0xEF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFF,
  0x01, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFC, 0x7F,
  0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC1, 0xFC,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF,
  0xF8, 0x0F, 0xFB, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xF0, 0xF8, 0x1F, 0x80, 0x7F, 0x3F, 0xC3, 0xFC, 0x07, 0xF7, 0xFC, 0x7F,
  0xE0, 0x7F, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE1, 0xFE, 0x0F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0x83, 0xFC, 0x3F, 0xC1, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0x83, 0xFC, 0x3F, 0xC1, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0x83, 0xF8, 0x3F, 0xC3, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x07, 0xF8, 0x7F,
  0x83, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0x83, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xE0,
  0x03, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xBF, 0xFF,
  0xC0, 0x7F, 0xDF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x03,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xF0,
  0x0F, 0xFB, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0xE7, 0xFF,
  0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x3F,
  0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0x9F, 0xF0, 0x3F,
  0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF,
  0x7F, 0xC0, 0x3F, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0x9F, 0xF0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xCF, 0xFF,
  0xE0, 0x1F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x81, 0xFC, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x83, 0xF8,
  0xFE, 0x0F, 0x78, 0x3F, 0x8F, 0xE0, 0xF7, 0x83, 0xF8, 0xFE, 0x0F, 0x78,
  0x7F, 0x8F, 0xE1, 0xE7, 0x87, 0xF0, 0xFE, 0x1E, 0x78, 0x7F, 0x0F, 0xE1,
  0xE7, 0x87, 0xF0, 0xFE, 0x3E, 0x78, 0xFE, 0x0F, 0xE3, 0xC7, 0x8F, 0xE0,
  0xFE, 0x3C, 0x78, 0xFE, 0x0F, 0xE7, 0xC7, 0x9F, 0xC0, 0xFE, 0x78, 0x79,
  0xFC, 0x0F, 0xE7, 0x8F, 0x9F, 0xC0, 0xFE, 0xF8, 0xF9, 0xF8, 0x0F, 0xEF,
  0x8F, 0xBF, 0x80, 0xFE, 0xF0, 0xFB, 0xF8, 0x0F, 0xEF, 0x0F, 0xBF, 0x80,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xF9, 0xFF, 0x01, 0xFF,
  0xFD, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x01,
  0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0xFF, 0x80,
  0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF,
  0x83, 0xF9, 0xFE, 0x3F, 0xF1, 0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0x9F, 0xC0,
  0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0xF8, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 18, 45, 37, 10, -45 },
  { 103, 25, 19, 37, 9, -45 },
  { 163, 38, 45, 37, 0, -45 },
  { 377, 35, 62, 37, 1, -53 },
  { 649, 46, 45, 37, -4, -45 },
  { 908, 36, 46, 37, 0, -45 },
  { 1115, 11, 19, 37, 16, -45 },
  { 1142, 27, 60, 37, 8, -52 },
  { 1345, 27, 60, 37, 3, -52 },
  { 1548, 33, 32, 37, 3, -37 },
  { 1680, 31, 30, 37, 3, -35 },
  { 1797, 19, 19, 37, 4, -9 },
  { 1843, 23, 8, 37, 7, -24 },
  { 1866, 13, 13, 37, 10, -12 },
  { 1888, 40, 58, 37, -1, -51 },
  { 2178, 34, 46, 37, 2, -45 },
  { 2374, 31, 45, 37, 2, -45 },
  { 2549, 34, 45, 37, 2, -45 },
  { 2741, 34, 46, 37, 2, -45 },
  { 2937, 33, 45, 37, 2, -45 },
  { 3123, 34, 46, 37, 2, -45 },
  { 3319, 32, 46, 37, 2, -45 },
  { 3503, 33, 45, 37, 5, -45 },
  { 3689, 35, 46, 37, 1, -45 },
  { 3891, 33, 45, 37, 4, -45 },
  { 4077, 17, 35, 37, 10, -34 },
  { 4152, 22, 44, 37, 5, -34 },
  { 4273, 32, 34, 37, 4, -37 },
  { 4409, 31, 24, 37, 3, -32 },
  { 4502, 32, 34, 37, 2, -37 },
  { 4638, 28, 45, 37, 7, -45 },
  { 4796, 39, 56, 37, -1, -45 },
  { 5069, 33, 45, 37, -1, -45 },
  { 5255, 36, 45, 37, 1, -45 },
  { 5458, 34, 46, 37, 2, -45 },
  { 5654, 35, 45, 37, 1, -45 },
  { 5851, 35, 45, 37, 2, -45 },
  { 6048, 35, 45, 37, 2, -45 },
  { 6245, 34, 46, 37, 2, -45 },
  { 6441, 36, 45, 37, 1, -45 },
  { 6644, 34, 45, 37, 2, -45 },
  { 6836, 36, 46, 37, 0, -45 },
  { 7043, 38, 45, 37, 1, -45 },
  { 7257, 29, 45, 37, 3, -45 },
  { 7421, 38, 45, 37, 0, -45 },
  { 7635, 36, 45, 37, 1, -45 },
  { 7838, 34, 46, 37, 2, -45 },
  { 8034, 37, 45, 37, 1, -45 },
  { 8243, 34, 56, 37, 2, -45 },
  { 8481, 36, 45, 37, 1, -45 },
  { 8684, 35, 46, 37, 1, -45 },
  { 8886, 34, 45, 37, 5, -45 },
  { 9078, 35, 46, 37, 2, -45 },
  { 9280, 33, 45, 37, 6, -45 },
  { 9466, 38, 45, 37, 2, -45 },
  { 9680, 40, 45, 37, -1, -45 },
  { 9905, 35, 45, 37, 5, -45 },
  { 10102, 34, 45, 37, 2, -45 },
  { 10294, 27, 58, 37, 7, -51 },
  { 10490, 22, 58, 37, 8, -51 },
  { 10650, 28, 58, 37, 4, -51 },
  { 10853, 30, 24, 37, 4, -45 },
  { 10943, 31, 8, 37, -1, 2 },
  { 10974, 15, 9, 37, 14, -48 },
  { 10991, 33, 35, 37, 2, -34 },
  { 11136, 34, 46, 37, 1, -45 },
  { 11332, 33, 35, 37, 2, -34 },
  { 11477, 35, 46, 37, 2, -45 },
  { 11679, 32, 35, 37, 2, -34 },
  { 11819, 42, 56, 37, -4, -45 },
  { 12113, 33, 45, 37, 2, -34 },
  { 12299, 33, 45, 37, 1, -45 },
  { 12485, 31, 48, 37, 2, -48 },
  { 12671, 34, 59, 37, 0, -48 },
  { 12922, 36, 45, 37, 2, -45 },
  { 13125, 28, 45, 37, 5, -45 },
  { 13283, 36, 34, 37, 0, -34 },
  { 13436, 33, 34, 37, 1, -34 },
  { 13577, 32, 35, 37, 2, -34 },
  { 13717, 35, 45, 37, 0, -34 },
  { 13914, 33, 45, 37, 2, -34 },
  { 14100, 34, 34, 37, 2, -34 },
  { 14245, 34, 35, 37, 1, -34 },
  { 14394, 32, 43, 37, 3, -43 },
  { 14566, 33, 35, 37, 2, -34 },
  { 14711, 34, 34, 37, 4, -34 },
  { 14856, 36, 34, 37, 3, -34 },
  { 15009, 38, 34, 37, -1, -34 },
  { 15171, 33, 45, 37, 2, -34 },
  { 15357, 32, 34, 37, 2, -34 },
  { 15493, 32, 58, 37, 5, -51 },
  { 15725, 18, 58, 37, 10, -51 },
  { 15856, 32, 58, 37, 1, -51 },
  { 16088, 34, 15, 37, 2, -29 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC61PT7B_H_
