#ifndef _JETBRAINSMONO_EXTRABOLDITALIC19PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0x00, 0x18, 0xF3, 0x80,
  0xE7, 0xE6, 0xEE, 0xEE, 0xCE, 0xCE, 0x06, 0x60, 0x66, 0x0C, 0x63, 0xFF,
  0x3F, 0xF5, 0x8C, 0x19, 0x81, 0x98, 0x31, 0x8F, 0xFC, 0xFF, 0xC6, 0x30,
  0x66, 0x0E, 0x60, 0x01, 0x00, 0x20, 0x0C, 0x07, 0xE1, 0xFE, 0x7F, 0xCE,
  0xB9, 0xD0, 0x3E, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x5C, 0xEB, 0x9D, 0xF3,
  0xFC, 0x3F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0E, 0x0C, 0x7C, 0x63, 0x33,
  0x0C, 0xD8, 0x37, 0xC0, 0xFE, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xF0, 0x3E,
  0xC1, 0xB3, 0x0C, 0xCC, 0x63, 0xE3, 0x07, 0x80, 0x07, 0x83, 0xF8, 0x77,
  0x0C, 0x61, 0x80, 0x38, 0x0F, 0x03, 0xF7, 0x6E, 0xCC, 0xFB, 0x8E, 0x73,
  0xC7, 0xF8, 0xFB, 0x80, 0x7F, 0xFF, 0x80, 0x01, 0x83, 0xC3, 0xE3, 0xC3,
  0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x06, 0x00, 0x10, 0x1C, 0x3E, 0x0F, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x1C, 0xF8, 0xF0, 0xC0, 0x0E, 0x03,
  0x80, 0xE1, 0xB3, 0xF7, 0xDF, 0xE1, 0xC0, 0xD8, 0x77, 0x38, 0xC0, 0x0E,
  0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0x70, 0x1C, 0x00, 0x1C,
  0xE3, 0x9C, 0x73, 0x80, 0x7E, 0xFF, 0xF8, 0x2F, 0xFE, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x0F, 0x8F, 0xF7, 0xBD, 0xC7, 0x61, 0xD8, 0x7E, 0xDF, 0xB6, 0xE1, 0xB8,
  0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80, 0x07, 0x0F, 0x9F, 0xCE, 0xE4, 0x70,
  0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x8F, 0xFF, 0xFC, 0x0F, 0x83,
  0xF8, 0xFF, 0x9C, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0x3F, 0xCF, 0xF3, 0xFC, 0x1C, 0x0E,
  0x07, 0xC1, 0xF8, 0x1E, 0x03, 0x80, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80,
  0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3B, 0x8E, 0xE3, 0xBF,
  0xEF, 0xF8, 0x0E, 0x03, 0x01, 0xC0, 0x3F, 0xCF, 0xF3, 0xFD, 0xC0, 0x70,
  0x1F, 0xC7, 0xF9, 0xCE, 0x03, 0x80, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80,
  0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0xFB, 0xFE, 0xE3, 0xB8,
  0x6C, 0x3B, 0x9E, 0xFF, 0x1F, 0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0x38, 0xEE,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xF3, 0x9C, 0x73, 0x8E, 0x73, 0x87, 0xE0,
  0xFC, 0x39, 0xCE, 0x39, 0xC7, 0x39, 0xE7, 0xF8, 0x7E, 0x00, 0x1F, 0x0F,
  0xF7, 0x9D, 0xC7, 0x61, 0xF8, 0x77, 0xFD, 0xFE, 0x13, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1E, 0x00, 0x11, 0xDE, 0x60, 0x00, 0x00, 0x77, 0xBC, 0x04,
  0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x00,
  0x00, 0x40, 0x30, 0x7C, 0x7E, 0x7C, 0x1C, 0x0F, 0x01, 0xF8, 0x1F, 0x81,
  0xE0, 0x10, 0x7F, 0xDF, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x40,
  0x38, 0x1F, 0x07, 0xE0, 0xF8, 0x1C, 0x1E, 0x7E, 0xFC, 0x70, 0x20, 0x00,
  0x7E, 0x3F, 0x9F, 0xC0, 0x70, 0x30, 0x38, 0xFC, 0x78, 0x70, 0x38, 0x00,
  0x0C, 0x0F, 0x07, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x07, 0x60, 0x76,
  0x7F, 0x66, 0x66, 0xE6, 0x6C, 0x6E, 0xC6, 0xCC, 0xEC, 0xFE, 0xC7, 0xCC,
  0x00, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x36, 0x1D,
  0x87, 0x61, 0x98, 0xE7, 0x39, 0xDF, 0xF7, 0xFD, 0xC7, 0xE1, 0xF8, 0x70,
  0x1F, 0x87, 0xFC, 0xE7, 0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xE3, 0xFE, 0x71,
  0xCE, 0x19, 0xC7, 0x39, 0xE7, 0xF9, 0xFE, 0x00, 0x0F, 0x8F, 0xF7, 0xBD,
  0xC7, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3B, 0x9E, 0xFF,
  0x1F, 0x80, 0x1F, 0x87, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x3B,
  0x87, 0x70, 0xEE, 0x19, 0xC7, 0x3F, 0xE7, 0xF9, 0xFC, 0x00, 0x3F, 0xCF,
  0xF3, 0xFD, 0xC0, 0x70, 0x1C, 0x07, 0xF9, 0xFE, 0x60, 0x38, 0x0E, 0x03,
  0x82, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x03,
  0x80, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x0F, 0x8F, 0xF7, 0xBD, 0xC7, 0x70, 0x1C, 0x0E, 0x7F, 0x9F, 0xEF,
  0xB8, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80, 0x18, 0x73, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xCE, 0x38, 0x3F, 0xCF, 0xF7, 0xFC, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0x3F, 0xC0, 0x07, 0xE0,
  0xFC, 0x1F, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B,
  0x87, 0x79, 0xC7, 0xF0, 0x7C, 0x00, 0x18, 0x73, 0x8E, 0x38, 0xE3, 0x9C,
  0x3B, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38,
  0x61, 0xCE, 0x1C, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x1F, 0xFF, 0xFF, 0xFC, 0x38, 0x73, 0x8F, 0x3C, 0xF3,
  0xDE, 0x7D, 0xE7, 0xF6, 0x7F, 0xE7, 0x6E, 0x60, 0xE6, 0x0C, 0x60, 0xCE,
  0x0C, 0xE1, 0xCE, 0x1C, 0x3C, 0x73, 0xC6, 0x3C, 0x63, 0xC6, 0x3E, 0xE3,
  0x6E, 0x76, 0xE7, 0x6C, 0x76, 0xC7, 0x6C, 0x63, 0xC6, 0x3C, 0x63, 0xCE,
  0x3C, 0x0F, 0x8F, 0xF7, 0xBD, 0xC7, 0x71, 0xDC, 0x7E, 0x1F, 0x86, 0xE3,
  0xB8, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80, 0x1F, 0x83, 0xFE, 0x3F, 0xE3,
  0x87, 0x38, 0x73, 0x8E, 0x3F, 0xE7, 0xFC, 0x7F, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x0F, 0x0F, 0xF7, 0xBD, 0xC7, 0x71, 0xDC, 0x7E,
  0x1F, 0x86, 0xE3, 0xB8, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80, 0xE0, 0x38,
  0x07, 0x00, 0x1F, 0x87, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xCF, 0xF3,
  0xFC, 0x7F, 0x0E, 0x61, 0xCE, 0x39, 0xC6, 0x19, 0xC3, 0x80, 0x0F, 0xC3,
  0xFC, 0xF7, 0x9C, 0x73, 0x80, 0x78, 0x0F, 0xE0, 0xFE, 0x03, 0xC0, 0x39,
  0xC7, 0x39, 0xE7, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x00,
  0x70, 0xEE, 0x19, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x77, 0x0C, 0xE3,
  0x9C, 0x73, 0x8E, 0x73, 0xCF, 0xF0, 0xFC, 0x00, 0xE1, 0xF8, 0x7E, 0x3B,
  0x8E, 0xE3, 0xB9, 0xCE, 0x73, 0x98, 0x6E, 0x1B, 0x86, 0xC1, 0xF0, 0x78,
  0x1E, 0x00, 0x66, 0x7E, 0x66, 0xEE, 0x6E, 0xAE, 0xCA, 0xCD, 0xEC, 0xDE,
  0xCD, 0x6C, 0xD7, 0x8F, 0x78, 0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0x38,
  0x73, 0x8E, 0x1D, 0xE1, 0xDC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF8, 0x3B, 0x87, 0x38, 0x71, 0xCE, 0x1C, 0xE1, 0xF8, 0x7E, 0x39,
  0x8C, 0x77, 0x1F, 0x87, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1C, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70,
  0x38, 0x1E, 0x07, 0x03, 0xFE, 0xFF, 0x3F, 0xC0, 0x1F, 0x8F, 0x87, 0xC7,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x81, 0xF8, 0xFC, 0x7E, 0x00, 0xE3, 0x8E, 0x38, 0xE1, 0xC7, 0x1C, 0x70,
  0xC3, 0x8E, 0x38, 0xE1, 0x87, 0x1C, 0x70, 0x1F, 0x8F, 0xC7, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0x07, 0x87, 0xC3, 0x63, 0xB9, 0x9D, 0xC7,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xF3, 0x8E, 0x18, 0x0F, 0xF7, 0xFD, 0xCF,
  0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0xBF, 0xE7, 0xB0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0xC3, 0xFC, 0x7F, 0x8E, 0x3B, 0x86, 0x71, 0xCE, 0x39, 0xC7,
  0x39, 0xE6, 0xF9, 0xDE, 0x00, 0x0E, 0x0F, 0xE7, 0xF9, 0xC7, 0xE0, 0x38,
  0x0E, 0x03, 0x8E, 0xE7, 0xBF, 0xC7, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x0C,
  0xE3, 0xFC, 0xFF, 0x9C, 0xF7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0xCF,
  0xF8, 0xF6, 0x00, 0x0E, 0x0F, 0xE7, 0xF9, 0x87, 0xE1, 0xBF, 0xEE, 0x03,
  0x80, 0xE3, 0xBF, 0xC7, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0xFC, 0x06, 0x00,
  0x70, 0x1F, 0xF8, 0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x1F, 0x80, 0xF8, 0x00, 0x18, 0x0F, 0xF7,
  0xFD, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xFF, 0x9E, 0xE0, 0x30, 0x1C,
  0x7F, 0x3F, 0x80, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0xC3, 0xFC, 0x7F, 0x8E,
  0x73, 0x86, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x1D, 0xC7, 0x00, 0x03,
  0x80, 0xE0, 0x30, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x7F, 0xDF, 0xFF, 0xFC, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0x87, 0xF1, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0xFE, 0x1F, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x81, 0x38, 0xE3, 0x9C, 0x3B, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0x73, 0x87,
  0x38, 0x73, 0xCE, 0x1C, 0x7E, 0x3F, 0x3F, 0x81, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x0E, 0x07, 0xF1, 0xF8, 0x7C, 0x04, 0x4F, 0xFD, 0xDB,
  0xBB, 0x36, 0x6E, 0xCD, 0xD9, 0xBB, 0x66, 0xEC, 0xDD, 0x9B, 0x37, 0x00,
  0x01, 0x87, 0xF8, 0xFF, 0x1C, 0xE7, 0x0C, 0xE3, 0x9C, 0x73, 0x8E, 0x71,
  0xCE, 0x3B, 0x8E, 0x00, 0x0E, 0x0F, 0xE7, 0xF9, 0xC7, 0xE1, 0xB8, 0xEE,
  0x3B, 0x8E, 0xE7, 0xBF, 0xC7, 0xE0, 0x01, 0x87, 0xF8, 0xFF, 0x1C, 0x77,
  0x0C, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0xCD, 0xF3, 0xBC, 0x70, 0x0E, 0x01,
  0xC0, 0x00, 0x18, 0x0F, 0xF7, 0xFD, 0xCF, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E,
  0xE7, 0xBF, 0xE7, 0xB0, 0x1C, 0x07, 0x01, 0xC0, 0x03, 0x1F, 0xF7, 0xFD,
  0xC7, 0x71, 0xD8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x07, 0x03,
  0xF8, 0xFF, 0x98, 0x03, 0x80, 0x7F, 0x03, 0xF0, 0x0E, 0x71, 0xCF, 0xF0,
  0xFC, 0x00, 0x0E, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xC7, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x1F, 0x00, 0x71, 0xDC, 0x76, 0x1F, 0x86,
  0xE3, 0xB8, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0x80, 0xE1, 0xEC, 0x39, 0xCE,
  0x39, 0xC7, 0x30, 0xEE, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xCE, 0x79,
  0xDB, 0x33, 0x6E, 0x6D, 0x5D, 0xAB, 0x3D, 0x67, 0x2C, 0xE7, 0x1C, 0xE0,
  0x39, 0xE3, 0xB8, 0x7E, 0x07, 0x80, 0xE0, 0x3E, 0x07, 0xC1, 0xDC, 0x73,
  0x9C, 0x38, 0x71, 0xD8, 0x7E, 0x1B, 0x8E, 0xE3, 0xB8, 0xEE, 0x7B, 0xFE,
  0x7B, 0x00, 0xC0, 0x71, 0xFC, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x82, 0x7F, 0x9F, 0xF0, 0x01, 0xE0, 0x78,
  0x1F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x7E, 0x0F, 0x83, 0xF8,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x1C, 0x71,
  0x8E, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x80,
  0x1C, 0x07, 0x81, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xC1,
  0xF0, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC1, 0xF0, 0x78, 0x3C, 0x00, 0x78,
  0xFF, 0x3C, 0xFF, 0x3E, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 14, 11, 3, -14 },
  { 12, 8, 6, 11, 3, -14 },
  { 18, 12, 14, 11, 0, -14 },
  { 39, 11, 20, 11, 0, -17 },
  { 67, 14, 14, 11, -1, -14 },
  { 92, 11, 14, 11, 0, -14 },
  { 112, 3, 6, 11, 5, -14 },
  { 115, 9, 18, 11, 2, -16 },
  { 136, 8, 18, 11, 1, -16 },
  { 154, 10, 10, 11, 1, -12 },
  { 167, 10, 9, 11, 1, -11 },
  { 179, 6, 6, 11, 1, -3 },
  { 184, 7, 3, 11, 2, -8 },
  { 187, 4, 4, 11, 3, -4 },
  { 189, 12, 18, 11, 0, -16 },
  { 216, 10, 14, 11, 1, -14 },
  { 234, 9, 14, 11, 1, -14 },
  { 250, 11, 14, 11, 0, -14 },
  { 270, 10, 14, 11, 1, -14 },
  { 288, 10, 14, 11, 1, -14 },
  { 306, 10, 14, 11, 1, -14 },
  { 324, 10, 14, 11, 1, -14 },
  { 342, 11, 14, 11, 1, -14 },
  { 362, 11, 14, 11, 0, -14 },
  { 382, 10, 14, 11, 1, -14 },
  { 400, 5, 11, 11, 3, -11 },
  { 407, 7, 14, 11, 1, -11 },
  { 420, 10, 11, 11, 1, -12 },
  { 434, 10, 7, 11, 1, -10 },
  { 443, 9, 11, 11, 1, -12 },
  { 456, 9, 14, 11, 2, -14 },
  { 472, 12, 17, 11, 0, -14 },
  { 498, 10, 14, 11, 0, -14 },
  { 516, 11, 14, 11, 0, -14 },
  { 536, 10, 14, 11, 1, -14 },
  { 554, 11, 14, 11, 0, -14 },
  { 574, 10, 14, 11, 1, -14 },
  { 592, 12, 14, 11, 0, -14 },
  { 613, 10, 14, 11, 1, -14 },
  { 631, 12, 14, 11, 0, -14 },
  { 652, 10, 14, 11, 1, -14 },
  { 670, 11, 14, 11, 0, -14 },
  { 690, 12, 14, 11, 0, -14 },
  { 711, 9, 14, 11, 1, -14 },
  { 727, 12, 14, 11, 0, -14 },
  { 748, 12, 14, 11, 0, -14 },
  { 769, 10, 14, 11, 1, -14 },
  { 787, 12, 14, 11, 0, -14 },
  { 808, 10, 17, 11, 1, -14 },
  { 830, 11, 14, 11, 0, -14 },
  { 850, 11, 14, 11, 0, -14 },
  { 870, 10, 14, 11, 2, -14 },
  { 888, 11, 14, 11, 1, -14 },
  { 908, 10, 14, 11, 2, -14 },
  { 926, 12, 14, 11, 1, -14 },
  { 947, 12, 14, 11, 0, -14 },
  { 968, 10, 14, 11, 2, -14 },
  { 986, 10, 14, 11, 1, -14 },
  { 1004, 9, 18, 11, 2, -16 },
  { 1025, 6, 18, 11, 3, -16 },
  { 1039, 9, 18, 11, 1, -16 },
  { 1060, 9, 8, 11, 1, -14 },
  { 1069, 9, 3, 11, 0, 0 },
  { 1073, 5, 3, 11, 4, -15 },
  { 1075, 10, 11, 11, 1, -11 },
  { 1089, 11, 14, 11, 0, -14 },
  { 1109, 10, 11, 11, 1, -11 },
  { 1123, 11, 14, 11, 1, -14 },
  { 1143, 10, 11, 11, 1, -11 },
  { 1157, 13, 17, 11, -1, -14 },
  { 1185, 10, 14, 11, 1, -11 },
  { 1203, 11, 14, 11, 0, -14 },
  { 1223, 10, 15, 11, 0, -15 },
  { 1242, 11, 18, 11, 0, -15 },
  { 1267, 12, 14, 11, 0, -14 },
  { 1288, 9, 14, 11, 1, -14 },
  { 1304, 11, 11, 11, 0, -11 },
  { 1320, 11, 11, 11, 0, -11 },
  { 1336, 10, 11, 11, 1, -11 },
  { 1350, 11, 14, 11, 0, -11 },
  { 1370, 10, 14, 11, 1, -11 },
  { 1388, 10, 11, 11, 1, -11 },
  { 1402, 11, 11, 11, 0, -11 },
  { 1418, 10, 13, 11, 1, -13 },
  { 1435, 10, 10, 11, 1, -10 },
  { 1448, 11, 10, 11, 1, -10 },
  { 1462, 11, 10, 11, 1, -10 },
  { 1476, 11, 10, 11, 0, -10 },
  { 1490, 10, 13, 11, 1, -10 },
  { 1507, 11, 10, 11, 0, -10 },
  { 1521, 11, 18, 11, 1, -16 },
  { 1546, 6, 18, 11, 3, -16 },
  { 1560, 10, 18, 11, 0, -16 },
  { 1583, 10, 5, 11, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC19PT7B_H_
