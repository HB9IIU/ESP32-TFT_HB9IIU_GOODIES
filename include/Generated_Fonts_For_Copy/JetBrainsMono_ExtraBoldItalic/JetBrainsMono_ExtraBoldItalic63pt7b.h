#ifndef _JETBRAINSMONO_EXTRABOLDITALIC63PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF7, 0xFE,
  0x0F, 0xF9, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x1F, 0xF9, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0xF3,
  0xFF, 0x80, 0xFF, 0xC7, 0x8F, 0xFC, 0x07, 0xFC, 0x7C, 0x7F, 0xE0, 0x7F,
  0xE3, 0xC3, 0xFF, 0x03, 0xFF, 0x1E, 0x00, 0x00, 0x1F, 0xF8, 0xF0, 0x00,
  0x00, 0xFF, 0xC7, 0x80, 0x00, 0x07, 0xFE, 0x3C, 0x00, 0x00, 0x3F, 0xFB,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7B, 0xFF, 0xC0, 0x00, 0x07,
  0xCF, 0xFE, 0x00, 0x00, 0x3C, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0x80,
  0x00, 0x0F, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0x3F, 0xE0, 0xFF, 0xC3, 0xC3,
  0xFF, 0x07, 0xFE, 0x1E, 0x1F, 0xF8, 0x3F, 0xF1, 0xE1, 0xFF, 0x81, 0xFF,
  0xCF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x3F,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF3, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xF3, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0xBF, 0xC0,
  0x00, 0x03, 0xF9, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x0F,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xE7,
  0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF7, 0xFC, 0x1F, 0xF0, 0xFF, 0xBF, 0xE0,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0xFF, 0xDF,
  0xFB, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x40, 0x07, 0xF0, 0x04, 0x1E, 0x01, 0xF8, 0x07,
  0x8F, 0xE0, 0x7E, 0x0F, 0xE3, 0xFC, 0x1F, 0x07, 0xF9, 0xFF, 0xC7, 0xC7,
  0xFE, 0x7F, 0xF9, 0xE7, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x27, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7F, 0xFD,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x20, 0x3F, 0xE1, 0xFF, 0x1F, 0x87,
  0xF8, 0x3F, 0xE7, 0xF9, 0xFF, 0x07, 0xFD, 0xFF, 0x3F, 0xE0, 0xFF, 0xBF,
  0xE7, 0xFC, 0x1F, 0xE7, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x9F, 0xF0, 0xFF,
  0x8F, 0xE3, 0xFC, 0x1F, 0xF0, 0xF8, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xF8, 0x7F, 0xE0, 0x07,
  0xF0, 0x7F, 0xE0, 0x07, 0xC0, 0x7F, 0xE0, 0x07, 0x80, 0x7F, 0xC0, 0x06,
  0x00, 0x7F, 0xC0, 0x04, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x02, 0x07, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0xF0, 0x07, 0xFD,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x07, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x5A, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0xFE,
  0x0F, 0xF0, 0x1F, 0xFE, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x7E, 0x0F, 0xF0,
  0x7F, 0xFE, 0x7E, 0x0F, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xC1, 0xFE,
  0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x03, 0xFC,
  0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x07,
  0xF8, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFF,
  0xF3, 0xF0, 0x7F, 0x01, 0xFF, 0xF7, 0xF0, 0x7F, 0x00, 0xFF, 0xE7, 0xF0,
  0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x7F, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3E, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7D, 0xFC, 0x03, 0xFB, 0xE0, 0xFD, 0xFC,
  0x07, 0xFB, 0xE0, 0xFB, 0xFC, 0x07, 0xFB, 0xE1, 0xFB, 0xFC, 0x07, 0xFB,
  0xE1, 0xFB, 0xFC, 0x07, 0xFB, 0xF3, 0xF3, 0xF8, 0x07, 0xF3, 0xF3, 0xF7,
  0xF8, 0x07, 0xF3, 0xF7, 0xE7, 0xF8, 0x0F, 0xF3, 0xF7, 0xE7, 0xF8, 0x0F,
  0xF3, 0xF7, 0xE7, 0xF8, 0x0F, 0xF3, 0xFF, 0xCF, 0xF8, 0x0F, 0xF1, 0xFF,
  0xCF, 0xF0, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF8,
  0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xEF, 0xE0,
  0x7F, 0x80, 0x7F, 0xBF, 0x81, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xF8, 0x07,
  0xFB, 0xF8, 0x1F, 0xE0, 0x1F, 0xEF, 0xE0, 0xFF, 0x80, 0xFF, 0x3F, 0xC3,
  0xFE, 0x03, 0xFC, 0x7F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xF9, 0xFF, 0x01, 0xFE,
  0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0, 0xFE, 0x7F,
  0x80, 0x7F, 0x83, 0xF9, 0xFE, 0x03, 0xFE, 0x07, 0xF7, 0xF8, 0x0F, 0xF8,
  0x1F, 0xDF, 0xE0, 0x3F, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0x01, 0xFD, 0xFC,
  0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFF, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x1F, 0xC0,
  0xFF, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0x83,
  0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0xC1, 0xEF, 0x87, 0xF8, 0x3F,
  0xC1, 0xEF, 0x07, 0xF8, 0x3F, 0xC3, 0xEF, 0x07, 0xF0, 0x3F, 0xC3, 0xEF,
  0x07, 0xF0, 0x3F, 0xC3, 0xCF, 0x07, 0xF0, 0x3F, 0x83, 0xCF, 0x0F, 0xF0,
  0x3F, 0x87, 0xCF, 0x0F, 0xE0, 0x3F, 0x87, 0xCF, 0x0F, 0xE0, 0x3F, 0x87,
  0x9F, 0x0F, 0xE0, 0x3F, 0x8F, 0x9F, 0x1F, 0xE0, 0x3F, 0x8F, 0x9F, 0x1F,
  0xC0, 0x3F, 0x8F, 0x9F, 0x1F, 0xC0, 0x3F, 0x8F, 0x1F, 0x1F, 0xC0, 0x3F,
  0x9F, 0x1F, 0x3F, 0xC0, 0x3F, 0x9F, 0x1F, 0x3F, 0x80, 0x7F, 0x9F, 0x1F,
  0x3F, 0x80, 0x7F, 0x9E, 0x1F, 0x3F, 0x80, 0x7F, 0x3E, 0x1F, 0x3F, 0x80,
  0x7F, 0x3E, 0x1F, 0x7F, 0x00, 0x7F, 0x3C, 0x1F, 0x7F, 0x00, 0x7F, 0x7C,
  0x1E, 0x7F, 0x00, 0x7F, 0x7C, 0x1E, 0x7F, 0x00, 0x7F, 0x7C, 0x1E, 0xFE,
  0x00, 0x7F, 0x78, 0x1E, 0xFE, 0x00, 0x7F, 0xF8, 0x1E, 0xFE, 0x00, 0x7F,
  0xF8, 0x1E, 0xFE, 0x00, 0x7F, 0xF8, 0x3E, 0xFC, 0x00, 0x7E, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFD, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xCF,
  0xF8, 0x03, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xFC,
  0x07, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF,
  0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F, 0xE7,
  0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x11, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x5C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xC0,
  0x0F, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xEF, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF,
  0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE,
  0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xF7, 0xFC,
  0x07, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0x9F, 0xFF,
  0x80, 0x7F, 0xEF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFE, 0x07, 0xFD, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x07, 0xF8, 0xFC, 0x0F, 0xC0, 0x3F, 0xCF, 0xF1, 0xFF, 0x01, 0xFC, 0xFF,
  0x9F, 0xFC, 0x0F, 0xEF, 0xFC, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xE1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8, 0x7F, 0x83, 0xF0, 0x7F, 0xC3, 0xFC,
  0x1F, 0x83, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0xFF, 0x0F,
  0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0x07, 0xF8, 0x3F, 0xC1, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x87, 0xF8, 0x3F,
  0x07, 0xF8, 0x3F, 0xC1, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x8F, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFC, 0x07,
  0xFD, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0xE0, 0x01, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0xF8, 0x03, 0xFE,
  0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xFC, 0x03,
  0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xF0, 0x03, 0xFE, 0x3F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF9, 0xFF,
  0x03, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF,
  0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F,
  0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0xFF,
  0x00, 0x7F, 0xCF, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01, 0xFD, 0xFE, 0x07, 0xF8, 0x0F,
  0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0x07, 0xF3, 0xFC, 0x1F,
  0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xFC, 0x1F, 0xC7,
  0xF8, 0x7F, 0xE0, 0xFE, 0x3F, 0xC3, 0xDF, 0x0F, 0xF1, 0xFE, 0x1E, 0xF8,
  0x7F, 0x0F, 0xF1, 0xF7, 0xC3, 0xF8, 0x7F, 0x0F, 0xBE, 0x1F, 0xC3, 0xF8,
  0x79, 0xF1, 0xFE, 0x1F, 0xC3, 0xCF, 0x8F, 0xE0, 0xFE, 0x3E, 0x7C, 0x7F,
  0x07, 0xF1, 0xE3, 0xE7, 0xF8, 0x3F, 0x8F, 0x1F, 0x3F, 0x81, 0xFC, 0xF8,
  0xF9, 0xFC, 0x0F, 0xE7, 0xC7, 0xCF, 0xE0, 0x7F, 0x3C, 0x3E, 0xFE, 0x03,
  0xFB, 0xE1, 0xF7, 0xF0, 0x1F, 0xDF, 0x0F, 0xBF, 0x80, 0xFE, 0xF0, 0x7F,
  0xFC, 0x07, 0xF7, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0xF3, 0xFE, 0x00, 0xFF,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0x01,
  0xFE, 0x7F, 0xFF, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x07, 0xF3, 0xFE, 0x3F,
  0xE1, 0xFE, 0x7F, 0x87, 0xFF, 0x7F, 0xCF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFC,
  0x07, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF1,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 17, 46, 38, 11, -46 },
  { 99, 26, 19, 38, 9, -46 },
  { 161, 39, 46, 38, 0, -46 },
  { 386, 37, 64, 38, 1, -55 },
  { 682, 47, 46, 38, -4, -46 },
  { 953, 37, 48, 38, 0, -47 },
  { 1175, 11, 19, 38, 17, -46 },
  { 1202, 28, 61, 38, 8, -53 },
  { 1416, 28, 61, 38, 3, -53 },
  { 1630, 34, 33, 38, 3, -38 },
  { 1771, 33, 30, 38, 3, -36 },
  { 1895, 20, 20, 38, 4, -10 },
  { 1945, 23, 9, 38, 8, -25 },
  { 1971, 14, 13, 38, 10, -12 },
  { 1994, 41, 59, 38, -1, -52 },
  { 2297, 35, 48, 38, 2, -47 },
  { 2507, 32, 46, 38, 2, -46 },
  { 2691, 35, 47, 38, 2, -47 },
  { 2897, 35, 47, 38, 2, -46 },
  { 3103, 34, 46, 38, 2, -46 },
  { 3299, 35, 47, 38, 2, -46 },
  { 3505, 33, 47, 38, 2, -46 },
  { 3699, 34, 46, 38, 5, -46 },
  { 3895, 35, 48, 38, 2, -47 },
  { 4105, 34, 47, 38, 4, -47 },
  { 4305, 18, 36, 38, 10, -35 },
  { 4386, 23, 45, 38, 5, -35 },
  { 4516, 33, 35, 38, 4, -38 },
  { 4661, 31, 25, 38, 4, -33 },
  { 4758, 33, 35, 38, 2, -38 },
  { 4903, 29, 46, 38, 7, -46 },
  { 5070, 40, 58, 38, -1, -47 },
  { 5360, 34, 46, 38, -1, -46 },
  { 5556, 37, 46, 38, 1, -46 },
  { 5769, 36, 48, 38, 2, -47 },
  { 5985, 37, 46, 38, 1, -46 },
  { 6198, 36, 46, 38, 2, -46 },
  { 6405, 37, 46, 38, 2, -46 },
  { 6618, 36, 48, 38, 2, -47 },
  { 6834, 37, 46, 38, 1, -46 },
  { 7047, 35, 46, 38, 2, -46 },
  { 7249, 37, 47, 38, 0, -46 },
  { 7467, 39, 46, 38, 1, -46 },
  { 7692, 30, 46, 38, 3, -46 },
  { 7865, 40, 46, 38, 0, -46 },
  { 8095, 38, 46, 38, 1, -46 },
  { 8314, 35, 48, 38, 2, -47 },
  { 8524, 38, 46, 38, 1, -46 },
  { 8743, 35, 58, 38, 2, -47 },
  { 8997, 37, 46, 38, 1, -46 },
  { 9210, 37, 48, 38, 1, -47 },
  { 9432, 34, 46, 38, 6, -46 },
  { 9628, 37, 47, 38, 2, -46 },
  { 9846, 35, 46, 38, 6, -46 },
  { 10048, 40, 46, 38, 2, -46 },
  { 10278, 42, 46, 38, -2, -46 },
  { 10520, 36, 46, 38, 5, -46 },
  { 10727, 35, 46, 38, 2, -46 },
  { 10929, 28, 59, 38, 7, -52 },
  { 11136, 22, 59, 38, 9, -52 },
  { 11299, 29, 59, 38, 4, -52 },
  { 11513, 31, 25, 38, 4, -46 },
  { 11610, 32, 8, 38, -1, 2 },
  { 11642, 15, 8, 38, 15, -49 },
  { 11657, 34, 36, 38, 2, -35 },
  { 11810, 35, 47, 38, 1, -46 },
  { 12016, 34, 36, 38, 2, -35 },
  { 12169, 36, 47, 38, 2, -46 },
  { 12381, 33, 36, 38, 2, -35 },
  { 12530, 43, 57, 38, -4, -46 },
  { 12837, 34, 46, 38, 2, -35 },
  { 13033, 34, 46, 38, 1, -46 },
  { 13229, 32, 50, 38, 2, -50 },
  { 13429, 35, 61, 38, 0, -50 },
  { 13696, 37, 46, 38, 2, -46 },
  { 13909, 29, 46, 38, 5, -46 },
  { 14076, 37, 35, 38, 0, -35 },
  { 14238, 34, 35, 38, 1, -35 },
  { 14387, 33, 36, 38, 2, -35 },
  { 14536, 36, 46, 38, 0, -35 },
  { 14743, 34, 46, 38, 2, -35 },
  { 14939, 36, 35, 38, 2, -35 },
  { 15097, 35, 36, 38, 1, -35 },
  { 15255, 32, 44, 38, 4, -44 },
  { 15431, 34, 36, 38, 2, -35 },
  { 15584, 35, 35, 38, 4, -35 },
  { 15738, 37, 35, 38, 3, -35 },
  { 15900, 39, 35, 38, -1, -35 },
  { 16071, 34, 46, 38, 2, -35 },
  { 16267, 33, 35, 38, 2, -35 },
  { 16412, 34, 59, 38, 5, -52 },
  { 16663, 19, 59, 38, 10, -52 },
  { 16804, 34, 59, 38, 1, -52 },
  { 17055, 35, 16, 38, 2, -30 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic63pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC63PT7B_H_
