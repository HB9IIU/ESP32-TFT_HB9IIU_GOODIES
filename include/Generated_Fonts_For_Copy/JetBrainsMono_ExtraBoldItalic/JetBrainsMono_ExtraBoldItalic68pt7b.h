#ifndef _JETBRAINSMONO_EXTRABOLDITALIC68PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0x7F,
  0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x10, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xEF, 0x9F, 0xFE, 0x03, 0xFF, 0x8F, 0x8F, 0xFE, 0x03,
  0xFF, 0x8F, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0x0F, 0xFE, 0x03, 0xFF, 0x0F,
  0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x00,
  0x07, 0xFF, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0x00, 0x00, 0x07, 0xFF,
  0xDE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x7F,
  0xF0, 0x00, 0x00, 0x78, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF9, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF3, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x9F, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0x0F, 0xFF, 0xFF,
  0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF9, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF0,
  0x7F, 0xDF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0xE0, 0x07,
  0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF7, 0xFF, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF,
  0xCF, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x60, 0xFC, 0x07, 0xF0, 0x1F,
  0x87, 0xF0, 0x3F, 0x03, 0xFC, 0x7F, 0xE1, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F,
  0x87, 0xFF, 0x3F, 0xFE, 0x3C, 0xFF, 0xF9, 0xFF, 0xF9, 0xEF, 0xFF, 0xFF,
  0xFF, 0xEE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x0F, 0x03, 0xFE, 0x0F, 0xF8,
  0xFE, 0x1F, 0xF0, 0xFF, 0xCF, 0xF0, 0xFF, 0x87, 0xFE, 0x7F, 0xCF, 0xFC,
  0x3F, 0xF7, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0xFF,
  0x9F, 0xF0, 0x7F, 0xC7, 0xF8, 0xFF, 0x87, 0xFE, 0x1F, 0xC7, 0xFC, 0x3F,
  0xF0, 0x78, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0x01, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0xE0, 0x07, 0xFE, 0x00,
  0x10, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x06, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xFF, 0x00,
  0xFF, 0xEF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFC,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE7,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xDF, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x38, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x70, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xF1, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0x9F, 0xC0, 0x7F, 0x80, 0xFF,
  0xF9, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xDF, 0xC0, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFC, 0xFE, 0x07, 0xF8, 0x0F, 0xFF,
  0x9F, 0xC0, 0x7F, 0x80, 0x7F, 0xF1, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0xFF, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x0F,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFE, 0xF8, 0x1F, 0xBF, 0xC0, 0x3F, 0xDF, 0x83, 0xF7, 0xF8, 0x07,
  0xFB, 0xF0, 0xFC, 0xFF, 0x01, 0xFF, 0x7E, 0x1F, 0xBF, 0xE0, 0x3F, 0xEF,
  0xC7, 0xF7, 0xF8, 0x07, 0xFD, 0xF8, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x3F,
  0x9F, 0xE0, 0x1F, 0xE7, 0xE7, 0xE7, 0xFC, 0x03, 0xFC, 0xFC, 0xFC, 0xFF,
  0x80, 0x7F, 0x8F, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0xE3, 0xFE, 0x03,
  0xFE, 0x3F, 0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8,
  0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xF0, 0x07,
  0xFB, 0xF8, 0x0F, 0xF8, 0x07, 0xFD, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x9F, 0xC0, 0xFF,
  0x80, 0x7F, 0x8F, 0xE0, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xC3, 0xFC,
  0x01, 0xFF, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x07, 0xF9, 0xFF, 0x00, 0xFF,
  0x83, 0xFC, 0xFF, 0x80, 0x7F, 0xC0, 0xFE, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0x9F, 0xF0, 0x0F, 0xF8, 0x1F, 0xEF, 0xF0,
  0x07, 0xFC, 0x0F, 0xF7, 0xF8, 0x07, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFE,
  0x01, 0xFD, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xEF, 0x83, 0xFC, 0x0F, 0xF0,
  0x7D, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xBE, 0x0F, 0xF0, 0x3F, 0xC1, 0xF7,
  0xC1, 0xFE, 0x07, 0xF8, 0x7C, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xBE, 0x0F,
  0xF0, 0x3F, 0xC1, 0xF7, 0xC1, 0xFE, 0x07, 0xF8, 0x3E, 0xF8, 0x3F, 0xC0,
  0xFF, 0x0F, 0x9F, 0x0F, 0xF0, 0x1F, 0xE1, 0xF3, 0xE1, 0xFE, 0x03, 0xFC,
  0x3E, 0x7C, 0x3F, 0xC0, 0x7F, 0x87, 0xCF, 0x87, 0xF8, 0x0F, 0xF1, 0xF1,
  0xF1, 0xFE, 0x01, 0xFE, 0x3E, 0x3E, 0x3F, 0xC0, 0x3F, 0xC7, 0xC7, 0xC7,
  0xF8, 0x07, 0xF9, 0xF8, 0xF8, 0xFF, 0x00, 0xFF, 0x3E, 0x1F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xC3, 0xE7, 0xF8, 0x03, 0xF8, 0xF8, 0x7C, 0xFF, 0x00, 0x7F,
  0x3F, 0x0F, 0x9F, 0xC0, 0x0F, 0xE7, 0xC1, 0xF3, 0xF8, 0x01, 0xFC, 0xF8,
  0x3E, 0xFF, 0x00, 0x7F, 0x9F, 0x07, 0xDF, 0xE0, 0x0F, 0xF7, 0xC1, 0xF3,
  0xF8, 0x01, 0xFE, 0xF8, 0x3E, 0x7F, 0x00, 0x3F, 0xDF, 0x07, 0xCF, 0xE0,
  0x07, 0xFB, 0xE0, 0xFB, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0x7F, 0x00, 0x1F,
  0xDF, 0x03, 0xEF, 0xE0, 0x03, 0xFB, 0xE0, 0x7D, 0xFC, 0x00, 0x7F, 0x7C,
  0x0F, 0xBF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F,
  0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE7, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xDF, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF,
  0xFF, 0x01, 0xFF, 0xBF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x81, 0xFF,
  0x80, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFF, 0xC7, 0xFE, 0x00, 0x7F,
  0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xF9, 0xFF, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xF3, 0xFF,
  0x03, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFB,
  0xFF, 0x03, 0xFF, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xE7, 0xFE, 0x00, 0xFF,
  0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xFF,
  0x00, 0x7F, 0xE7, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0x07, 0xFD,
  0xFF, 0x8F, 0xFE, 0x07, 0xFB, 0xFF, 0x9F, 0xFE, 0x07, 0xFB, 0xFF, 0xBF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFC, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0x07, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x1F, 0xE0,
  0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0xF0,
  0x07, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFE, 0x00,
  0x7F, 0xE7, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF, 0xF0, 0x07, 0xFD, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFD, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0xFF, 0x80, 0xFF, 0xDF,
  0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0x00,
  0x3F, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x01,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xFF,
  0x3F, 0xF0, 0x1F, 0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF,
  0xC3, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x81,
  0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xDF, 0x07, 0xF8, 0xFF, 0x07, 0xDF,
  0x07, 0xF8, 0xFF, 0x07, 0xDF, 0x07, 0xF0, 0xFF, 0x07, 0x9F, 0x0F, 0xF0,
  0xFF, 0x0F, 0x9F, 0x0F, 0xF0, 0xFF, 0x0F, 0x9F, 0x0F, 0xF0, 0xFF, 0x0F,
  0x9F, 0x1F, 0xE0, 0xFF, 0x1F, 0x1F, 0x1F, 0xE0, 0xFF, 0x1F, 0x1F, 0x1F,
  0xE0, 0xFF, 0x1F, 0x1F, 0x3F, 0xC0, 0xFF, 0x1E, 0x1F, 0x3F, 0xC0, 0xFF,
  0x3E, 0x1F, 0x3F, 0xC0, 0xFF, 0x3E, 0x1F, 0x3F, 0x80, 0xFF, 0x3E, 0x1F,
  0x7F, 0x80, 0xFF, 0x7C, 0x1F, 0x7F, 0x80, 0xFF, 0x7C, 0x1F, 0x7F, 0x00,
  0xFF, 0x7C, 0x1F, 0xFF, 0x00, 0xFF, 0x78, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xE7, 0xFE, 0x01, 0xFF,
  0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0xFE, 0x00, 0xFF,
  0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF,
  0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0xE7, 0xFF, 0x07, 0xF9,
  0xFF, 0x0F, 0xFE, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xFF, 0x87,
  0xF8, 0x03, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 19, 50, 41, 12, -50 },
  { 120, 28, 21, 41, 10, -50 },
  { 194, 43, 50, 41, 0, -50 },
  { 463, 40, 69, 41, 1, -59 },
  { 808, 51, 50, 41, -4, -50 },
  { 1127, 40, 51, 41, 0, -50 },
  { 1382, 12, 21, 41, 18, -50 },
  { 1414, 30, 66, 41, 9, -57 },
  { 1662, 30, 66, 41, 3, -57 },
  { 1910, 37, 35, 41, 3, -41 },
  { 2072, 34, 33, 41, 4, -39 },
  { 2213, 21, 21, 41, 5, -10 },
  { 2269, 26, 9, 41, 8, -27 },
  { 2299, 15, 14, 41, 11, -13 },
  { 2326, 44, 63, 41, -1, -56 },
  { 2673, 37, 51, 41, 3, -50 },
  { 2909, 35, 50, 41, 2, -50 },
  { 3128, 38, 50, 41, 2, -50 },
  { 3366, 38, 51, 41, 2, -50 },
  { 3609, 37, 50, 41, 2, -50 },
  { 3841, 38, 51, 41, 2, -50 },
  { 4084, 36, 51, 41, 2, -50 },
  { 4314, 37, 50, 41, 5, -50 },
  { 4546, 38, 51, 41, 2, -50 },
  { 4789, 36, 50, 41, 5, -50 },
  { 5014, 19, 39, 41, 11, -38 },
  { 5107, 25, 49, 41, 5, -38 },
  { 5261, 35, 38, 41, 5, -41 },
  { 5428, 34, 27, 41, 4, -36 },
  { 5543, 35, 38, 41, 2, -41 },
  { 5710, 31, 50, 41, 8, -50 },
  { 5904, 44, 62, 41, -1, -50 },
  { 6245, 37, 50, 41, -1, -50 },
  { 6477, 40, 50, 41, 1, -50 },
  { 6727, 38, 51, 41, 3, -50 },
  { 6970, 40, 50, 41, 1, -50 },
  { 7220, 39, 50, 41, 2, -50 },
  { 7464, 40, 50, 41, 2, -50 },
  { 7714, 38, 51, 41, 3, -50 },
  { 7957, 40, 50, 41, 1, -50 },
  { 8207, 38, 50, 41, 2, -50 },
  { 8445, 40, 51, 41, 0, -50 },
  { 8700, 43, 50, 41, 1, -50 },
  { 8969, 32, 50, 41, 3, -50 },
  { 9169, 43, 50, 41, 0, -50 },
  { 9438, 41, 50, 41, 1, -50 },
  { 9695, 37, 51, 41, 3, -50 },
  { 9931, 41, 50, 41, 1, -50 },
  { 10188, 37, 62, 41, 3, -50 },
  { 10475, 40, 50, 41, 1, -50 },
  { 10725, 40, 51, 41, 1, -50 },
  { 10980, 37, 50, 41, 6, -50 },
  { 11212, 40, 51, 41, 2, -50 },
  { 11467, 37, 50, 41, 7, -50 },
  { 11699, 43, 50, 41, 2, -50 },
  { 11968, 45, 50, 41, -2, -50 },
  { 12250, 39, 50, 41, 6, -50 },
  { 12494, 38, 50, 41, 2, -50 },
  { 12732, 31, 63, 41, 7, -56 },
  { 12977, 24, 63, 41, 9, -56 },
  { 13166, 31, 63, 41, 4, -56 },
  { 13411, 32, 27, 41, 5, -50 },
  { 13519, 34, 9, 41, -1, 2 },
  { 13558, 16, 9, 41, 16, -53 },
  { 13576, 37, 39, 41, 2, -38 },
  { 13757, 37, 51, 41, 1, -50 },
  { 13993, 36, 39, 41, 3, -38 },
  { 14169, 39, 51, 41, 2, -50 },
  { 14418, 35, 39, 41, 3, -38 },
  { 14589, 46, 62, 41, -4, -50 },
  { 14946, 36, 50, 41, 3, -38 },
  { 15171, 37, 50, 41, 1, -50 },
  { 15403, 35, 54, 41, 2, -54 },
  { 15640, 38, 66, 41, 0, -54 },
  { 15954, 40, 50, 41, 2, -50 },
  { 16204, 32, 50, 41, 5, -50 },
  { 16404, 40, 38, 41, 0, -38 },
  { 16594, 37, 38, 41, 1, -38 },
  { 16770, 35, 39, 41, 3, -38 },
  { 16941, 38, 50, 41, 0, -38 },
  { 17179, 37, 50, 41, 2, -38 },
  { 17411, 38, 38, 41, 3, -38 },
  { 17592, 38, 39, 41, 1, -38 },
  { 17778, 35, 48, 41, 4, -48 },
  { 17988, 36, 38, 41, 3, -37 },
  { 18159, 37, 37, 41, 5, -37 },
  { 18331, 40, 37, 41, 3, -37 },
  { 18516, 42, 37, 41, -1, -37 },
  { 18711, 36, 49, 41, 3, -37 },
  { 18932, 36, 37, 41, 2, -37 },
  { 19099, 37, 64, 41, 5, -56 },
  { 19395, 20, 63, 41, 11, -56 },
  { 19553, 36, 64, 41, 1, -56 },
  { 19841, 38, 18, 41, 2, -33 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC68PT7B_H_
