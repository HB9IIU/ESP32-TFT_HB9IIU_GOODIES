#ifndef _JETBRAINSMONO_EXTRABOLDITALIC28PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x79, 0xF7, 0x9E,
  0x79, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0x01, 0xC3, 0x80,
  0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x30, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0xE1, 0xC0, 0x38, 0xE0, 0x0E,
  0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0xDE, 0x3C, 0x9E,
  0x3D, 0x80, 0x3D, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFC, 0x03, 0x7C, 0x03, 0x3C, 0xF3, 0x3C, 0xF3, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x08, 0x3F, 0x03, 0x83, 0xFC, 0x1C, 0x1C, 0xE1,
  0xC0, 0xC7, 0x1C, 0x0E, 0x39, 0xC0, 0x71, 0xDC, 0x03, 0xFD, 0xC0, 0x0F,
  0xFC, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xF8,
  0x00, 0xEF, 0xE0, 0x0E, 0xE7, 0x00, 0xE7, 0x38, 0x0E, 0x31, 0xC0, 0xE3,
  0x8E, 0x07, 0x1E, 0xF0, 0x70, 0x7F, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x70,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xCF, 0x7B, 0xDE,
  0x79, 0xFE, 0x79, 0xFC, 0x78, 0xF8, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0x9E, 0x7B, 0xDE, 0xF7, 0xBB, 0xDE, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x07, 0x00, 0x10, 0x08, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x18, 0x01, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x01, 0x0E, 0x17, 0x98, 0xEF, 0xB7,
  0xFF, 0xDF, 0x9F, 0xFC, 0x03, 0x80, 0x1D, 0xC0, 0x7B, 0x81, 0xE7, 0x87,
  0x8F, 0x87, 0x0C, 0x04, 0x10, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFC, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1F, 0x8F, 0x8F, 0x87, 0xC3,
  0xC3, 0xC1, 0xE1, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0x7F, 0xE0, 0x7B, 0xEF,
  0xBE, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83,
  0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF7, 0x3D, 0xEF, 0x7B, 0xDF, 0xE7,
  0x9B, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xF9, 0xF1, 0xFF,
  0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3C, 0xF0, 0xE7, 0xC2, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xE3, 0xE7, 0x83, 0xDF, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xBC, 0x0F,
  0x78, 0x3E, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x3C, 0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xDF, 0xFF,
  0xBF, 0xFE, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0xFC, 0x3F, 0xFC, 0x7F, 0xF9, 0xF1, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x7C, 0x3C, 0xFC, 0xF8, 0xFF, 0xE1, 0xFF, 0x81,
  0xFE, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF8, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xC1, 0xFF,
  0x83, 0xDF, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x3E, 0x7C, 0x3F,
  0xF0, 0x3F, 0x80, 0xFF, 0xC3, 0xEF, 0x8F, 0x0F, 0xBE, 0x0F, 0x78, 0x1E,
  0xF0, 0x7D, 0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0xC0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1E, 0xF0, 0x3D, 0xF0, 0xF9, 0xFF, 0xE3, 0xFB, 0xC3, 0xEF, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1C, 0x7D, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x8F, 0x9F, 0x3E, 0x78, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x0F, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0x7F, 0xFD, 0xFF,
  0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFC, 0x87, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x1F, 0xE1,
  0xFF, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE1, 0xCE,
  0x78, 0xFB, 0x9E, 0x7F, 0xE7, 0x1C, 0x79, 0xCF, 0x1E, 0x73, 0xC7, 0x1C,
  0xE1, 0xCF, 0x38, 0x73, 0xCE, 0x3C, 0xF3, 0x8F, 0x38, 0xFF, 0xCE, 0x3E,
  0xE3, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x84, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xDC, 0x03, 0xDE, 0x03, 0xDE, 0x03, 0x9E, 0x07, 0x9E, 0x07,
  0x9E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E,
  0x1E, 0x3C, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x1F, 0xFC, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF8, 0x78, 0x7C, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C,
  0x1F, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x3C, 0xF8, 0x7C, 0xFC,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3C, 0x7E, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8,
  0x3C, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x04, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1F, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0xFE, 0x79, 0xFE, 0x79, 0xFC, 0x78, 0x3C, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFC, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xC0, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x41, 0xE3, 0xC0, 0xF1, 0xF0, 0xF8, 0xFC, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x03, 0xF8, 0x00, 0x1E, 0x0F, 0x8F, 0x0F, 0x8F, 0x87, 0x87, 0x87,
  0xC3, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1,
  0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x80, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x1F, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1B, 0x8F, 0xEF, 0xE3,
  0xFB, 0x78, 0xEF, 0xDC, 0x3B, 0xF7, 0x0E, 0x7B, 0xC7, 0x9E, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0x0F, 0x87, 0x8F, 0xC3, 0xC7,
  0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0x70, 0xFE, 0x78, 0x77, 0x3C, 0x7B, 0x9E,
  0x3D, 0xCF, 0x1E, 0xE7, 0x8F, 0x7B, 0x87, 0x9D, 0xC3, 0x8E, 0xE3, 0xC7,
  0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78, 0xFC, 0x3C, 0x3E, 0x1C, 0x1F, 0x1E,
  0x0F, 0x80, 0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1,
  0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x79, 0xF9, 0xF1,
  0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF,
  0x3C, 0x3F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x3E,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x7C, 0x1E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x79, 0xFB, 0xF1, 0xFF, 0xC3, 0xFF, 0x01,
  0xFC, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x3C, 0x3F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C,
  0x1E, 0x3C, 0x1E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x79,
  0xE0, 0x79, 0xE0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E,
  0x1E, 0x3C, 0x1E, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xFC, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0x83, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xFC, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83,
  0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0x79, 0xF0, 0xF3, 0xC1,
  0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x79, 0xE3, 0xDE, 0x78, 0xE7,
  0x1E, 0x79, 0xC7, 0x9E, 0x73, 0x67, 0x1C, 0xD9, 0xC7, 0x36, 0xF1, 0xCD,
  0xB8, 0x76, 0xEE, 0x1D, 0xBB, 0x87, 0x6C, 0xE3, 0xDB, 0x70, 0xFC, 0xDC,
  0x3F, 0x37, 0x0E, 0xCD, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x83, 0xC3, 0xC0, 0x0F, 0x83, 0xE0, 0xF0, 0xF8, 0x1E, 0x3E, 0x03,
  0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xEF, 0x00, 0xF9, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xC1, 0xF0,
  0x78, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x3C, 0x3C,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE1,
  0xEF, 0x0F, 0x78, 0xF1, 0xC7, 0x8F, 0x78, 0x7F, 0xC3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xF1, 0xE7, 0x8F, 0x03, 0x00, 0x1F, 0xBC,
  0x7F, 0x79, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x3D, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3, 0xCF, 0xCF, 0x9F, 0xFF, 0x1F, 0xDE,
  0x1F, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC6, 0x07,
  0xBF, 0x0F, 0xFF, 0x1F, 0xFE, 0x7C, 0x3E, 0xF8, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x3E, 0xFC, 0xF9, 0xFF, 0xF3,
  0xFF, 0xC7, 0xBF, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xC3, 0xEF, 0x07, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC3, 0xEF, 0xCF, 0x8F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x03, 0x1E, 0x0F, 0xDE, 0x1F, 0xDE,
  0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xFC, 0xF8, 0xFF, 0xF8, 0x7F, 0x78,
  0x3E, 0x78, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x0F, 0x3F, 0xFE, 0x7F, 0xFD, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x87, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xBC,
  0x7F, 0x79, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x3D, 0xF0, 0x7B, 0xE1, 0xF7, 0xFF, 0xC7, 0xFF, 0x8F, 0xEF, 0x0F, 0x9E,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC6, 0x07, 0xBF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x7C, 0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0xBE, 0x1F, 0x7C, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x1F, 0x3C,
  0x3E, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x79, 0xF0, 0xF8, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0,
  0x01, 0x86, 0x1F, 0xEF, 0x8E, 0xFF, 0xC7, 0xBD, 0xE3, 0x8C, 0x71, 0xCE,
  0x79, 0xE7, 0x3C, 0xF3, 0x9E, 0x79, 0xCF, 0x3C, 0xE7, 0x1C, 0x73, 0x8E,
  0x71, 0xCF, 0x39, 0xE7, 0x9C, 0xF3, 0xCE, 0x79, 0xE7, 0x3C, 0x00, 0x60,
  0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3, 0xEF, 0x07, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xE0,
  0xF7, 0xC3, 0xCF, 0xCF, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x30,
  0x1E, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3C, 0x7E, 0x7C,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7B, 0xF0, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x1F, 0xBC, 0x7F, 0x79, 0xFE, 0xF7,
  0xC3, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xE1,
  0xF7, 0xC3, 0xCF, 0xCF, 0x9F, 0xFF, 0x1F, 0xDE, 0x1F, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x30, 0x3D, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7,
  0xC3, 0xEF, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00,
  0xF0, 0x01, 0xEF, 0x07, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x7B, 0xE1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x3D, 0xF0, 0xFB, 0xE1, 0xE3, 0xE7, 0xC7, 0xFF, 0x0F, 0xFC, 0x07,
  0xF0, 0x00, 0xF0, 0x3F, 0xE0, 0x7B, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F,
  0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xF1, 0xC7, 0xF8, 0xE3, 0xBC,
  0xF1, 0xDE, 0x79, 0xEF, 0x3C, 0xE7, 0xB6, 0x73, 0xDB, 0x79, 0xED, 0xB8,
  0xFC, 0xDC, 0x7E, 0x7E, 0x3B, 0x3E, 0x1D, 0x9F, 0x0F, 0x8F, 0x87, 0xC7,
  0x83, 0xE3, 0xC0, 0x1F, 0x0F, 0xC3, 0xE3, 0xC0, 0x79, 0xF0, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7C, 0xF0, 0x1E, 0x3E, 0x0F, 0x07, 0x8F, 0xC1,
  0xF0, 0x3C, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xFF, 0xE3, 0xFF, 0xC7,
  0xF7, 0x83, 0xCF, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x83, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x00,
  0x3F, 0x0E, 0xFF, 0x1D, 0xFE, 0x3F, 0x9F, 0xFF, 0x3F, 0xDC, 0x3F, 0x80,
  0x1C, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 20, 17, 5, -20 },
  { 21, 12, 8, 17, 4, -20 },
  { 33, 18, 20, 17, 0, -20 },
  { 78, 16, 28, 17, 1, -24 },
  { 134, 21, 21, 17, -2, -21 },
  { 190, 16, 21, 17, 0, -21 },
  { 232, 5, 8, 17, 7, -20 },
  { 237, 12, 28, 17, 4, -24 },
  { 279, 13, 28, 17, 1, -24 },
  { 325, 15, 15, 17, 1, -17 },
  { 354, 15, 13, 17, 1, -16 },
  { 379, 9, 8, 17, 2, -4 },
  { 388, 11, 4, 17, 3, -11 },
  { 394, 6, 5, 17, 5, -5 },
  { 398, 18, 26, 17, 0, -23 },
  { 457, 15, 21, 17, 1, -21 },
  { 497, 14, 20, 17, 1, -20 },
  { 532, 15, 21, 17, 1, -21 },
  { 572, 15, 20, 17, 1, -20 },
  { 610, 15, 20, 17, 1, -20 },
  { 648, 15, 20, 17, 1, -20 },
  { 686, 15, 20, 17, 1, -20 },
  { 724, 15, 20, 17, 2, -20 },
  { 762, 15, 21, 17, 1, -21 },
  { 802, 15, 21, 17, 2, -21 },
  { 842, 7, 16, 17, 5, -16 },
  { 856, 10, 20, 17, 2, -16 },
  { 881, 14, 16, 17, 2, -17 },
  { 909, 14, 11, 17, 2, -15 },
  { 929, 14, 16, 17, 1, -17 },
  { 957, 13, 20, 17, 3, -20 },
  { 990, 18, 26, 17, 0, -21 },
  { 1049, 16, 20, 17, -1, -20 },
  { 1089, 16, 20, 17, 1, -20 },
  { 1129, 16, 21, 17, 1, -21 },
  { 1171, 16, 20, 17, 1, -20 },
  { 1211, 16, 20, 17, 1, -20 },
  { 1251, 16, 20, 17, 1, -20 },
  { 1291, 16, 21, 17, 1, -21 },
  { 1333, 16, 20, 17, 1, -20 },
  { 1373, 16, 20, 17, 1, -20 },
  { 1413, 17, 20, 17, 0, -20 },
  { 1456, 17, 20, 17, 1, -20 },
  { 1499, 14, 20, 17, 1, -20 },
  { 1534, 18, 20, 17, 0, -20 },
  { 1579, 17, 20, 17, 0, -20 },
  { 1622, 15, 21, 17, 1, -21 },
  { 1662, 16, 20, 17, 1, -20 },
  { 1702, 15, 26, 17, 1, -21 },
  { 1751, 16, 20, 17, 1, -20 },
  { 1791, 16, 21, 17, 1, -21 },
  { 1833, 16, 20, 17, 2, -20 },
  { 1873, 16, 20, 17, 1, -20 },
  { 1913, 15, 20, 17, 3, -20 },
  { 1951, 18, 20, 17, 1, -20 },
  { 1996, 19, 20, 17, -1, -20 },
  { 2044, 16, 20, 17, 2, -20 },
  { 2084, 15, 20, 17, 1, -20 },
  { 2122, 13, 26, 17, 3, -23 },
  { 2165, 10, 26, 17, 4, -23 },
  { 2198, 12, 26, 17, 2, -23 },
  { 2237, 13, 10, 17, 2, -20 },
  { 2254, 14, 4, 17, 0, 1 },
  { 2261, 6, 4, 17, 7, -22 },
  { 2264, 15, 16, 17, 1, -16 },
  { 2294, 15, 20, 17, 1, -20 },
  { 2332, 15, 16, 17, 1, -16 },
  { 2362, 16, 20, 17, 1, -20 },
  { 2402, 15, 16, 17, 1, -16 },
  { 2432, 19, 25, 17, -2, -20 },
  { 2492, 15, 21, 17, 1, -16 },
  { 2532, 15, 20, 17, 1, -20 },
  { 2570, 14, 22, 17, 1, -22 },
  { 2609, 16, 27, 17, 0, -22 },
  { 2663, 16, 20, 17, 1, -20 },
  { 2703, 13, 20, 17, 2, -20 },
  { 2736, 17, 16, 17, 0, -16 },
  { 2770, 15, 16, 17, 1, -16 },
  { 2800, 15, 16, 17, 1, -16 },
  { 2830, 16, 21, 17, 0, -16 },
  { 2872, 15, 21, 17, 1, -16 },
  { 2912, 16, 16, 17, 1, -16 },
  { 2944, 15, 16, 17, 1, -16 },
  { 2974, 14, 20, 17, 2, -20 },
  { 3009, 15, 15, 17, 1, -15 },
  { 3038, 15, 15, 17, 2, -15 },
  { 3067, 17, 15, 17, 1, -15 },
  { 3099, 18, 15, 17, -1, -15 },
  { 3133, 15, 20, 17, 1, -15 },
  { 3171, 15, 15, 17, 1, -15 },
  { 3200, 15, 26, 17, 2, -23 },
  { 3249, 8, 26, 17, 5, -23 },
  { 3275, 15, 26, 17, 0, -23 },
  { 3324, 15, 7, 17, 1, -13 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC28PT7B_H_
