#ifndef _JETBRAINSMONO_EXTRABOLDITALIC21PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0xB9, 0xCE, 0x73, 0x00, 0x0E, 0x73, 0x80, 0x73,
  0xBB, 0xB9, 0xDC, 0xEE, 0x77, 0x38, 0x07, 0x38, 0x31, 0x81, 0x8C, 0x7F,
  0xF3, 0xFF, 0x86, 0x30, 0x73, 0x03, 0x18, 0x18, 0xC7, 0xFF, 0xBF, 0xF8,
  0x63, 0x07, 0x30, 0x31, 0x81, 0x9C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x1F, 0xC1, 0xFF, 0x1E, 0xB8, 0xED, 0xC7, 0x60, 0x3E, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xC0, 0x6E, 0x03, 0x71, 0xDB, 0x8F, 0xFC, 0x7F, 0xC1, 0xFC,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1F, 0x0E, 0x37, 0x18, 0xCE, 0x61,
  0x99, 0x83, 0x36, 0x07, 0xF8, 0x03, 0x60, 0x01, 0xC0, 0x07, 0x70, 0x0F,
  0xF0, 0x36, 0x60, 0xCC, 0xC3, 0x19, 0x8C, 0x3E, 0x30, 0x78, 0x00, 0x01,
  0x00, 0x7E, 0x0F, 0xE1, 0xCE, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xE0, 0x7E,
  0x77, 0x77, 0x77, 0xE6, 0x3C, 0xE3, 0xCF, 0x3C, 0x7F, 0xC7, 0xEE, 0xFF,
  0xFD, 0x80, 0x00, 0x81, 0xC3, 0xE3, 0xE3, 0xC1, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0x80, 0x40, 0x10, 0x0E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x3E, 0x3E, 0x1C,
  0x08, 0x00, 0x07, 0x00, 0xE0, 0x18, 0x33, 0x3F, 0x5F, 0xFF, 0xC3, 0x80,
  0xD8, 0x3B, 0x8E, 0x70, 0x8C, 0x00, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x1E, 0x03, 0x80, 0x1E, 0x38, 0xE1, 0xC7,
  0x1E, 0x00, 0xFF, 0xFF, 0xF8, 0x73, 0xDE, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x9C, 0x77, 0x0E, 0xE1, 0xDC,
  0x3B, 0xF7, 0x6E, 0xFC, 0x9B, 0x87, 0x70, 0xEE, 0x1D, 0xFF, 0x1F, 0xE1,
  0xF0, 0x0F, 0x87, 0xE3, 0xF8, 0xDE, 0x67, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0xF8, 0xFF,
  0xBC, 0xF7, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xFF, 0xBF, 0xF7, 0xFE, 0x3F, 0xE7, 0xFC, 0x07, 0x81, 0xC0,
  0x70, 0x1E, 0x03, 0xF0, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x70, 0xEF, 0x7D,
  0xFF, 0x1F, 0x80, 0x01, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x7B, 0x8E, 0xE1, 0xDF, 0xFB, 0xFF, 0x7F, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9C, 0x07, 0x00, 0xEF, 0x1F, 0xF3, 0xDE, 0x01,
  0xC0, 0x38, 0x07, 0x70, 0xEF, 0xF9, 0xFF, 0x1F, 0x80, 0x03, 0xC0, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1F, 0xF3, 0xFE, 0xF1, 0xFC, 0x3F, 0x87,
  0x70, 0xEF, 0x7D, 0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEE,
  0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80,
  0xE0, 0x3C, 0x00, 0x01, 0x80, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x73, 0x87,
  0x3C, 0xE1, 0xFC, 0x1F, 0xC3, 0xDE, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0xBE,
  0x7F, 0xC3, 0xF8, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x9E, 0x7F, 0xC3, 0xDC, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1C, 0x07, 0x80, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x31, 0xE7, 0x9C,
  0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0xE3, 0xC7, 0x1C,
  0x38, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x8F, 0xE7, 0xE0, 0xF0, 0x1C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x00, 0x40, 0x7F, 0xEF, 0xF9, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xBF, 0xF7, 0xFE, 0x40, 0x0E, 0x01, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0x80, 0xF0, 0x7E, 0x7F, 0x1F, 0x83, 0x80, 0x40, 0x00, 0x3F,
  0x0F, 0xE7, 0xFC, 0x0F, 0x03, 0xC0, 0xE3, 0xF8, 0xFC, 0x3C, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x7F, 0x87, 0xFC, 0x70,
  0x73, 0x03, 0xB8, 0x1D, 0xCF, 0xEC, 0xEF, 0x66, 0x33, 0x31, 0xB9, 0x8D,
  0xDC, 0xEE, 0xE7, 0x73, 0xDB, 0x1D, 0x9C, 0x00, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xEC, 0x39, 0x87,
  0x30, 0xE6, 0x38, 0xE7, 0xFD, 0xFF, 0xBF, 0xF7, 0x0F, 0xC1, 0xF8, 0x38,
  0x1F, 0xE0, 0xFF, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xFF, 0x07,
  0xF8, 0x79, 0xE3, 0x87, 0x9C, 0x3C, 0xE1, 0xC7, 0xFE, 0x3F, 0xE3, 0xFC,
  0x00, 0x03, 0x01, 0xFC, 0x3F, 0xE3, 0x8E, 0x70, 0xE7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xCF, 0xFC, 0x7F, 0x83,
  0xE0, 0x1F, 0xE0, 0xFF, 0x8F, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1,
  0xC7, 0x0E, 0x78, 0x73, 0x87, 0x9C, 0x38, 0xE3, 0xC7, 0xFC, 0x3F, 0xE3,
  0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x7F,
  0xC7, 0xFC, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xFF, 0xCF, 0xF8, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0x3F, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xC7,
  0xFC, 0x7F, 0xCF, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x01, 0xFC, 0x3F, 0xE3, 0x8E, 0x70, 0xE7, 0x00, 0x70, 0x07, 0x00,
  0x77, 0xEF, 0x7E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xE0,
  0x1C, 0x78, 0xE3, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xC7,
  0xFC, 0x78, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xF3, 0xC7,
  0x00, 0x3F, 0xE7, 0xFC, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x1C, 0x38, 0xE3,
  0x8F, 0x3C, 0x71, 0xC3, 0x9E, 0x1C, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83,
  0x9E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xF3, 0xC3, 0x80, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x69, 0xF3,
  0x7B, 0x3B, 0xD9, 0xDF, 0xCE, 0xEE, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x83, 0x80, 0x1E, 0x39, 0xF1, 0xCF, 0x8C, 0x7C,
  0xE3, 0xE7, 0x1F, 0x38, 0xDD, 0xC6, 0xEE, 0x73, 0x63, 0x9B, 0x1C, 0xD8,
  0xE7, 0xC7, 0x3E, 0x30, 0xF3, 0x87, 0x80, 0x03, 0x03, 0xF8, 0xFF, 0x9C,
  0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xFE, 0x3B, 0x87, 0x70, 0xEE,
  0x1D, 0xFF, 0x1F, 0xE1, 0xF0, 0x1F, 0xE0, 0xFF, 0x8F, 0xFE, 0x70, 0xF3,
  0x83, 0x9C, 0x38, 0xE3, 0xC7, 0xFC, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x9C, 0x77,
  0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xFE, 0x3B, 0x87, 0x70, 0xEE, 0x1D,
  0xFF, 0x1F, 0xE1, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1F, 0xE0,
  0xFF, 0x8F, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xC7, 0xFC, 0x7F,
  0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0xC3, 0x80, 0x01,
  0x80, 0x7F, 0x07, 0xFC, 0x78, 0xE3, 0x87, 0x1C, 0x00, 0xF0, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x00, 0x38, 0x01, 0xC7, 0x0E, 0x3F, 0xF1, 0xFF, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x38, 0x77,
  0x8F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xCE,
  0x1C, 0xE1, 0xCE, 0x1C, 0xFF, 0x87, 0xF8, 0x3E, 0x00, 0xE0, 0xFE, 0x0E,
  0xE1, 0xCE, 0x1C, 0xF1, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x67, 0x3B, 0x39, 0x99,
  0xCD, 0xCE, 0xEE, 0xF7, 0x77, 0xB3, 0xAD, 0x9F, 0x6C, 0xDB, 0xE6, 0x9E,
  0x34, 0xB1, 0xE5, 0x8F, 0x3C, 0x71, 0xC3, 0x8E, 0x00, 0x1E, 0x3C, 0x38,
  0xE0, 0xE7, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0xCF, 0x07, 0x00,
  0xE0, 0xFF, 0x1E, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x3F, 0x03, 0xE0,
  0x3C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x00, 0x3F,
  0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0xFD, 0xFF, 0x3F, 0xE0, 0x1F, 0xC7, 0xE1, 0xF8,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x7E, 0x1F, 0x8F, 0xE0, 0xE1, 0xC3, 0xC3, 0x87,
  0x0E, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1C,
  0x38, 0x1F, 0xC7, 0xF1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x7E, 0x1F, 0x8F,
  0xE0, 0x07, 0x81, 0xF0, 0x36, 0x0E, 0xC3, 0x9C, 0x73, 0x9C, 0x77, 0x87,
  0xFF, 0xFF, 0xF0, 0xF3, 0xC0, 0x0C, 0xE7, 0xDD, 0xFF, 0xB8, 0xF7, 0x1D,
  0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDF, 0xFB, 0xFF, 0x3D, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x9C, 0x3B, 0xE3, 0xFF, 0x38, 0xF3, 0x8F, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x7F, 0xE7, 0xFC, 0xF7, 0x80, 0x0F, 0x07, 0xF9,
  0xFF, 0xB8, 0xF7, 0x0F, 0xE0, 0x38, 0x07, 0x00, 0xE1, 0xDF, 0xF9, 0xFE,
  0x1F, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xCE, 0x3E, 0xE7, 0xFE, 0x71,
  0xE7, 0x1C, 0xF1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xFF, 0xCF, 0xFC, 0x7B,
  0x80, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0xF7, 0x0F, 0xFF, 0xBF, 0xF7, 0x00,
  0xE0, 0x1E, 0x79, 0xFE, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0x00, 0x00, 0x0C, 0xE7, 0xDD, 0xFF, 0xB8, 0xF7, 0x1D, 0xE3,
  0xB8, 0x77, 0x0E, 0xF3, 0xDF, 0xB9, 0xFF, 0x01, 0xC0, 0x38, 0xFF, 0x1F,
  0xC3, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x9C, 0x3B, 0xE3, 0xFE, 0x38,
  0xF3, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1,
  0xC0, 0x01, 0x01, 0xE0, 0x78, 0x0C, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x47,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x60, 0x0F, 0x00, 0xE0, 0x04, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x7F, 0x0F, 0xE0, 0xFC, 0x00, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x0F, 0x70, 0xE7, 0x1E, 0x73, 0xC7, 0x38, 0x7F, 0x0F, 0xF0, 0xE7, 0x0E,
  0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xC0, 0xFE, 0x7E, 0x3F, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF9, 0xFC, 0x7E, 0x36,
  0x63, 0xFF, 0x7F, 0x77, 0x37, 0x77, 0x77, 0x67, 0x76, 0x76, 0x67, 0x66,
  0x6E, 0x66, 0xE6, 0xEE, 0xEE, 0x39, 0xC3, 0xBE, 0x3F, 0xE3, 0x8F, 0x38,
  0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xEF, 0x1C, 0x0F,
  0x07, 0xF9, 0xFF, 0x38, 0xF7, 0x1F, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDF,
  0xF1, 0xFE, 0x1F, 0x00, 0x39, 0xC3, 0xBE, 0x3F, 0xF3, 0x8F, 0x38, 0xF7,
  0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0xFE, 0x7F, 0xC7, 0x78, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x0C, 0xE7, 0xDD, 0xFF, 0xB8, 0xF7, 0x1D, 0xE3,
  0xB8, 0x77, 0x0E, 0xE1, 0xDF, 0xFB, 0xFF, 0x3D, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x3B, 0x87, 0x7E, 0x7F, 0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xC1, 0xFE, 0x3F,
  0xF3, 0x87, 0x38, 0x03, 0xF8, 0x1F, 0xE0, 0x0E, 0x00, 0xE7, 0x1E, 0x7F,
  0xC3, 0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xFC, 0x3F, 0x03, 0xE0, 0x70,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1F, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDF,
  0xF1, 0xFE, 0x1F, 0x00, 0xF0, 0x77, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7,
  0x3C, 0x7B, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0xE6, 0x3E,
  0x63, 0xEE, 0x7E, 0xE6, 0xCA, 0x6C, 0xAE, 0xDA, 0xCD, 0x2C, 0xD3, 0xCF,
  0x3C, 0xF3, 0x8E, 0x38, 0x38, 0x79, 0xE7, 0x87, 0x38, 0x3B, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xCE, 0x1C, 0x71, 0xE3, 0xC0,
  0x70, 0xEE, 0x1D, 0xC7, 0xB8, 0xEF, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xFF,
  0xDF, 0xF9, 0xEE, 0x01, 0xC0, 0x38, 0xFF, 0x1F, 0xC7, 0xE0, 0x3F, 0xEF,
  0xFD, 0xFF, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0xFB,
  0xFE, 0x7F, 0xC0, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0xFE, 0x1F, 0x03, 0xF8, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x07,
  0xF0, 0x3E, 0x0F, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x8F, 0xBB, 0xE3, 0xFC, 0x7C,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 9, 6, 13, 3, -15 },
  { 18, 13, 15, 13, 0, -15 },
  { 43, 13, 21, 13, 0, -18 },
  { 78, 15, 15, 13, -1, -15 },
  { 107, 12, 16, 13, 0, -16 },
  { 131, 3, 6, 13, 6, -15 },
  { 134, 9, 21, 13, 3, -18 },
  { 158, 9, 21, 13, 1, -18 },
  { 182, 11, 11, 13, 1, -13 },
  { 198, 11, 10, 13, 1, -12 },
  { 212, 7, 6, 13, 1, -3 },
  { 218, 7, 3, 13, 3, -8 },
  { 221, 5, 4, 13, 3, -4 },
  { 224, 13, 19, 13, 0, -17 },
  { 255, 11, 16, 13, 1, -16 },
  { 277, 10, 15, 13, 1, -15 },
  { 296, 11, 16, 13, 1, -16 },
  { 318, 11, 15, 13, 1, -15 },
  { 339, 11, 15, 13, 1, -15 },
  { 360, 11, 15, 13, 1, -15 },
  { 381, 11, 15, 13, 1, -15 },
  { 402, 11, 15, 13, 2, -15 },
  { 423, 12, 16, 13, 0, -16 },
  { 447, 12, 16, 13, 1, -16 },
  { 471, 6, 12, 13, 3, -12 },
  { 480, 7, 15, 13, 2, -12 },
  { 494, 11, 12, 13, 1, -13 },
  { 511, 11, 8, 13, 1, -11 },
  { 522, 11, 12, 13, 1, -13 },
  { 539, 10, 15, 13, 2, -15 },
  { 558, 13, 20, 13, 0, -16 },
  { 591, 11, 15, 13, 0, -15 },
  { 612, 13, 15, 13, 0, -15 },
  { 637, 12, 16, 13, 1, -16 },
  { 661, 13, 15, 13, 0, -15 },
  { 686, 12, 15, 13, 1, -15 },
  { 709, 12, 15, 13, 1, -15 },
  { 732, 12, 16, 13, 1, -16 },
  { 756, 13, 15, 13, 0, -15 },
  { 781, 11, 15, 13, 1, -15 },
  { 802, 12, 15, 13, 0, -15 },
  { 825, 13, 15, 13, 0, -15 },
  { 850, 10, 15, 13, 1, -15 },
  { 869, 13, 15, 13, 0, -15 },
  { 894, 13, 15, 13, 0, -15 },
  { 919, 11, 16, 13, 1, -16 },
  { 941, 13, 15, 13, 0, -15 },
  { 966, 11, 20, 13, 1, -16 },
  { 994, 13, 15, 13, 0, -15 },
  { 1019, 13, 16, 13, 0, -16 },
  { 1045, 11, 15, 13, 2, -15 },
  { 1066, 12, 15, 13, 1, -15 },
  { 1089, 12, 15, 13, 2, -15 },
  { 1112, 13, 15, 13, 1, -15 },
  { 1137, 14, 15, 13, -1, -15 },
  { 1164, 12, 15, 13, 2, -15 },
  { 1187, 11, 15, 13, 1, -15 },
  { 1208, 10, 19, 13, 2, -17 },
  { 1232, 7, 19, 13, 3, -17 },
  { 1249, 10, 19, 13, 1, -17 },
  { 1273, 11, 8, 13, 1, -15 },
  { 1284, 10, 2, 13, 0, 1 },
  { 1287, 5, 2, 13, 5, -16 },
  { 1289, 11, 12, 13, 1, -12 },
  { 1306, 12, 15, 13, 0, -15 },
  { 1329, 11, 12, 13, 1, -12 },
  { 1346, 12, 15, 13, 1, -15 },
  { 1369, 11, 12, 13, 1, -12 },
  { 1386, 14, 19, 13, -1, -15 },
  { 1420, 11, 16, 13, 1, -12 },
  { 1442, 12, 15, 13, 0, -15 },
  { 1465, 10, 17, 13, 1, -17 },
  { 1487, 12, 21, 13, 0, -17 },
  { 1519, 12, 15, 13, 1, -15 },
  { 1542, 9, 15, 13, 2, -15 },
  { 1559, 12, 12, 13, 0, -12 },
  { 1577, 12, 12, 13, 0, -12 },
  { 1595, 11, 12, 13, 1, -12 },
  { 1612, 12, 16, 13, 0, -12 },
  { 1636, 11, 16, 13, 1, -12 },
  { 1658, 12, 12, 13, 1, -12 },
  { 1676, 12, 12, 13, 0, -12 },
  { 1694, 11, 15, 13, 1, -15 },
  { 1715, 11, 12, 13, 1, -12 },
  { 1732, 12, 12, 13, 1, -12 },
  { 1750, 12, 12, 13, 1, -12 },
  { 1768, 13, 12, 13, 0, -12 },
  { 1788, 11, 16, 13, 1, -12 },
  { 1810, 11, 12, 13, 1, -12 },
  { 1827, 11, 19, 13, 2, -17 },
  { 1854, 7, 19, 13, 3, -17 },
  { 1871, 12, 19, 13, 0, -17 },
  { 1900, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC21PT7B_H_
