#ifndef _JETBRAINSMONO_EXTRABOLDITALIC26PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x10, 0x78, 0x78, 0x78, 0x79, 0xFE, 0x3B, 0xCF,
  0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0x01, 0xC7, 0x03, 0x8E, 0x03,
  0x8E, 0x03, 0x8E, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x38, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xDE,
  0x3D, 0xBC, 0xF3, 0x01, 0xF4, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFC, 0x02, 0x78, 0x04, 0xF3, 0xD9, 0xE7, 0xF7, 0x8F, 0xFF,
  0x0F, 0xFC, 0x0F, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x70, 0xFE, 0x0E, 0x0E, 0x61, 0xC0, 0xC6, 0x38, 0x1C, 0x67,
  0x01, 0xCE, 0xE0, 0x1F, 0xFC, 0x00, 0xFD, 0x80, 0x02, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE4, 0x00, 0x1D, 0xF0, 0x03, 0xBF, 0x80, 0x77, 0x38, 0x0E,
  0x73, 0x80, 0xC7, 0x38, 0x18, 0x73, 0x83, 0x87, 0xF0, 0xF0, 0x3E, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x79, 0xE0, 0xE1, 0xC1, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x1F, 0x00, 0x7F, 0x01, 0xEE, 0x7B, 0xDF, 0xE7, 0x1F,
  0x8E, 0x3F, 0x3C, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0xFF, 0xF0, 0xFC, 0xF0,
  0x7F, 0xBD, 0xEF, 0x7B, 0x9C, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x7E, 0x0F,
  0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x10, 0xE1, 0x73, 0x9D, 0xF5, 0xFF, 0xFF, 0xC3, 0xF0, 0x07,
  0x80, 0x77, 0x03, 0xDE, 0x1E, 0x3C, 0x38, 0xE0, 0x42, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x81, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0x70, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x39, 0xFF, 0xFE,
  0x78, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x7B, 0xBD, 0xFE,
  0xE7, 0x3B, 0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBE, 0x3C, 0x7F,
  0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF8, 0x7F, 0xC3,
  0xDE, 0x18, 0xF0, 0x87, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x9F, 0x3C, 0x3D, 0xE0, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3F, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xEF, 0x07,
  0xBC, 0x3C, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x79,
  0xF1, 0xE7, 0x87, 0xBC, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xCF,
  0xFF, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xFC, 0x3F, 0xF9, 0xFF, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xEF, 0x07, 0xBE, 0x3C, 0xFF, 0xF1,
  0xFF, 0x83, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x90, 0x3F, 0xF1, 0xFF, 0xE7, 0xCF, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xFF, 0xF1, 0xFF, 0x83,
  0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xC3,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3C, 0xE0, 0xF3, 0xC3,
  0xCF, 0xBE, 0x1F, 0xF0, 0x3F, 0x83, 0xFF, 0x1E, 0x3E, 0xF0, 0x7B, 0xC1,
  0xEF, 0x07, 0xBE, 0x3C, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0xF0, 0x7B, 0xC0, 0xEF, 0x07, 0xBC, 0x1E,
  0xF8, 0xFB, 0xFF, 0xC7, 0xEF, 0x06, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x08, 0x3C, 0xF9, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0x1E, 0x00, 0x03, 0x03,
  0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x00, 0x00, 0x08, 0x01, 0xC0,
  0x3E, 0x0F, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0x1C, 0x00, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xC0, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x0F, 0x80,
  0x70, 0x02, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0x7F, 0xE7, 0xFE, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x7E, 0x3F, 0xC3, 0xF8, 0x3F, 0x03, 0x80, 0x38, 0x04,
  0x00, 0x00, 0x03, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xFC, 0x07,
  0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78, 0xF7, 0x71,
  0xF7, 0x73, 0xCF, 0x73, 0x8E, 0x73, 0x8E, 0x73, 0x8E, 0x73, 0x8E, 0xF7,
  0x8E, 0xE7, 0x9E, 0xE7, 0xFE, 0xE3, 0xEC, 0xE0, 0x90, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE,
  0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x70, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0x1E, 0x0F, 0x7C, 0x1E, 0xF0, 0x3F, 0xE0, 0x78, 0x3F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x7C,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x38, 0x3C, 0x78,
  0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x04, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF3, 0xF9, 0xE7, 0xE3, 0xCF, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F,
  0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xC3, 0xC7, 0x87, 0x9E,
  0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x9E, 0x0F, 0x3C,
  0x1E, 0x7C, 0x7C, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x3C, 0x1F, 0x3C,
  0x1E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0xF0, 0x38, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x79, 0xE0, 0x71, 0xE0, 0xF1,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F,
  0xF7, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x1E, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F,
  0x3B, 0x37, 0x3B, 0x7F, 0x3B, 0x6E, 0x3B, 0x6E, 0x3B, 0xEE, 0x7B, 0xDE,
  0x7B, 0xDE, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x1F, 0x0F, 0x1F, 0x0F, 0x1F, 0x0F,
  0x1F, 0x8E, 0x1F, 0x8E, 0x1F, 0x8E, 0x3F, 0x9E, 0x3F, 0x9E, 0x39, 0x9E,
  0x39, 0xDC, 0x39, 0xDC, 0x39, 0xDC, 0x79, 0xDC, 0x79, 0xDC, 0x78, 0xFC,
  0x70, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0, 0xF8, 0x07, 0xF0, 0x3F, 0xE1,
  0xFF, 0xCF, 0x9F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D,
  0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBE, 0x3C,
  0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x1E, 0x78, 0xFC, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFE, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF,
  0x9F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE1, 0xE7,
  0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBE, 0x3C, 0x7F, 0xF1,
  0xFF, 0x83, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x8E,
  0x0F, 0x3C, 0x1E, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x07, 0x1C,
  0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xE0,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E, 0x1E, 0x1E, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x78, 0x3C, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00,
  0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E,
  0x3C, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC,
  0x07, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x71, 0xC7,
  0x71, 0xC7, 0x73, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x76, 0xDE,
  0x76, 0xDC, 0x76, 0xDC, 0xE6, 0xDC, 0xEC, 0xDC, 0xEC, 0xF8, 0xEC, 0xF8,
  0xF8, 0xB8, 0xF9, 0xB0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0,
  0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x78, 0xF0,
  0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xC3, 0x8F, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xCF, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70,
  0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x80,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x00, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE7, 0x8F, 0x70,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xE3, 0xC0, 0x02, 0x00,
  0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3E, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xEF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x40, 0xFF, 0xC3,
  0xBF, 0x9F, 0xFE, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x7B,
  0xC1, 0xEF, 0x07, 0xBE, 0x3C, 0xFF, 0xF3, 0xFF, 0x8E, 0x7C, 0x00, 0x01,
  0x00, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7C, 0x7D, 0xE0, 0xF7, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xBE, 0x3C, 0x7F, 0xF1, 0xFF, 0x83,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x23, 0xC3,
  0xF7, 0x8F, 0xFF, 0x1F, 0xFE, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x7C, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFB, 0xC0, 0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xBE, 0x78, 0x39, 0xE0,
  0xE7, 0x03, 0x9F, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x7F,
  0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x02,
  0x00, 0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x8F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFB, 0xC0,
  0x0F, 0x00, 0x3C, 0x03, 0xE1, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x40, 0xFF, 0xC3, 0xBF, 0x9F, 0xFE,
  0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x00, 0x40, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xCF, 0x1F, 0x3C, 0x3C, 0x78,
  0xF0, 0xF3, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF,
  0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0x07,
  0xF0, 0x01, 0x08, 0x77, 0xBC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xEF, 0x39,
  0xDE, 0x67, 0xB9, 0xCF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x77, 0x9C, 0xEF,
  0x33, 0xDE, 0x67, 0xB9, 0xCE, 0x00, 0x00, 0x40, 0xFF, 0xC3, 0xBF, 0x9F,
  0xFE, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x01, 0x80, 0x3F,
  0xC1, 0xFF, 0x8F, 0xFE, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBE, 0x3C, 0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00,
  0x00, 0x20, 0x3F, 0xF0, 0x77, 0xF1, 0xFF, 0xE3, 0xE3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xE3, 0xC7, 0xFF,
  0x8F, 0xFE, 0x1E, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x02, 0x00, 0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3E, 0x7C, 0xFF,
  0xF1, 0xFF, 0xC3, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0x40, 0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xC3, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFB, 0xF3, 0xC1, 0xE7, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xF8, 0x00, 0xF3, 0xC1, 0xE7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xE3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3C, 0x3D, 0xE0, 0xF7, 0x83,
  0xDE, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1E, 0xF0, 0x7B, 0xC3,
  0xCF, 0x9F, 0x1F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0xF0, 0x3F, 0xC1, 0xEF,
  0x07, 0xBC, 0x3C, 0x70, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1,
  0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0xE3, 0x8F, 0xC7,
  0x1F, 0x8E, 0x3F, 0x3C, 0xEE, 0x79, 0xDC, 0xF3, 0xBB, 0x6E, 0x76, 0xDC,
  0xED, 0xB9, 0xD3, 0x63, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x00,
  0x3E, 0x1F, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3E, 0xF0, 0x3C, 0xF8,
  0x78, 0x78, 0xF0, 0x7C, 0x7C, 0x3D, 0xE0, 0xF7, 0x87, 0x9E, 0x1E, 0x78,
  0x79, 0xE1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xF7, 0xCF, 0xFF, 0x1F,
  0xBC, 0x3C, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x7F, 0xC1, 0xFE, 0x07,
  0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x3F, 0xE0,
  0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0x0E, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x1D, 0xFC, 0x7F,
  0xF9, 0xF8, 0xFF, 0xE3, 0xF8, 0x07, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 19, 16, 4, -19 },
  { 20, 11, 8, 16, 4, -19 },
  { 31, 16, 19, 16, 0, -19 },
  { 69, 15, 27, 16, 1, -23 },
  { 120, 20, 19, 16, -2, -19 },
  { 168, 15, 19, 16, 0, -19 },
  { 204, 5, 8, 16, 7, -19 },
  { 209, 12, 25, 16, 3, -22 },
  { 247, 12, 25, 16, 1, -22 },
  { 285, 14, 14, 16, 1, -16 },
  { 310, 14, 13, 16, 1, -15 },
  { 333, 8, 8, 16, 2, -4 },
  { 341, 10, 3, 16, 3, -10 },
  { 345, 6, 5, 16, 4, -5 },
  { 349, 17, 25, 16, 0, -22 },
  { 403, 14, 19, 16, 1, -19 },
  { 437, 13, 19, 16, 1, -19 },
  { 468, 14, 19, 16, 1, -19 },
  { 502, 14, 19, 16, 1, -19 },
  { 536, 14, 19, 16, 1, -19 },
  { 570, 14, 19, 16, 1, -19 },
  { 604, 14, 19, 16, 1, -19 },
  { 638, 14, 19, 16, 2, -19 },
  { 672, 14, 19, 16, 1, -19 },
  { 706, 14, 19, 16, 2, -19 },
  { 740, 7, 15, 16, 4, -15 },
  { 754, 9, 19, 16, 2, -15 },
  { 776, 13, 15, 16, 2, -16 },
  { 801, 14, 10, 16, 1, -14 },
  { 819, 13, 15, 16, 1, -16 },
  { 844, 12, 19, 16, 3, -19 },
  { 873, 16, 24, 16, 0, -19 },
  { 921, 15, 19, 16, -1, -19 },
  { 957, 15, 19, 16, 1, -19 },
  { 993, 15, 19, 16, 1, -19 },
  { 1029, 16, 19, 16, 0, -19 },
  { 1067, 15, 19, 16, 1, -19 },
  { 1103, 15, 19, 16, 1, -19 },
  { 1139, 15, 19, 16, 1, -19 },
  { 1175, 15, 19, 16, 1, -19 },
  { 1211, 14, 19, 16, 1, -19 },
  { 1245, 15, 19, 16, 0, -19 },
  { 1281, 16, 19, 16, 1, -19 },
  { 1319, 12, 19, 16, 1, -19 },
  { 1348, 16, 19, 16, 0, -19 },
  { 1386, 16, 19, 16, 0, -19 },
  { 1424, 14, 19, 16, 1, -19 },
  { 1458, 15, 19, 16, 1, -19 },
  { 1494, 14, 24, 16, 1, -19 },
  { 1536, 15, 19, 16, 1, -19 },
  { 1572, 16, 19, 16, 0, -19 },
  { 1610, 14, 19, 16, 2, -19 },
  { 1644, 15, 19, 16, 1, -19 },
  { 1680, 14, 19, 16, 3, -19 },
  { 1714, 16, 19, 16, 1, -19 },
  { 1752, 18, 19, 16, -1, -19 },
  { 1795, 15, 19, 16, 2, -19 },
  { 1831, 14, 19, 16, 1, -19 },
  { 1865, 12, 25, 16, 3, -22 },
  { 1903, 9, 25, 16, 4, -22 },
  { 1932, 11, 25, 16, 2, -22 },
  { 1967, 12, 10, 16, 2, -19 },
  { 1982, 13, 3, 16, 0, 1 },
  { 1987, 6, 3, 16, 6, -20 },
  { 1990, 14, 15, 16, 1, -15 },
  { 2017, 14, 19, 16, 1, -19 },
  { 2051, 14, 15, 16, 1, -15 },
  { 2078, 15, 19, 16, 1, -19 },
  { 2114, 14, 15, 16, 1, -15 },
  { 2141, 18, 24, 16, -2, -19 },
  { 2195, 14, 20, 16, 1, -15 },
  { 2230, 14, 19, 16, 1, -19 },
  { 2264, 13, 21, 16, 1, -21 },
  { 2299, 15, 26, 16, 0, -21 },
  { 2348, 15, 19, 16, 1, -19 },
  { 2384, 12, 19, 16, 2, -19 },
  { 2413, 15, 15, 16, 0, -15 },
  { 2442, 14, 15, 16, 1, -15 },
  { 2469, 14, 15, 16, 1, -15 },
  { 2496, 15, 20, 16, 0, -15 },
  { 2534, 14, 20, 16, 1, -15 },
  { 2569, 15, 15, 16, 1, -15 },
  { 2598, 15, 15, 16, 0, -15 },
  { 2627, 14, 18, 16, 1, -18 },
  { 2659, 14, 14, 16, 1, -14 },
  { 2684, 14, 14, 16, 2, -14 },
  { 2709, 15, 14, 16, 1, -14 },
  { 2736, 16, 14, 16, 0, -14 },
  { 2764, 14, 19, 16, 1, -14 },
  { 2798, 14, 14, 16, 1, -14 },
  { 2823, 14, 25, 16, 2, -22 },
  { 2867, 8, 25, 16, 4, -22 },
  { 2892, 14, 25, 16, 0, -22 },
  { 2936, 14, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC26PT7B_H_
