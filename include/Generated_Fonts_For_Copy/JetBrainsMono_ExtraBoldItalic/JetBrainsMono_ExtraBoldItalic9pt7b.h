#ifndef _JETBRAINSMONO_EXTRABOLDITALIC9PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x88, 0x5D, 0xF0, 0x28, 0xA7, 0xD4, 0x53, 0xEA, 0x00, 0x11,
  0x9E, 0xC7, 0x1F, 0xEE, 0x20, 0x32, 0x69, 0x61, 0x41, 0xC6, 0xB7, 0x00,
  0x33, 0xD0, 0xCE, 0xCB, 0xE0, 0x5C, 0x13, 0x64, 0x4C, 0xC4, 0x60, 0x43,
  0x11, 0x11, 0x36, 0xC0, 0x36, 0xCC, 0xA0, 0x33, 0xFE, 0x40, 0xE0, 0xFC,
  0x50, 0x0C, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x33, 0xD2, 0xD4, 0xED, 0xC0,
  0x13, 0x94, 0x23, 0x1B, 0xE0, 0x33, 0xC2, 0x33, 0x23, 0xE0, 0x7B, 0xCC,
  0x71, 0xED, 0xC0, 0x08, 0x88, 0x9D, 0xFC, 0x40, 0x7B, 0xD0, 0xF0, 0xED,
  0xC0, 0x19, 0x88, 0xFC, 0xED, 0xC0, 0xFF, 0xA4, 0x46, 0x23, 0x00, 0x33,
  0xD2, 0x65, 0xED, 0xC0, 0x6F, 0x9F, 0x26, 0xC0, 0x68, 0x24, 0x68, 0x0D,
  0x00, 0x3C, 0xC7, 0x10, 0xFF, 0x0F, 0x60, 0xCF, 0xC8, 0x00, 0x6F, 0x16,
  0x40, 0xC0, 0x31, 0x25, 0xEA, 0xAA, 0xAB, 0x30, 0x60, 0x31, 0x8C, 0xE7,
  0xFE, 0x60, 0x73, 0xD2, 0xE4, 0xEF, 0xC0, 0x33, 0xD0, 0x84, 0x6D, 0xC0,
  0x73, 0xD2, 0x94, 0xEF, 0xC0, 0x7B, 0xD0, 0xF4, 0x23, 0xE0, 0x7D, 0xE4,
  0x1E, 0x43, 0x0C, 0x00, 0x33, 0xD0, 0xB5, 0xED, 0xC0, 0x6A, 0x52, 0xF5,
  0xEF, 0x40, 0x7B, 0xCC, 0x62, 0x13, 0xC0, 0x39, 0xC2, 0x31, 0xCB, 0xC0,
  0x6D, 0x25, 0x9C, 0x53, 0x4D, 0x80, 0x63, 0x18, 0x84, 0x23, 0xE0, 0x6D,
  0xB7, 0x9E, 0xCA, 0x29, 0x80, 0x6D, 0xA6, 0x9A, 0x6B, 0x69, 0x80, 0x33,
  0xD2, 0x94, 0xED, 0xC0, 0x71, 0xE4, 0x9E, 0x73, 0x0C, 0x00, 0x33, 0xD2,
  0x94, 0xED, 0xC6, 0x10, 0x73, 0xD2, 0xF7, 0x6B, 0x60, 0x33, 0xD0, 0xE1,
  0xED, 0xC0, 0xFF, 0xD8, 0xC4, 0x21, 0x00, 0x6D, 0x24, 0x92, 0x4B, 0x67,
  0x00, 0x9C, 0xA5, 0x6A, 0x73, 0x00, 0x55, 0x57, 0x9E, 0xBB, 0x6D, 0x00,
  0x4D, 0xA3, 0x0C, 0x71, 0x4D, 0x80, 0x9C, 0xBC, 0xC4, 0x21, 0x00, 0x7B,
  0xC4, 0x66, 0x27, 0xC0, 0x74, 0x44, 0x4C, 0xCE, 0xC9, 0x26, 0xC9, 0x72,
  0x22, 0x26, 0x6C, 0x26, 0xF9, 0xF0, 0xC0, 0x7A, 0x57, 0xB7, 0x00, 0x62,
  0x1E, 0x94, 0xEF, 0xC0, 0x7A, 0x51, 0xB7, 0x00, 0x08, 0x5E, 0x95, 0xED,
  0xC0, 0x7A, 0x5F, 0x97, 0x00, 0x06, 0x38, 0x41, 0xE1, 0x02, 0x0C, 0x18,
  0xC0, 0x7A, 0x57, 0xB7, 0x09, 0x80, 0x62, 0x1E, 0x95, 0xEF, 0x60, 0x10,
  0x1C, 0x63, 0x13, 0xE0, 0x18, 0x1E, 0x21, 0x08, 0x5E, 0xC0, 0x61, 0x04,
  0xD6, 0x73, 0x4D, 0x80, 0xEE, 0x44, 0x44, 0x70, 0x7B, 0x7B, 0x5B, 0x80,
  0x7A, 0x57, 0xBD, 0x80, 0x7A, 0x53, 0xB7, 0x00, 0x7A, 0x53, 0xBF, 0x42,
  0x00, 0x7A, 0x57, 0xB7, 0x08, 0x40, 0x5B, 0x50, 0x8C, 0x00, 0x7A, 0x1E,
  0x3F, 0x00, 0x6F, 0x44, 0xD6, 0x4A, 0x57, 0xB7, 0x00, 0x9D, 0xA9, 0x4C,
  0x00, 0xF6, 0xEB, 0xB6, 0xD0, 0x4B, 0x88, 0xED, 0x80, 0x4A, 0x57, 0xF5,
  0x19, 0x80, 0x78, 0xC8, 0x8F, 0x80, 0x39, 0x09, 0xC6, 0x31, 0x0C, 0x2D,
  0xB4, 0x96, 0x71, 0x88, 0x72, 0x11, 0x98, 0x6C, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 4, 3, 5, 1, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 7, 7, 5, -1, -7 },
  { 24, 5, 7, 5, 0, -7 },
  { 29, 2, 3, 5, 2, -7 },
  { 30, 4, 9, 5, 1, -8 },
  { 35, 4, 9, 5, 0, -8 },
  { 40, 5, 4, 5, 0, -5 },
  { 43, 5, 4, 5, 0, -5 },
  { 46, 2, 2, 5, 1, -1 },
  { 47, 3, 2, 5, 1, -4 },
  { 48, 2, 2, 5, 1, -2 },
  { 49, 6, 8, 5, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 1, -7 },
  { 95, 5, 7, 5, 0, -7 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 3, 5, 5, 1, -5 },
  { 106, 3, 6, 5, 1, -5 },
  { 109, 4, 5, 5, 1, -5 },
  { 112, 4, 4, 5, 1, -5 },
  { 114, 5, 5, 5, 0, -5 },
  { 118, 4, 7, 5, 1, -7 },
  { 122, 6, 9, 5, 0, -7 },
  { 129, 5, 7, 5, 0, -7 },
  { 134, 5, 7, 5, 0, -7 },
  { 139, 5, 7, 5, 0, -7 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 6, 7, 5, 0, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 5, 7, 5, 0, -7 },
  { 170, 5, 7, 5, 0, -7 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 6, 7, 5, 0, -7 },
  { 186, 5, 7, 5, 0, -7 },
  { 191, 6, 7, 5, 0, -7 },
  { 197, 6, 7, 5, 0, -7 },
  { 203, 5, 7, 5, 0, -7 },
  { 208, 6, 7, 5, 0, -7 },
  { 214, 5, 9, 5, 0, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 5, 7, 5, 1, -7 },
  { 235, 6, 7, 5, 0, -7 },
  { 241, 5, 7, 5, 1, -7 },
  { 246, 6, 7, 5, 0, -7 },
  { 252, 6, 7, 5, 0, -7 },
  { 258, 5, 7, 5, 1, -7 },
  { 263, 5, 7, 5, 0, -7 },
  { 268, 4, 8, 5, 1, -7 },
  { 272, 3, 8, 5, 1, -7 },
  { 275, 4, 8, 5, 1, -7 },
  { 279, 4, 4, 5, 1, -7 },
  { 281, 4, 1, 5, 0, 0 },
  { 282, 2, 1, 5, 2, -7 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 5, 7, 5, 0, -7 },
  { 292, 5, 5, 5, 0, -5 },
  { 296, 5, 7, 5, 0, -7 },
  { 301, 5, 5, 5, 0, -5 },
  { 305, 7, 9, 5, -1, -7 },
  { 313, 5, 7, 5, 0, -5 },
  { 318, 5, 7, 5, 0, -7 },
  { 323, 5, 7, 5, 0, -7 },
  { 328, 5, 9, 5, 0, -7 },
  { 334, 6, 7, 5, 0, -7 },
  { 340, 4, 7, 5, 1, -7 },
  { 344, 5, 5, 5, 0, -5 },
  { 348, 5, 5, 5, 0, -5 },
  { 352, 5, 5, 5, 0, -5 },
  { 356, 5, 7, 5, 0, -5 },
  { 361, 5, 7, 5, 0, -5 },
  { 366, 5, 5, 5, 0, -5 },
  { 370, 5, 5, 5, 0, -5 },
  { 374, 4, 6, 5, 1, -6 },
  { 377, 5, 5, 5, 0, -5 },
  { 381, 5, 5, 5, 1, -5 },
  { 385, 6, 5, 5, 0, -5 },
  { 389, 5, 5, 5, 0, -5 },
  { 393, 5, 7, 5, 0, -5 },
  { 398, 5, 5, 5, 0, -5 },
  { 402, 5, 8, 5, 1, -7 },
  { 407, 3, 8, 5, 1, -7 },
  { 410, 5, 8, 5, 0, -7 },
  { 415, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC9PT7B_H_
