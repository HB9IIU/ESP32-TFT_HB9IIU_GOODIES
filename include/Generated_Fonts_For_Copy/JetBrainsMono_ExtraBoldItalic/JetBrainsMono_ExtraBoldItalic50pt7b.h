#ifndef _JETBRAINSMONO_EXTRABOLDITALIC50PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFE, 0x7F, 0x0F, 0xF7, 0xF8, 0x7F, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE7, 0x3F, 0xC1, 0xFE, 0x79, 0xFE, 0x0F, 0xF3,
  0xC7, 0xF0, 0x7F, 0x1C, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x1F, 0xE7, 0x00,
  0x00, 0xFF, 0x38, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x39, 0xFF, 0x00, 0x01, 0xC7, 0xF8, 0x00, 0x0E, 0x1F, 0xC0,
  0x00, 0x70, 0xFE, 0x1F, 0xC7, 0x8F, 0xF0, 0xFE, 0x3C, 0x7F, 0x87, 0xF9,
  0xC7, 0xF8, 0x3F, 0xEE, 0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xC0,
  0x1F, 0x9F, 0x80, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x7C, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x3E, 0x7E, 0x00, 0x0F, 0x83, 0xE7, 0xE0,
  0x00, 0x3E, 0x3F, 0x3E, 0x00, 0x01, 0xFF, 0xF3, 0xE0, 0x00, 0x0F, 0xFF,
  0x3E, 0x00, 0x00, 0x3F, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x04, 0x00, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0x00,
  0x1F, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xFF, 0xC0, 0x00, 0x1F, 0x3F, 0xFF,
  0x00, 0x01, 0xF3, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x07, 0xC0, 0x01, 0xF8,
  0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xFC,
  0x7E, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x07, 0xF3, 0xFD, 0xFC,
  0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0xBF, 0x87, 0xF1, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE,
  0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0x80, 0x7F, 0xE1, 0xFE, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE,
  0x7F, 0x3F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x7C, 0x0E,
  0x3F, 0x0F, 0x87, 0xE7, 0xF1, 0xE3, 0xFD, 0xFF, 0x3C, 0xFF, 0xBF, 0xF3,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x0F,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0xE0, 0x1C,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x02,
  0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0x87,
  0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xF1,
  0xFC, 0x70, 0xFE, 0x3F, 0x9F, 0x9F, 0xC7, 0xF7, 0xF3, 0xF8, 0xFE, 0xFE,
  0x7F, 0x1F, 0xDF, 0xCF, 0xE7, 0xF1, 0xFB, 0xF8, 0xFE, 0x3E, 0x7F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE,
  0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xE3,
  0xFC, 0x03, 0xE1, 0xFE, 0x01, 0xC0, 0xFF, 0x00, 0xC0, 0x7F, 0x00, 0x80,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0x83, 0xFE,
  0x07, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xF3, 0xFF, 0x00, 0xFE, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F,
  0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF8,
  0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x9F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x81,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFD, 0xFC, 0x07, 0xFE, 0xFF, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF,
  0x83, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x3C, 0x3F, 0x0F, 0xC0, 0xFF, 0x3F, 0x0F,
  0xC1, 0xFF, 0xBE, 0x1F, 0x83, 0xFF, 0xBE, 0x1F, 0x83, 0xFF, 0xFE, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xE0, 0xFE, 0x1F,
  0x8F, 0xC0, 0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x1F, 0xC1, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xFF, 0xF8, 0x7E, 0x0F, 0xFC, 0xF8, 0x7E,
  0x07, 0xF9, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF9,
  0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0xFC, 0x3F, 0x87, 0xFF, 0xC3,
  0xF8, 0x7F, 0xFC, 0x7F, 0x87, 0xFF, 0xC7, 0xF8, 0x7F, 0xFC, 0x7F, 0x87,
  0xFF, 0x87, 0xF0, 0x83, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xDE, 0x0F,
  0x7C, 0x0F, 0xDE, 0x1F, 0xFC, 0x0F, 0xDE, 0x1E, 0xFC, 0x0F, 0xDE, 0x3E,
  0xFC, 0x0F, 0xDE, 0x3E, 0xFC, 0x0F, 0xDF, 0x3D, 0xFC, 0x0F, 0xDF, 0x7D,
  0xF8, 0x1F, 0xDF, 0x79, 0xF8, 0x1F, 0xDF, 0xF9, 0xF8, 0x1F, 0xCF, 0xFB,
  0xF8, 0x1F, 0xCF, 0xF3, 0xF8, 0x1F, 0x8F, 0xF3, 0xF8, 0x1F, 0x8F, 0xE3,
  0xF0, 0x1F, 0x8F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC7, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x01,
  0xFC, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x81, 0xFF, 0x80, 0x7E,
  0x07, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0x83,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF,
  0xF0, 0x7F, 0x03, 0xF7, 0xC1, 0xFC, 0x0F, 0xDF, 0x07, 0xF0, 0x3F, 0x7E,
  0x1F, 0xC1, 0xFD, 0xF8, 0x7E, 0x07, 0xF7, 0xE1, 0xF8, 0x1F, 0xCF, 0x8F,
  0xE0, 0x7E, 0x3E, 0x3F, 0x81, 0xF8, 0xF8, 0xFE, 0x07, 0xE3, 0xF3, 0xF8,
  0x3F, 0x8F, 0xCF, 0xC0, 0xFE, 0x3F, 0x3F, 0x03, 0xF8, 0x7C, 0xFC, 0x0F,
  0xE1, 0xF3, 0xF0, 0x3F, 0x07, 0xEF, 0xC0, 0xFC, 0x1F, 0xBF, 0x07, 0xF0,
  0x7F, 0xF8, 0x1F, 0xC1, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x0F,
  0xFE, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0xE0, 0xFE, 0x03, 0xFF,
  0x83, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F,
  0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF1, 0xFE,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFE, 0x03,
  0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x7E, 0x7E, 0x0F, 0xC0, 0xFC, 0xFC, 0x1F,
  0x83, 0xF9, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC,
  0x1F, 0x8F, 0xC3, 0xB8, 0x3F, 0x1F, 0x87, 0x70, 0xFC, 0x3E, 0x1F, 0xE1,
  0xF8, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x87, 0xE3, 0xF0, 0xEF, 0x1F,
  0x87, 0xE3, 0xDE, 0x3F, 0x0F, 0xC7, 0xBC, 0x7E, 0x1F, 0x8F, 0x78, 0xF8,
  0x3F, 0x1C, 0xF3, 0xF0, 0x7E, 0x79, 0xE7, 0xE0, 0xFC, 0xF3, 0xCF, 0xC1,
  0xF9, 0xE7, 0x9F, 0x03, 0xF7, 0x8F, 0x3E, 0x07, 0xCF, 0x1C, 0xFC, 0x0F,
  0x9E, 0x39, 0xF8, 0x1F, 0x38, 0x73, 0xE0, 0x3E, 0xF0, 0xE7, 0xC0, 0x7D,
  0xE1, 0xDF, 0x81, 0xFB, 0xC7, 0xBF, 0x03, 0xF7, 0x0F, 0x7C, 0x07, 0xFE,
  0x1E, 0xF8, 0x0F, 0xFC, 0x3D, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3E, 0xE0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F,
  0xDF, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0xF3, 0xFC, 0x0F, 0xFF, 0x7F,
  0x83, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F,
  0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFE, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0xF7, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x1F, 0x80, 0x3F, 0xCF, 0xFC, 0x07, 0xFB, 0xFF, 0xC0, 0xFE, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFD,
  0xFF, 0xF0, 0x7F, 0xBF, 0xFC, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xF0, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE1, 0xFE, 0x01,
  0xFF, 0x9F, 0xE0, 0x3F, 0xFD, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xE0, 0x3F,
  0xFE, 0xFE, 0x03, 0xFF, 0xDF, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0xF3, 0xFC, 0x0F,
  0xFF, 0x7F, 0x83, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7,
  0xF0, 0x1F, 0xFC, 0xFE, 0x01, 0xFF, 0x1F, 0xC0, 0x06, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x3F, 0xCF, 0xFC, 0x07, 0xFB,
  0xFF, 0xC0, 0xFE, 0xFF, 0xFC, 0x1F, 0xDF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xC7,
  0x83, 0xE0, 0x3F, 0x3F, 0x1F, 0xC0, 0xFD, 0xFC, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0x9F, 0xCF, 0xE1, 0xFC, 0x3E, 0x1F,
  0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x1F, 0x0F, 0xE1,
  0xF8, 0x7C, 0x3F, 0x8F, 0xE1, 0xF0, 0xFC, 0x3F, 0x87, 0xC3, 0xF0, 0xFE,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xE1, 0xFC, 0x3F, 0x0F,
  0x87, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xF0, 0xF8, 0x7E, 0x1F, 0xC3, 0xE1,
  0xF8, 0x7F, 0x1F, 0x8F, 0xE1, 0xF8, 0x7C, 0x3F, 0x87, 0xE1, 0xF0, 0xFE,
  0x1F, 0x87, 0xC3, 0xF0, 0xFE, 0x1F, 0x0F, 0xC3, 0xF8, 0x7C, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFC, 0x01, 0xFE,
  0x7F, 0xE0, 0x3F, 0x9F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0xFE, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F,
  0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x9F, 0xF8,
  0x07, 0xF3, 0xFF, 0xC0, 0x7F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3,
  0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0xE0,
  0x7F, 0xBF, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x01, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0xF3, 0xFC, 0x0F, 0xFF,
  0x7F, 0x83, 0xFF, 0xEF, 0xE0, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0x9F, 0xC0, 0xFF, 0xF7, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0x10, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x3F, 0xF8, 0x0F, 0xEF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x03, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0xFD, 0xF8, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0x1F, 0x9F, 0x03, 0xF0, 0x7E, 0x7C, 0x1F, 0xC1, 0xF1, 0xF0, 0x7F, 0x0F,
  0xC7, 0xC1, 0xFC, 0x3F, 0x1F, 0x0F, 0xF0, 0xFC, 0x7C, 0x3B, 0xC7, 0xE1,
  0xF0, 0xEF, 0x1F, 0x87, 0xC7, 0xBC, 0x7E, 0x3F, 0x1E, 0xF1, 0xF0, 0xFC,
  0x73, 0xCF, 0xC3, 0xF3, 0xCF, 0x3F, 0x0F, 0xCF, 0x3C, 0xF8, 0x3F, 0x38,
  0xF7, 0xE0, 0xFC, 0xE3, 0xDF, 0x83, 0xF7, 0x8F, 0x7C, 0x0F, 0xDE, 0x3F,
  0xF0, 0x3F, 0x70, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x03,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFD, 0xFC, 0x1F, 0xFF, 0xBF, 0x81, 0xFF, 0xE7, 0xF0, 0x1F, 0xF9, 0xFE,
  0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x7F,
  0xF8, 0x1F, 0x9F, 0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0x0F,
  0xDF, 0x8F, 0xF3, 0xFF, 0xE0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xDF, 0x81,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 14, 37, 30, 9, -37 },
  { 66, 21, 16, 30, 7, -37 },
  { 108, 31, 37, 30, 0, -37 },
  { 252, 29, 51, 30, 1, -44 },
  { 437, 37, 37, 30, -3, -37 },
  { 609, 29, 38, 30, 0, -37 },
  { 747, 9, 16, 30, 13, -37 },
  { 765, 23, 48, 30, 6, -42 },
  { 903, 21, 48, 30, 3, -42 },
  { 1029, 27, 27, 30, 2, -31 },
  { 1121, 25, 25, 30, 3, -29 },
  { 1200, 15, 16, 30, 4, -8 },
  { 1230, 19, 7, 30, 6, -20 },
  { 1247, 11, 11, 30, 8, -10 },
  { 1263, 33, 48, 30, -1, -42 },
  { 1461, 27, 38, 30, 2, -37 },
  { 1590, 25, 37, 30, 2, -37 },
  { 1706, 28, 37, 30, 1, -37 },
  { 1836, 28, 38, 30, 1, -37 },
  { 1969, 27, 37, 30, 2, -37 },
  { 2094, 27, 38, 30, 2, -37 },
  { 2223, 27, 38, 30, 1, -37 },
  { 2352, 27, 37, 30, 4, -37 },
  { 2477, 28, 38, 30, 1, -37 },
  { 2610, 26, 37, 30, 4, -37 },
  { 2731, 14, 29, 30, 8, -28 },
  { 2782, 18, 36, 30, 4, -28 },
  { 2863, 26, 28, 30, 3, -30 },
  { 2954, 25, 19, 30, 3, -26 },
  { 3014, 26, 28, 30, 2, -30 },
  { 3105, 22, 37, 30, 6, -37 },
  { 3207, 32, 46, 30, -1, -37 },
  { 3391, 28, 37, 30, -1, -37 },
  { 3521, 29, 37, 30, 1, -37 },
  { 3656, 28, 38, 30, 2, -37 },
  { 3789, 29, 37, 30, 1, -37 },
  { 3924, 28, 37, 30, 2, -37 },
  { 4054, 30, 37, 30, 1, -37 },
  { 4193, 28, 38, 30, 2, -37 },
  { 4326, 29, 37, 30, 1, -37 },
  { 4461, 28, 37, 30, 2, -37 },
  { 4591, 30, 38, 30, 0, -37 },
  { 4734, 31, 37, 30, 1, -37 },
  { 4878, 23, 37, 30, 3, -37 },
  { 4985, 32, 37, 30, 0, -37 },
  { 5133, 30, 37, 30, 1, -37 },
  { 5272, 27, 38, 30, 2, -37 },
  { 5401, 30, 37, 30, 1, -37 },
  { 5540, 27, 46, 30, 2, -37 },
  { 5696, 29, 37, 30, 1, -37 },
  { 5831, 29, 38, 30, 1, -37 },
  { 5969, 28, 37, 30, 4, -37 },
  { 6099, 29, 38, 30, 2, -37 },
  { 6237, 27, 37, 30, 5, -37 },
  { 6362, 31, 37, 30, 2, -37 },
  { 6506, 33, 37, 30, -1, -37 },
  { 6659, 29, 37, 30, 4, -37 },
  { 6794, 27, 37, 30, 2, -37 },
  { 6919, 23, 48, 30, 5, -42 },
  { 7057, 17, 48, 30, 7, -42 },
  { 7159, 23, 48, 30, 3, -42 },
  { 7297, 25, 20, 30, 3, -37 },
  { 7360, 26, 7, 30, -1, 1 },
  { 7383, 12, 7, 30, 12, -39 },
  { 7394, 27, 29, 30, 2, -28 },
  { 7492, 27, 38, 30, 1, -37 },
  { 7621, 26, 29, 30, 2, -28 },
  { 7716, 28, 38, 30, 2, -37 },
  { 7849, 26, 29, 30, 2, -28 },
  { 7944, 34, 46, 30, -3, -37 },
  { 8140, 27, 37, 30, 2, -28 },
  { 8265, 27, 37, 30, 1, -37 },
  { 8390, 26, 40, 30, 1, -40 },
  { 8520, 28, 49, 30, 0, -40 },
  { 8692, 30, 37, 30, 1, -37 },
  { 8831, 23, 37, 30, 4, -37 },
  { 8938, 30, 28, 30, 0, -28 },
  { 9043, 27, 28, 30, 1, -28 },
  { 9138, 26, 29, 30, 2, -28 },
  { 9233, 28, 37, 30, 0, -28 },
  { 9363, 27, 37, 30, 2, -28 },
  { 9488, 28, 28, 30, 2, -28 },
  { 9586, 28, 29, 30, 1, -28 },
  { 9688, 26, 35, 30, 3, -35 },
  { 9802, 27, 29, 30, 2, -28 },
  { 9900, 28, 28, 30, 3, -28 },
  { 9998, 30, 28, 30, 2, -28 },
  { 10103, 31, 28, 30, -1, -28 },
  { 10212, 27, 37, 30, 2, -28 },
  { 10337, 27, 28, 30, 1, -28 },
  { 10432, 27, 48, 30, 4, -42 },
  { 10594, 15, 48, 30, 8, -42 },
  { 10684, 26, 48, 30, 1, -42 },
  { 10840, 27, 13, 30, 2, -24 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC50PT7B_H_
