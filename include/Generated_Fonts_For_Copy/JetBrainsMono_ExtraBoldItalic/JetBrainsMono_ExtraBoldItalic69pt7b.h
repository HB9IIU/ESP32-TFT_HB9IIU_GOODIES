#ifndef _JETBRAINSMONO_EXTRABOLDITALIC69PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF9, 0xFF, 0xC1,
  0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF,
  0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x10, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xF7, 0xBF, 0xFE, 0x01, 0xFF, 0xC7, 0x8F, 0xFE, 0x03, 0xFF,
  0x8F, 0x87, 0xFE, 0x03, 0xFF, 0x8F, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0x87,
  0xFE, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0x00, 0x00, 0x03, 0xFF, 0x9F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xF8,
  0x00, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x00,
  0x78, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE7, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xDF,
  0xF8, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xBF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0B, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0x00,
  0x10, 0x3C, 0x03, 0xFC, 0x03, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF8,
  0x3F, 0x83, 0xFC, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF,
  0xE7, 0xFF, 0xE7, 0x9F, 0xFF, 0xBF, 0xFF, 0xDE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC3, 0xE0, 0xFF, 0xC1, 0xFF, 0x1F, 0xC3,
  0xFF, 0x0F, 0xFC, 0xFF, 0x8F, 0xFC, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0xFF,
  0xCF, 0xF8, 0xFF, 0x83, 0xFF, 0x3F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0x9F,
  0xF8, 0x3F, 0xE3, 0xFE, 0x7F, 0xE1, 0xFF, 0x87, 0xF1, 0xFF, 0x87, 0xFE,
  0x06, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF0, 0x00, 0xFC, 0x07, 0xFE,
  0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0xC0, 0x07,
  0xFF, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0x03, 0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0xDF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8,
  0x03, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE1, 0xFE,
  0x07, 0xF8, 0x03, 0xFF, 0x9F, 0xE0, 0x7F, 0x80, 0x7F, 0xF9, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0xDF, 0xE0, 0xFF, 0x81, 0xFF, 0xFC, 0xFE, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81,
  0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xCF, 0xE0, 0x7F,
  0x80, 0x7F, 0xFC, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFD, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xBF, 0x03, 0xF7,
  0xF8, 0x0F, 0xF7, 0xE0, 0x7E, 0xFF, 0x01, 0xFE, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xDF, 0x83, 0xF7, 0xF8, 0x07, 0xFB, 0xF0, 0xFE, 0xFF, 0x01, 0xFF,
  0x7E, 0x1F, 0x9F, 0xE0, 0x3F, 0xEF, 0xC7, 0xF7, 0xFC, 0x07, 0xFD, 0xFC,
  0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0x9F, 0x9F, 0xF0, 0x1F, 0xF3, 0xF7, 0xF3,
  0xFC, 0x03, 0xFC, 0x7E, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x9F, 0xF0,
  0x1F, 0xF1, 0xFF, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xFC, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x1F,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xDF, 0xC0, 0x3F, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF7, 0xF8, 0x0F, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFC, 0x07, 0xFD,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x7F, 0x03, 0xFE, 0x01, 0xFF, 0x3F, 0x81,
  0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC7,
  0xFC, 0x03, 0xFE, 0x1F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF1, 0xFF, 0x00,
  0xFF, 0x87, 0xF8, 0xFF, 0x80, 0xFF, 0x81, 0xFC, 0x7F, 0x80, 0x7F, 0xC0,
  0xFF, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xF0, 0x3F, 0xDF,
  0xF0, 0x0F, 0xF8, 0x1F, 0xEF, 0xF8, 0x07, 0xFC, 0x07, 0xF7, 0xFC, 0x07,
  0xFE, 0x03, 0xFB, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xBE, 0x0F, 0xF8, 0x1F,
  0xE0, 0xFB, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xBE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFB, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0x3E, 0x1F, 0xF0, 0x1F, 0xE1, 0xF3,
  0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0x3E, 0x1F, 0xE0, 0x3F, 0xC3, 0xF3, 0xE1,
  0xFE, 0x03, 0xFC, 0x3E, 0x3E, 0x1F, 0xE0, 0x3F, 0xC3, 0xE3, 0xE3, 0xFC,
  0x03, 0xFC, 0x3E, 0x7E, 0x3F, 0xC0, 0x3F, 0xC7, 0xE7, 0xC3, 0xFC, 0x03,
  0xFC, 0x7C, 0x7C, 0x3F, 0xC0, 0x3F, 0xC7, 0xC7, 0xC7, 0xF8, 0x03, 0xFC,
  0x7C, 0x7C, 0x7F, 0x80, 0x3F, 0xCF, 0x87, 0xC7, 0xF8, 0x03, 0xFC, 0xF8,
  0x7C, 0x7F, 0x00, 0x3F, 0xCF, 0x87, 0xCF, 0xF0, 0x03, 0xF9, 0xF8, 0x7C,
  0xFF, 0x00, 0x3F, 0x9F, 0x07, 0xCF, 0xF0, 0x03, 0xF9, 0xF0, 0x7C, 0xFE,
  0x00, 0x7F, 0x9F, 0x07, 0xCF, 0xE0, 0x07, 0xFB, 0xF0, 0x7D, 0xFE, 0x00,
  0x7F, 0xBE, 0x07, 0xDF, 0xE0, 0x07, 0xFB, 0xE0, 0x7D, 0xFC, 0x00, 0x7F,
  0xBE, 0x07, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0x7C, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF7, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF7,
  0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x01,
  0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF,
  0xFF, 0xFE, 0x03, 0xFF, 0x3F, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0xFE, 0x00,
  0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xFF, 0xDF, 0xF8, 0x01, 0xFF,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xDF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0x3F,
  0xFF, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x8F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF,
  0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x7F, 0xE0, 0x3F, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xF8, 0x03,
  0xFF, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x01,
  0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xFE, 0x3F, 0x81,
  0xFE, 0x00, 0xFF, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xBF, 0xF1, 0xFF, 0xC0,
  0x7F, 0xBF, 0xFD, 0xFF, 0xF0, 0x3F, 0xDF, 0xFE, 0xFF, 0xF8, 0x1F, 0xEF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE7, 0xFE, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x1F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFF,
  0xE0, 0x0F, 0xFC, 0x7F, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0xFC, 0x03, 0xFF,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x01,
  0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFE,
  0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xFF,
  0x00, 0x3F, 0xF7, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xBF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0xDF,
  0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF7, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF,
  0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFF, 0x81, 0xFF, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0xBF,
  0xC0, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF1, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x7F,
  0x83, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xF7,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFB, 0xE0, 0xFF, 0x0F, 0xF8, 0x7D, 0xF0, 0x7F,
  0x87, 0xF8, 0x3E, 0xF8, 0x3F, 0xC3, 0xFC, 0x1E, 0x7C, 0x3F, 0xC1, 0xFE,
  0x1F, 0x3E, 0x1F, 0xE0, 0xFF, 0x0F, 0x9F, 0x0F, 0xF0, 0x7F, 0x87, 0x8F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xC7, 0xC7, 0xF8, 0x1F, 0xE3, 0xE3, 0xE3, 0xFC,
  0x0F, 0xF1, 0xF1, 0xF1, 0xFC, 0x07, 0xF9, 0xF0, 0xF9, 0xFE, 0x03, 0xFC,
  0xF8, 0x7C, 0xFF, 0x01, 0xFE, 0x7C, 0x3E, 0x7F, 0x80, 0xFF, 0x7C, 0x1F,
  0x7F, 0x80, 0x7F, 0xBE, 0x0F, 0xBF, 0xC0, 0x3F, 0xDF, 0x07, 0xDF, 0xE0,
  0x1F, 0xEF, 0x83, 0xEF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F,
  0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07,
  0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x07, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0xBF,
  0xF0, 0x3F, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x04, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0xC0,
  0x7F, 0x8F, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x3F,
  0xC3, 0xFF, 0x87, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFF,
  0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x40, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 19, 50, 41, 12, -50 },
  { 120, 29, 20, 41, 10, -50 },
  { 193, 43, 50, 41, 0, -50 },
  { 462, 40, 70, 41, 1, -60 },
  { 812, 51, 51, 41, -4, -51 },
  { 1138, 41, 52, 41, 0, -51 },
  { 1405, 13, 20, 41, 18, -50 },
  { 1438, 31, 67, 41, 9, -58 },
  { 1698, 30, 67, 41, 4, -58 },
  { 1950, 38, 36, 41, 3, -42 },
  { 2121, 35, 33, 41, 4, -39 },
  { 2266, 21, 21, 41, 5, -10 },
  { 2322, 26, 10, 41, 8, -28 },
  { 2355, 15, 14, 41, 11, -13 },
  { 2382, 45, 65, 41, -1, -57 },
  { 2748, 38, 52, 41, 3, -51 },
  { 2995, 35, 50, 41, 2, -50 },
  { 3214, 38, 51, 41, 2, -51 },
  { 3457, 38, 51, 41, 2, -50 },
  { 3700, 37, 50, 41, 2, -50 },
  { 3932, 38, 51, 41, 2, -50 },
  { 4175, 37, 51, 41, 2, -50 },
  { 4411, 38, 50, 41, 5, -50 },
  { 4649, 39, 52, 41, 2, -51 },
  { 4903, 36, 51, 41, 5, -51 },
  { 5133, 19, 40, 41, 11, -39 },
  { 5228, 25, 50, 41, 5, -39 },
  { 5385, 35, 39, 41, 5, -42 },
  { 5556, 35, 27, 41, 4, -36 },
  { 5675, 36, 39, 41, 2, -42 },
  { 5851, 31, 50, 41, 8, -50 },
  { 6045, 44, 63, 41, -1, -51 },
  { 6392, 38, 50, 41, -1, -50 },
  { 6630, 39, 50, 41, 2, -50 },
  { 6874, 38, 52, 41, 3, -51 },
  { 7121, 40, 50, 41, 1, -50 },
  { 7371, 40, 50, 41, 2, -50 },
  { 7621, 40, 50, 41, 2, -50 },
  { 7871, 38, 52, 41, 3, -51 },
  { 8118, 40, 50, 41, 2, -50 },
  { 8368, 39, 50, 41, 2, -50 },
  { 8612, 41, 51, 41, 0, -50 },
  { 8874, 43, 50, 41, 1, -50 },
  { 9143, 32, 50, 41, 4, -50 },
  { 9343, 43, 50, 41, 0, -50 },
  { 9612, 41, 50, 41, 1, -50 },
  { 9869, 38, 52, 41, 3, -51 },
  { 10116, 41, 50, 41, 2, -50 },
  { 10373, 38, 63, 41, 3, -51 },
  { 10673, 41, 50, 41, 1, -50 },
  { 10930, 40, 52, 41, 1, -51 },
  { 11190, 38, 50, 41, 6, -50 },
  { 11428, 40, 51, 41, 2, -50 },
  { 11683, 38, 50, 41, 7, -50 },
  { 11921, 44, 50, 41, 2, -50 },
  { 12196, 46, 50, 41, -2, -50 },
  { 12484, 39, 50, 41, 6, -50 },
  { 12728, 38, 50, 41, 2, -50 },
  { 12966, 31, 65, 41, 8, -57 },
  { 13218, 25, 65, 41, 9, -57 },
  { 13422, 32, 65, 41, 4, -57 },
  { 13682, 33, 27, 41, 5, -50 },
  { 13794, 35, 9, 41, -1, 2 },
  { 13834, 17, 10, 41, 16, -54 },
  { 13856, 38, 40, 41, 2, -39 },
  { 14046, 37, 51, 41, 2, -50 },
  { 14282, 36, 40, 41, 3, -39 },
  { 14462, 40, 51, 41, 2, -50 },
  { 14717, 36, 40, 41, 3, -39 },
  { 14897, 47, 62, 41, -4, -50 },
  { 15262, 37, 51, 41, 3, -39 },
  { 15498, 37, 50, 41, 2, -50 },
  { 15730, 35, 55, 41, 2, -55 },
  { 15971, 39, 67, 41, 0, -55 },
  { 16298, 41, 50, 41, 2, -50 },
  { 16555, 32, 50, 41, 5, -50 },
  { 16755, 41, 39, 41, 0, -39 },
  { 16955, 37, 39, 41, 2, -39 },
  { 17136, 36, 40, 41, 3, -39 },
  { 17316, 39, 51, 41, 0, -39 },
  { 17565, 38, 51, 41, 2, -39 },
  { 17808, 38, 39, 41, 3, -39 },
  { 17994, 38, 40, 41, 1, -39 },
  { 18184, 36, 48, 41, 4, -48 },
  { 18400, 37, 39, 41, 3, -38 },
  { 18581, 38, 38, 41, 5, -38 },
  { 18762, 41, 38, 41, 3, -38 },
  { 18957, 43, 38, 41, -1, -38 },
  { 19162, 36, 50, 41, 3, -38 },
  { 19387, 37, 38, 41, 2, -38 },
  { 19563, 37, 65, 41, 5, -57 },
  { 19864, 21, 65, 41, 11, -57 },
  { 20035, 37, 65, 41, 1, -57 },
  { 20336, 39, 17, 41, 2, -33 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC69PT7B_H_
