#ifndef _JETBRAINSMONO_EXTRABOLDITALIC29PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x7C, 0xF7,
  0x8F, 0x78, 0xF7, 0x9F, 0x79, 0xFF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0,
  0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x07,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x38, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0xDF, 0x3C, 0xC0, 0x3C, 0xC0, 0x3E, 0x80,
  0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0x3E,
  0x03, 0x3E, 0xF3, 0x3E, 0xFB, 0x3C, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x3C, 0x1F, 0xC1, 0xC0, 0xE7, 0x87, 0x03, 0x8C, 0x38, 0x0E, 0x71, 0xC0,
  0x71, 0xCE, 0x01, 0xC7, 0x70, 0x03, 0xFB, 0x80, 0x0F, 0xDC, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x80, 0x00, 0xEF, 0xC0, 0x07, 0x7F,
  0x80, 0x3B, 0x8E, 0x01, 0xCE, 0x38, 0x0E, 0x38, 0xE0, 0x70, 0xE7, 0x03,
  0xC3, 0x9C, 0x0E, 0x0F, 0xE0, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xF3, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x2F, 0xF9, 0xE7, 0x9E, 0xF3,
  0xCF, 0xF1, 0xE3, 0xF0, 0xF1, 0xF8, 0xF8, 0x78, 0x3C, 0x7E, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xF9, 0xF0, 0x7F, 0xFF, 0xEF, 0x7B, 0xDC, 0xE0, 0x00,
  0x08, 0x01, 0xC0, 0x3C, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x38, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x31, 0xC6, 0x79, 0xDF, 0x7F,
  0xBF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C,
  0xF8, 0x7C, 0x78, 0x38, 0x70, 0x10, 0x40, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x8F, 0x87, 0x87,
  0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x11, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0x3F, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7D, 0x9E,
  0x7B, 0xDE, 0x7B, 0xDE, 0x7B, 0xDE, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C,
  0xF0, 0x3C, 0xF8, 0x3C, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xEF, 0x07, 0x9E, 0x0C,
  0x3C, 0x10, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF,
  0x3E, 0x1F, 0x3C, 0x1F, 0x40, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x3E,
  0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0xF0, 0x3D, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x40, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0xF8, 0x7B, 0xF9, 0xFF,
  0xF3, 0xF3, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3D,
  0xF9, 0xF9, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0x78, 0x1E, 0xF8, 0x3C, 0xF8, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3F, 0x3E, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1E, 0x3E, 0x3E, 0x1F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF8, 0x7C, 0x7C, 0x78, 0x3C, 0xF8, 0x3E, 0xF0, 0x3C, 0xF8, 0x3C,
  0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF3, 0xF1, 0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFD, 0xF9, 0xFF, 0xF1, 0xFB, 0xC1, 0xCF, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x1E, 0x3F, 0x3E, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xFC, 0xFC, 0xF8, 0xF8, 0x03, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x00,
  0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x08, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x80, 0x20, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x7F, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x7F, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C,
  0xE1, 0xEF, 0x78, 0xFD, 0xDE, 0x79, 0xE7, 0x9C, 0x39, 0xC7, 0x0E, 0x73,
  0xC7, 0x9C, 0xF1, 0xEF, 0x3C, 0x7B, 0xCF, 0x1C, 0xF3, 0xCF, 0x3C, 0xFF,
  0xCE, 0x1F, 0x73, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xDE, 0x03, 0xDE, 0x07,
  0xDE, 0x07, 0x9E, 0x07, 0x8E, 0x0F, 0x8F, 0x0F, 0x0F, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0xF8,
  0x0F, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x3E, 0x3F, 0x3C, 0x1F, 0x3C,
  0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFF, 0x1F, 0x3F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0xF8, 0x3C, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x3E, 0x1F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x02, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x3F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0xFE, 0x78, 0xFE, 0x78, 0xFE, 0x79, 0xFE,
  0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xFF, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC7, 0xC1,
  0xE3, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x3C, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF1,
  0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x07,
  0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x1E, 0x0F, 0xC7, 0x83, 0xE1, 0xE1, 0xF0, 0xF8,
  0x78, 0x3E, 0x3E, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xF3, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0xC3, 0xC1,
  0xF0, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC,
  0x7E, 0x3F, 0x1F, 0x9F, 0xCF, 0xE6, 0xE3, 0xFB, 0xB8, 0xF6, 0xFE, 0x3D,
  0xF7, 0x8F, 0x7D, 0xE3, 0x9E, 0x79, 0xE7, 0x9C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xC3, 0xE0, 0xE1, 0xF8, 0x78,
  0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0x71, 0xE1, 0xDC, 0x78, 0x77, 0x1E, 0x3D,
  0xC7, 0x0F, 0x7B, 0xC3, 0xCE, 0xF0, 0xF3, 0xBC, 0x3C, 0xEF, 0x0E, 0x3B,
  0xC7, 0x8E, 0xE1, 0xE3, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1,
  0xE1, 0xF8, 0xF0, 0x7C, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x3F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8,
  0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x7C,
  0xF0, 0x3E, 0x78, 0x1E, 0x3C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0x3F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F,
  0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E,
  0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x78,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x7C, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF,
  0x3F, 0x3F, 0x3E, 0x1F, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E,
  0xF0, 0x3E, 0xF8, 0x3C, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x8F, 0x07, 0x8F, 0x83, 0xC7, 0xC1,
  0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x7C, 0x1E, 0x3E,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xF3, 0xE0, 0xF1,
  0xF0, 0x78, 0xF8, 0x7C, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC,
  0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8,
  0x78, 0xF8, 0x78, 0xF8, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79,
  0xE0, 0x79, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7B, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0xE3, 0xDE, 0x38, 0xF7,
  0x9E, 0x3D, 0xE7, 0x8E, 0x71, 0xE3, 0x9C, 0x79, 0xE7, 0x36, 0x71, 0xCD,
  0x9C, 0x73, 0x67, 0x1D, 0xDB, 0xC7, 0x66, 0xE1, 0xD9, 0xB8, 0x76, 0x6E,
  0x3F, 0x9F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0xEC, 0xFC, 0x3E, 0x3F, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x78, 0x3C,
  0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xE0, 0x1F,
  0x3E, 0x01, 0xE1, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x80,
  0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0x7C, 0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0xF0, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0x70, 0x79,
  0xC1, 0xE7, 0x8F, 0x1E, 0x3C, 0x79, 0xE0, 0xFF, 0x83, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF1, 0xF0, 0x0F, 0xDF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78,
  0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x9F, 0x0F, 0x7F, 0x1F, 0xFF, 0x3F, 0xFE, 0xF8, 0x7D,
  0xF0, 0x7B, 0xC0, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0x7C, 0x1E, 0xF8,
  0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xBF, 0x8F, 0x7E, 0x00, 0x07, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x3C, 0xF8, 0x3C, 0xFF, 0xFC, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x7E, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xF7, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF1, 0xF7, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xBF, 0xFF, 0x7F, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x87, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0x0F, 0xDF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x7F,
  0xFC, 0x7F, 0xBC, 0x7F, 0xFC, 0x3F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x9F, 0x0F, 0x7F, 0x1F, 0xFF, 0x3F, 0xFE,
  0xF8, 0x7D, 0xF0, 0x7B, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0x9E, 0x0F, 0x7C,
  0x1E, 0xF8, 0x3D, 0xF0, 0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0x80, 0x00,
  0x70, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x7C, 0xF0, 0x7C, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x3E,
  0x1F, 0x3E, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xF1,
  0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x8F, 0x03, 0xC0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07,
  0xF8, 0x3D, 0xCF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0x9C, 0xF3, 0xCE, 0x79,
  0xC7, 0x3D, 0xE7, 0x1C, 0xF3, 0x8E, 0x79, 0xCF, 0x3C, 0xE7, 0x9E, 0x73,
  0xCE, 0x39, 0xEF, 0x3C, 0xF7, 0x9C, 0x73, 0xCE, 0x79, 0xE7, 0x3C, 0x3C,
  0xF8, 0x7B, 0xF8, 0xFF, 0xF9, 0xFF, 0xF7, 0xC3, 0xEF, 0x83, 0xDE, 0x0F,
  0xBC, 0x1F, 0x78, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0xC1, 0xEF, 0x87, 0xDE,
  0x0F, 0xBC, 0x1F, 0x78, 0x3C, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xF7, 0xC3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x1F, 0x78, 0x3F, 0xF0, 0x7B,
  0xE0, 0xF7, 0xC3, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x1E,
  0x7C, 0x1E, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x1F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7F,
  0xFE, 0x7F, 0xFC, 0x7B, 0xF8, 0x7B, 0xF0, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xDF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3E,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x1E,
  0xFC, 0x3D, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C,
  0x1F, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3C, 0x3E, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F,
  0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xC0, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0x7C, 0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x71, 0xC3, 0xF8,
  0xE1, 0xFC, 0x71, 0xFE, 0x78, 0xEF, 0x3C, 0x77, 0x9E, 0x7B, 0xDB, 0x39,
  0xED, 0x9C, 0xF6, 0xDE, 0x7F, 0x6E, 0x3F, 0x37, 0x1F, 0x9B, 0x8F, 0xCF,
  0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x1F, 0x07, 0xE1, 0xF1, 0xF0,
  0x1E, 0x3E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x01,
  0xF3, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0xC7, 0xE0, 0xF8, 0x3C, 0x1F, 0x3C,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78,
  0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F,
  0x78, 0x1E, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x7E,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x3F, 0x8F, 0x7F, 0x8F, 0x7F, 0xCF, 0xF3, 0xFE, 0xF1, 0xFE,
  0xF0, 0xFC,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 21, 17, 5, -21 },
  { 22, 12, 9, 17, 4, -21 },
  { 36, 18, 21, 17, 0, -21 },
  { 84, 16, 29, 17, 1, -25 },
  { 142, 22, 21, 17, -2, -21 },
  { 200, 17, 21, 17, 0, -21 },
  { 245, 5, 9, 17, 8, -21 },
  { 251, 13, 29, 17, 4, -25 },
  { 299, 13, 29, 17, 1, -25 },
  { 347, 16, 16, 17, 1, -18 },
  { 379, 14, 14, 17, 2, -17 },
  { 404, 9, 9, 17, 2, -4 },
  { 415, 10, 4, 17, 4, -12 },
  { 420, 6, 6, 17, 5, -6 },
  { 425, 18, 27, 17, 0, -24 },
  { 486, 16, 21, 17, 1, -21 },
  { 528, 15, 21, 17, 1, -21 },
  { 568, 16, 21, 17, 1, -21 },
  { 610, 16, 21, 17, 1, -21 },
  { 652, 16, 21, 17, 1, -21 },
  { 694, 16, 21, 17, 1, -21 },
  { 736, 15, 21, 17, 1, -21 },
  { 776, 16, 21, 17, 2, -21 },
  { 818, 16, 21, 17, 1, -21 },
  { 860, 15, 21, 17, 2, -21 },
  { 900, 8, 16, 17, 5, -16 },
  { 916, 11, 21, 17, 2, -16 },
  { 945, 15, 17, 17, 2, -18 },
  { 977, 14, 11, 17, 2, -15 },
  { 997, 15, 17, 17, 1, -18 },
  { 1029, 13, 21, 17, 3, -21 },
  { 1064, 18, 26, 17, 0, -21 },
  { 1123, 16, 21, 17, -1, -21 },
  { 1165, 16, 21, 17, 1, -21 },
  { 1207, 16, 21, 17, 1, -21 },
  { 1249, 16, 21, 17, 1, -21 },
  { 1291, 16, 21, 17, 1, -21 },
  { 1333, 17, 21, 17, 1, -21 },
  { 1378, 16, 21, 17, 1, -21 },
  { 1420, 17, 21, 17, 1, -21 },
  { 1465, 16, 21, 17, 1, -21 },
  { 1507, 17, 21, 17, 0, -21 },
  { 1552, 18, 21, 17, 1, -21 },
  { 1600, 14, 21, 17, 1, -21 },
  { 1637, 18, 21, 17, 0, -21 },
  { 1685, 18, 21, 17, 0, -21 },
  { 1733, 16, 21, 17, 1, -21 },
  { 1775, 17, 21, 17, 1, -21 },
  { 1820, 16, 26, 17, 1, -21 },
  { 1872, 16, 21, 17, 1, -21 },
  { 1914, 16, 21, 17, 1, -21 },
  { 1956, 15, 21, 17, 3, -21 },
  { 1996, 17, 21, 17, 1, -21 },
  { 2041, 16, 21, 17, 3, -21 },
  { 2083, 18, 21, 17, 1, -21 },
  { 2131, 20, 21, 17, -1, -21 },
  { 2184, 16, 21, 17, 3, -21 },
  { 2226, 16, 21, 17, 1, -21 },
  { 2268, 13, 27, 17, 3, -24 },
  { 2312, 10, 27, 17, 4, -24 },
  { 2346, 13, 27, 17, 2, -24 },
  { 2390, 14, 11, 17, 2, -21 },
  { 2410, 14, 4, 17, 0, 1 },
  { 2417, 7, 4, 17, 7, -23 },
  { 2421, 16, 16, 17, 1, -16 },
  { 2453, 15, 21, 17, 1, -21 },
  { 2493, 16, 16, 17, 1, -16 },
  { 2525, 17, 21, 17, 1, -21 },
  { 2570, 15, 16, 17, 1, -16 },
  { 2600, 20, 26, 17, -2, -21 },
  { 2665, 16, 21, 17, 1, -16 },
  { 2707, 15, 21, 17, 1, -21 },
  { 2747, 15, 23, 17, 1, -23 },
  { 2791, 16, 28, 17, 0, -23 },
  { 2847, 17, 21, 17, 1, -21 },
  { 2892, 14, 21, 17, 2, -21 },
  { 2929, 17, 16, 17, 0, -16 },
  { 2963, 15, 16, 17, 1, -16 },
  { 2993, 15, 16, 17, 1, -16 },
  { 3023, 16, 21, 17, 0, -16 },
  { 3065, 16, 21, 17, 1, -16 },
  { 3107, 16, 16, 17, 1, -16 },
  { 3139, 16, 16, 17, 1, -16 },
  { 3171, 15, 20, 17, 2, -20 },
  { 3209, 16, 16, 17, 1, -16 },
  { 3241, 16, 16, 17, 2, -16 },
  { 3273, 17, 16, 17, 1, -16 },
  { 3307, 19, 16, 17, -1, -16 },
  { 3345, 16, 21, 17, 1, -16 },
  { 3387, 15, 16, 17, 1, -16 },
  { 3417, 16, 27, 17, 2, -24 },
  { 3471, 8, 27, 17, 5, -24 },
  { 3498, 16, 27, 17, 0, -24 },
  { 3552, 16, 7, 17, 1, -14 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC29PT7B_H_
