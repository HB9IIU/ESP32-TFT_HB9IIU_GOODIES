#ifndef _JETBRAINSMONO_EXTRABOLDITALIC48PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xCF,
  0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xB9, 0xFE, 0x0F, 0xF3, 0x8F, 0xE0, 0xFE, 0x38, 0xFE, 0x0F, 0xE3,
  0x80, 0x00, 0xFE, 0x78, 0x00, 0x1F, 0xE7, 0x00, 0x00, 0xFF, 0x70, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xE7, 0xF8, 0x00,
  0x1E, 0x3F, 0x80, 0x01, 0xC3, 0xF8, 0x7F, 0x1C, 0x3F, 0x87, 0xF1, 0xC7,
  0xF8, 0x7F, 0x1C, 0x7F, 0x07, 0xF9, 0xCF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07,
  0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0xF8,
  0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF1, 0xF0, 0x00, 0x7C,
  0x1F, 0x1F, 0x00, 0x07, 0xC1, 0xF3, 0xE0, 0x00, 0x7E, 0x3E, 0x7C, 0x00,
  0x03, 0xFF, 0xEF, 0x80, 0x00, 0x3F, 0xFD, 0xF0, 0x00, 0x01, 0xFF, 0x3E,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x07, 0xCF, 0xF8, 0x00, 0x00, 0xFB, 0xFF, 0xC0, 0x00, 0x1F, 0x3F,
  0xFC, 0x00, 0x03, 0xE7, 0xC7, 0xE0, 0x00, 0x7C, 0x78, 0x3E, 0x00, 0x0F,
  0xCF, 0x83, 0xE0, 0x00, 0xF8, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x83, 0xC0,
  0x03, 0xE0, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0xF8,
  0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x7F, 0x3F, 0xBF, 0x8F, 0xE3, 0xF9, 0xFC,
  0xFC, 0x3F, 0x1F, 0xDF, 0xC7, 0xF0, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0x07,
  0xF0, 0x7F, 0xF0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0x80, 0xFF,
  0xC1, 0xFC, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFC, 0xFC, 0xFC, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x01, 0xC1, 0xF0, 0x38, 0xF8, 0x3C, 0x3E, 0x7F, 0x8E, 0x3F, 0xDF,
  0xF3, 0x9F, 0xFF, 0xFE, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xF7,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F,
  0xC3, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xF0, 0x3F, 0x00, 0x38, 0x07, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x78, 0xFE, 0x3F, 0xBF, 0x3F, 0x8F, 0xCF, 0xCF, 0xE3,
  0xF3, 0xF3, 0xF9, 0xFC, 0xFC, 0xFC, 0x7F, 0x3F, 0x3F, 0x1F, 0xC7, 0x9F,
  0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x0F, 0xC7,
  0xF0, 0x0F, 0x87, 0xF0, 0x0E, 0x0F, 0xF0, 0x1C, 0x0F, 0xF0, 0x10, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF0,
  0x0F, 0xE3, 0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xC0, 0x7F,
  0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0x80, 0x3F, 0x9F,
  0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0xC1,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xF8, 0x1F,
  0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xF8, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x03, 0x87, 0xC1, 0xF0, 0x3F, 0xCF, 0x87,
  0xE0, 0xFF, 0xDF, 0x0F, 0xC1, 0xFF, 0xBE, 0x1F, 0x87, 0xF3, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x03, 0xF0, 0xF8, 0x7E, 0x07, 0xC1, 0xF0,
  0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x8F,
  0xC0, 0xFC, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x3F, 0x03, 0xE0, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xFF,
  0xFE, 0x1F, 0x87, 0xFF, 0x7C, 0x3F, 0x07, 0xFD, 0xF0, 0x7E, 0x07, 0xF3,
  0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x3F, 0xC7, 0xFF, 0xC7,
  0xF0, 0xFF, 0xF8, 0xFE, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xF8, 0xF7, 0xE0, 0xFD, 0xE7, 0xDF, 0x83, 0xF7, 0x9E, 0xFC, 0x1F,
  0x9E, 0xFB, 0xF0, 0x7E, 0x7B, 0xCF, 0xC1, 0xF9, 0xEF, 0x3F, 0x07, 0xE7,
  0xFC, 0xFC, 0x1F, 0x9F, 0xE7, 0xF0, 0x7E, 0x7F, 0x9F, 0x81, 0xF9, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF1, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xFC, 0x03,
  0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0x0F,
  0xFE, 0x07, 0xE0, 0xFF, 0xE0, 0x7E, 0x0F, 0xFE, 0x07, 0xE0, 0xFF, 0xE0,
  0x7E, 0x0F, 0xFF, 0x0F, 0xE1, 0xFB, 0xF0, 0xFE, 0x1F, 0x9F, 0x0F, 0xC1,
  0xF9, 0xF0, 0xFC, 0x1F, 0x9F, 0x0F, 0xC1, 0xF9, 0xF0, 0xFC, 0x1F, 0x9F,
  0x9F, 0xC1, 0xF9, 0xF9, 0xFC, 0x3F, 0x8F, 0x9F, 0x83, 0xF8, 0xF9, 0xF8,
  0x3F, 0x0F, 0x9F, 0x83, 0xF0, 0xF9, 0xF8, 0x3F, 0x0F, 0xDF, 0x83, 0xF0,
  0xFD, 0xF8, 0x7F, 0x07, 0xDF, 0x07, 0xF0, 0x7D, 0xF0, 0x7E, 0x07, 0xDF,
  0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0xFE,
  0x03, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC1, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0xFC,
  0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0xFE, 0x1F, 0x8F, 0x83, 0xF0, 0x7E, 0x3E,
  0x0F, 0xC1, 0xF8, 0xF8, 0x3F, 0x07, 0xC7, 0xE1, 0xFC, 0x3F, 0x1F, 0x87,
  0x70, 0xFC, 0x7E, 0x1D, 0xC3, 0xF1, 0xF8, 0xF7, 0x0F, 0x87, 0xE3, 0xDC,
  0x7E, 0x1F, 0x8E, 0x71, 0xF8, 0x7E, 0x3B, 0xC7, 0xE1, 0xF9, 0xEF, 0x1F,
  0x07, 0xC7, 0xBC, 0xFC, 0x1F, 0x1C, 0xF3, 0xF0, 0x7C, 0x73, 0xCF, 0xC1,
  0xF3, 0xCF, 0x3E, 0x07, 0xCF, 0x3C, 0xF8, 0x1F, 0x38, 0xF7, 0xE0, 0x7D,
  0xE3, 0xDF, 0x03, 0xF7, 0x8F, 0x7C, 0x0F, 0xDE, 0x39, 0xF0, 0x3F, 0x70,
  0xEF, 0xC0, 0xFF, 0xC3, 0xBE, 0x03, 0xFF, 0x0E, 0xF8, 0x0F, 0xB8, 0x3B,
  0xE0, 0x3E, 0xE0, 0xEF, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x7F,
  0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0,
  0x7F, 0x3F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xCF,
  0xF0, 0x7F, 0xFB, 0xF8, 0x3F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xBF, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFD, 0xFC, 0x0F, 0xFE, 0x7F, 0x01, 0xFF, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0xFF, 0x80, 0xFE, 0xFF, 0xF0, 0x3F, 0xBF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF7, 0xFF, 0xE1, 0xFF, 0xCF, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xF8, 0x3F, 0x9F, 0xFC,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE7, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xDF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xBF, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x1F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x1F, 0xFE, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xE1, 0xFE, 0x07, 0xFC, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFC, 0x07, 0xFF, 0x3F, 0x80,
  0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0x81, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xCF, 0xF0, 0x7F, 0xFB, 0xF8, 0x3F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0xC0, 0xFF, 0xE7,
  0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0xFF,
  0x80, 0xFE, 0xFF, 0xF0, 0x3F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF7,
  0xFF, 0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF1, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x03, 0x80,
  0xFD, 0xF8, 0xFE, 0x0F, 0xBF, 0xDF, 0xF0, 0xFB, 0xFD, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFC, 0x7E, 0x7F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F,
  0x1F, 0x87, 0xC7, 0xF1, 0xF8, 0x7C, 0x7F, 0x3F, 0x8F, 0x87, 0xE3, 0xF8,
  0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x8F,
  0xE3, 0xF0, 0xF8, 0xFE, 0x3F, 0x1F, 0x0F, 0xC7, 0xF1, 0xF0, 0xFC, 0x7E,
  0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF1,
  0xFC, 0x7E, 0x1F, 0x1F, 0x8F, 0xE3, 0xE1, 0xF8, 0xFE, 0x3E, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xF8,
  0xFF, 0x80, 0xFE, 0xFF, 0xF0, 0x3F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xF7, 0xFF, 0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F, 0x80, 0xFF,
  0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01,
  0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xE0,
  0x3F, 0xCF, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFE, 0x3F, 0xE0, 0x1F, 0xDF, 0xFE, 0x03, 0xFB,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xDF, 0xFF, 0x83, 0xFF, 0x9F, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xE7, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x7F, 0xFB, 0xF8,
  0x3F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0x3F,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xC7,
  0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF7, 0xF0, 0x7F, 0xFD, 0xFC, 0x0F,
  0xFE, 0x7F, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x07, 0xEF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x01, 0xFC,
  0xFF, 0x00, 0x7F, 0x3F, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7C, 0x0F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3E, 0xFC, 0x3F, 0x87, 0xEF, 0xC3, 0xF8, 0x7E,
  0xFC, 0x3F, 0x87, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0x77, 0x8F, 0xCF, 0xC7,
  0x78, 0xF8, 0xFC, 0x77, 0x8F, 0x8F, 0xCF, 0x79, 0xF8, 0xFC, 0xE7, 0x9F,
  0x0F, 0xCE, 0x79, 0xF0, 0xFD, 0xE7, 0xBF, 0x0F, 0xDC, 0x7B, 0xF0, 0xFD,
  0xC7, 0xBE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x3F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFE,
  0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0xC1, 0xFF, 0xEF, 0xE0, 0x7F, 0xE7, 0xF0,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xF3, 0xFF,
  0xC0, 0xFC, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x0F, 0xDF, 0xFF, 0xC3, 0xFF,
  0xC3, 0xF9, 0xFB, 0xF0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x3F, 0x07, 0xFF,
  0xCF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 14, 35, 29, 8, -35 },
  { 63, 20, 14, 29, 7, -35 },
  { 98, 30, 35, 29, 0, -35 },
  { 230, 28, 49, 29, 1, -42 },
  { 402, 36, 35, 29, -3, -35 },
  { 560, 28, 36, 29, 0, -36 },
  { 686, 8, 14, 29, 13, -35 },
  { 700, 22, 47, 29, 6, -41 },
  { 830, 21, 47, 29, 2, -41 },
  { 954, 26, 25, 29, 2, -29 },
  { 1036, 25, 23, 29, 2, -27 },
  { 1108, 15, 15, 29, 3, -7 },
  { 1137, 18, 7, 29, 6, -19 },
  { 1153, 10, 9, 29, 8, -9 },
  { 1165, 32, 45, 29, -1, -40 },
  { 1345, 26, 36, 29, 2, -36 },
  { 1462, 24, 35, 29, 2, -35 },
  { 1567, 27, 36, 29, 1, -36 },
  { 1689, 27, 35, 29, 1, -35 },
  { 1808, 25, 35, 29, 2, -35 },
  { 1918, 26, 35, 29, 2, -35 },
  { 2032, 26, 35, 29, 1, -35 },
  { 2146, 26, 35, 29, 4, -35 },
  { 2260, 27, 36, 29, 1, -36 },
  { 2382, 26, 36, 29, 3, -36 },
  { 2499, 13, 27, 29, 8, -27 },
  { 2543, 17, 35, 29, 4, -27 },
  { 2618, 25, 27, 29, 3, -29 },
  { 2703, 24, 19, 29, 3, -25 },
  { 2760, 24, 27, 29, 2, -29 },
  { 2841, 21, 35, 29, 6, -35 },
  { 2933, 31, 45, 29, -1, -36 },
  { 3108, 26, 35, 29, -1, -35 },
  { 3222, 28, 35, 29, 1, -35 },
  { 3345, 27, 36, 29, 2, -36 },
  { 3467, 28, 35, 29, 1, -35 },
  { 3590, 27, 35, 29, 2, -35 },
  { 3709, 28, 35, 29, 1, -35 },
  { 3832, 27, 36, 29, 2, -36 },
  { 3954, 28, 35, 29, 1, -35 },
  { 4077, 26, 35, 29, 2, -35 },
  { 4191, 28, 36, 29, 0, -35 },
  { 4317, 30, 35, 29, 1, -35 },
  { 4449, 23, 35, 29, 2, -35 },
  { 4550, 30, 35, 29, 0, -35 },
  { 4682, 28, 35, 29, 1, -35 },
  { 4805, 26, 36, 29, 2, -36 },
  { 4922, 29, 35, 29, 1, -35 },
  { 5049, 26, 45, 29, 2, -36 },
  { 5196, 28, 35, 29, 1, -35 },
  { 5319, 28, 36, 29, 1, -36 },
  { 5445, 26, 35, 29, 4, -35 },
  { 5559, 27, 35, 29, 2, -35 },
  { 5678, 26, 35, 29, 5, -35 },
  { 5792, 30, 35, 29, 2, -35 },
  { 5924, 32, 35, 29, -1, -35 },
  { 6064, 28, 35, 29, 4, -35 },
  { 6187, 26, 35, 29, 2, -35 },
  { 6301, 22, 45, 29, 5, -40 },
  { 6425, 16, 45, 29, 7, -40 },
  { 6515, 22, 45, 29, 3, -40 },
  { 6639, 23, 19, 29, 3, -35 },
  { 6694, 24, 7, 29, 0, 1 },
  { 6715, 12, 7, 29, 11, -38 },
  { 6726, 26, 27, 29, 2, -27 },
  { 6814, 26, 35, 29, 1, -35 },
  { 6928, 25, 27, 29, 2, -27 },
  { 7013, 27, 35, 29, 2, -35 },
  { 7132, 25, 27, 29, 2, -27 },
  { 7217, 33, 44, 29, -3, -35 },
  { 7399, 26, 36, 29, 2, -27 },
  { 7516, 26, 35, 29, 1, -35 },
  { 7630, 25, 38, 29, 1, -38 },
  { 7749, 27, 47, 29, 0, -38 },
  { 7908, 29, 35, 29, 1, -35 },
  { 8035, 22, 35, 29, 4, -35 },
  { 8132, 28, 27, 29, 0, -27 },
  { 8227, 26, 27, 29, 1, -27 },
  { 8315, 25, 27, 29, 2, -27 },
  { 8400, 27, 36, 29, 0, -27 },
  { 8522, 26, 36, 29, 2, -27 },
  { 8639, 27, 27, 29, 2, -27 },
  { 8731, 26, 27, 29, 1, -27 },
  { 8819, 25, 34, 29, 3, -34 },
  { 8926, 26, 26, 29, 2, -26 },
  { 9011, 27, 26, 29, 3, -26 },
  { 9099, 28, 26, 29, 2, -26 },
  { 9190, 30, 26, 29, -1, -26 },
  { 9288, 25, 35, 29, 2, -26 },
  { 9398, 26, 26, 29, 1, -26 },
  { 9483, 25, 45, 29, 4, -40 },
  { 9624, 14, 45, 29, 8, -40 },
  { 9703, 25, 45, 29, 1, -40 },
  { 9844, 26, 12, 29, 2, -23 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC48PT7B_H_
