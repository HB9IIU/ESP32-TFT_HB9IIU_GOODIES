#ifndef _JETBRAINSMONO_EXTRABOLDITALIC44PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F,
  0xC0, 0x7F, 0x1F, 0xDF, 0x87, 0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x3F,
  0xBF, 0x8F, 0xEF, 0xC3, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF,
  0xF0, 0xFE, 0x73, 0xF8, 0x7E, 0x31, 0xFC, 0x7F, 0x38, 0x00, 0x3F, 0x9C,
  0x00, 0x1F, 0xCE, 0x00, 0x0F, 0xF7, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0E, 0x7F, 0x80,
  0x07, 0x1F, 0xC0, 0x03, 0x8F, 0xE7, 0xF1, 0xC7, 0xF3, 0xF8, 0xE3, 0xF1,
  0xFE, 0x73, 0xF8, 0x7F, 0xB7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x7F, 0xE0,
  0x0F, 0x80, 0x7F, 0xF8, 0x0F, 0x80, 0x7E, 0x7C, 0x0F, 0x80, 0x3C, 0x3E,
  0x07, 0x80, 0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x87, 0x80, 0x0F, 0x87,
  0xC7, 0xC0, 0x07, 0xC3, 0xC7, 0xC0, 0x03, 0xE1, 0xE7, 0xC0, 0x01, 0xF1,
  0xF7, 0xC0, 0x00, 0x7F, 0xF7, 0xC0, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x0F,
  0xF3, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x00,
  0x03, 0xEF, 0xFE, 0x00, 0x03, 0xEF, 0xFF, 0x00, 0x01, 0xE7, 0xCF, 0x80,
  0x01, 0xE7, 0xC3, 0xC0, 0x01, 0xF3, 0xE1, 0xE0, 0x01, 0xF1, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x3C, 0x01, 0xF0, 0x3C, 0x3E,
  0x01, 0xF0, 0x1F, 0xFE, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x03, 0xFF,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x87, 0xF3, 0xFF, 0xF1, 0xF8, 0xFC, 0xFC, 0xFC, 0x3F, 0x3F,
  0xBF, 0x1F, 0xC7, 0xFF, 0x87, 0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x7E,
  0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB,
  0xF8, 0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFE, 0xFE,
  0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x20,
  0x3E, 0x02, 0x38, 0x3E, 0x0E, 0x3E, 0x3C, 0x3E, 0x7F, 0x1C, 0xFE, 0x7F,
  0x99, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xCF, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0x8F, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1E,
  0x07, 0x80, 0x0C, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0x1F,
  0xE7, 0xF9, 0xFE, 0xFF, 0xBF, 0xE7, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x3C, 0x7E, 0x7F, 0x7E, 0xFE, 0x7E,
  0x7E, 0xFC, 0x7E, 0x7E, 0xFC, 0x7E, 0x7C, 0xFC, 0x7E, 0x3C, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0xC0, 0x70, 0x7F, 0x01, 0x81, 0xFC, 0x04, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xE1, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0xFD, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF1,
  0x80, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x7F,
  0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x01,
  0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0,
  0xFF, 0x3F, 0xE7, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xBF, 0x80, 0x10, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x7F,
  0x8F, 0xF8, 0xFF, 0x87, 0xF0, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x7E, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x01,
  0xE3, 0xE1, 0xF8, 0x3F, 0x9F, 0x0F, 0xC3, 0xFE, 0xF8, 0x7C, 0x3F, 0xF7,
  0xC3, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F,
  0xC7, 0xC0, 0xF8, 0x7E, 0x3E, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0xFC, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0x7E, 0x3E, 0x07,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC7, 0xF0, 0xF8, 0x7F, 0xFF, 0x07,
  0xC1, 0xFE, 0x78, 0x3E, 0x07, 0xE7, 0xC1, 0xF0, 0x08, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x7F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0x83, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0x03, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x3F, 0x03, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFE, 0x7F, 0x1F, 0xFE,
  0x7F, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFF, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7E, 0x0F, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x7B, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xB8, 0xF7, 0xC1, 0xFB, 0xCF, 0x7C,
  0x1F, 0xBD, 0xE7, 0xC1, 0xFB, 0xDE, 0xFC, 0x1F, 0xBD, 0xEF, 0xC1, 0xFB,
  0xFC, 0xFC, 0x1F, 0x3F, 0xCF, 0x81, 0xF3, 0xF9, 0xF8, 0x3F, 0x3F, 0x9F,
  0x83, 0xF1, 0xF9, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC1, 0xFE, 0x03, 0xF0,
  0xFF, 0x80, 0xFC, 0x3F, 0xE0, 0x3E, 0x0F, 0xF8, 0x1F, 0x83, 0xFE, 0x07,
  0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x7E, 0x1F, 0xFC, 0x1F, 0x87, 0xFF,
  0x07, 0xC1, 0xFF, 0xC3, 0xF0, 0x7C, 0xF0, 0xFC, 0x1F, 0x3E, 0x3F, 0x07,
  0xCF, 0x8F, 0xC3, 0xF3, 0xE3, 0xF0, 0xFC, 0xF8, 0xF8, 0x3F, 0x3E, 0x3E,
  0x0F, 0xC7, 0xDF, 0x83, 0xF1, 0xF7, 0xE0, 0xFC, 0x7D, 0xF8, 0x3E, 0x1F,
  0x7E, 0x1F, 0x87, 0xDF, 0x87, 0xE0, 0xF7, 0xC1, 0xF8, 0x3F, 0xF0, 0x7E,
  0x0F, 0xFC, 0x1F, 0x83, 0xFF, 0x07, 0xC0, 0xFF, 0xC3, 0xF0, 0x3F, 0xF0,
  0xFC, 0x07, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x1F,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x8F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFE, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0, 0xFF,
  0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x9F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0,
  0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0x07, 0xC1, 0xF3, 0xF0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC3, 0xE3, 0xF0, 0xFC,
  0x3E, 0x3F, 0x0F, 0xC3, 0xE3, 0xE1, 0xDC, 0x7E, 0x3E, 0x1F, 0xC7, 0xC3,
  0xE1, 0xFC, 0x7C, 0x3E, 0x3F, 0x87, 0xC3, 0xE3, 0xB8, 0xFC, 0x3E, 0x3B,
  0x8F, 0x83, 0xE3, 0xB8, 0xF8, 0x3E, 0x7B, 0x8F, 0x83, 0xE7, 0x38, 0xF8,
  0x3E, 0x73, 0x9F, 0x03, 0xE7, 0x39, 0xF0, 0x3E, 0xF3, 0x9F, 0x07, 0xCE,
  0x39, 0xF0, 0x7C, 0xE3, 0xBE, 0x07, 0xDE, 0x3B, 0xE0, 0x7D, 0xE3, 0xBE,
  0x07, 0xDC, 0x3B, 0xE0, 0x7D, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F,
  0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x03, 0xF0,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xEF,
  0xC0, 0x3F, 0xFE, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x00, 0x18, 0x00, 0x01,
  0xFE, 0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFD, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xFB, 0xF8, 0x0F, 0xF3, 0xF8, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xC0, 0x0F,
  0xCF, 0xF8, 0x0F, 0xDF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFE, 0xFF, 0xE0, 0xFE, 0xFF, 0xC0, 0xFC, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7F, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xFC, 0x7F, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x60,
  0xFC, 0x01, 0xFE, 0x3F, 0x00, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07,
  0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF8, 0x0F, 0xFF, 0x7E,
  0x01, 0xFF, 0xBF, 0x80, 0x3F, 0xCF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF,
  0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE7, 0xF0, 0x3F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0xFC, 0x1F, 0xF9, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0x9F, 0xC0, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFE,
  0x03, 0xF9, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xBF, 0x07, 0xFE, 0x7E, 0x07, 0xF9, 0xFC, 0x03, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xC0,
  0x0F, 0xC7, 0xF8, 0x0F, 0xDF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0xC3, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x04, 0x04, 0x03, 0xEF, 0xC7, 0xE1, 0xFF,
  0xF3, 0xF8, 0x7F, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE3, 0xE3, 0xF1,
  0xF8, 0xF8, 0xFC, 0x7C, 0x3C, 0x3E, 0x3F, 0x0F, 0x0F, 0x8F, 0xC7, 0xC7,
  0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x87,
  0x87, 0xE3, 0xE1, 0xE1, 0xF1, 0xF8, 0x78, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F,
  0x8F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF0, 0xFC, 0x7C, 0x3C, 0x3E,
  0x3F, 0x0F, 0x0F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C,
  0x7E, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC7, 0xF8, 0x0F, 0xDF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x7E,
  0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE7,
  0xFC, 0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x03, 0xF3, 0xFE, 0x01,
  0xFB, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFD, 0xFF, 0xC0, 0xFE, 0xFF, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF,
  0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xCF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB,
  0xF8, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0xCF, 0xF8, 0x1F, 0x9F,
  0xFC, 0x1F, 0xBF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xE1,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3,
  0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x0F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x1E, 0x0F,
  0xFF, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3E, 0xF8, 0x7E,
  0x1F, 0x3E, 0x1F, 0x87, 0xCF, 0x87, 0xE1, 0xF3, 0xE3, 0xB8, 0xFC, 0xF8,
  0xEE, 0x3E, 0x3E, 0x3B, 0x8F, 0x8F, 0x9E, 0xE3, 0xE3, 0xE7, 0x39, 0xF0,
  0xF9, 0xCE, 0x7C, 0x3E, 0x73, 0x9F, 0x0F, 0xB8, 0xEF, 0x83, 0xEE, 0x3B,
  0xE0, 0xFB, 0x8E, 0xF8, 0x3F, 0xE3, 0xBC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x83,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xC3, 0xFF, 0xDF,
  0x83, 0xFF, 0x7F, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0x3F, 0xF8, 0x3F,
  0x7F, 0xFC, 0x3E, 0x7F, 0xFC, 0x3E, 0xFC, 0xFE, 0x3E, 0xF8, 0x7F, 0xFE,
  0xF8, 0x3F, 0xFC, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 12, 32, 26, 8, -32 },
  { 49, 18, 13, 26, 7, -32 },
  { 79, 28, 32, 26, 0, -32 },
  { 191, 25, 44, 26, 1, -38 },
  { 329, 33, 32, 26, -3, -32 },
  { 461, 26, 33, 26, 0, -33 },
  { 569, 8, 13, 26, 12, -32 },
  { 582, 19, 43, 26, 6, -37 },
  { 685, 19, 43, 26, 2, -37 },
  { 788, 24, 23, 26, 2, -27 },
  { 857, 23, 21, 26, 2, -25 },
  { 918, 14, 14, 26, 3, -7 },
  { 943, 17, 7, 26, 5, -18 },
  { 958, 10, 8, 26, 7, -8 },
  { 968, 28, 42, 26, 0, -37 },
  { 1115, 24, 33, 26, 2, -33 },
  { 1214, 22, 32, 26, 2, -32 },
  { 1302, 25, 33, 26, 1, -33 },
  { 1406, 25, 32, 26, 1, -32 },
  { 1506, 24, 32, 26, 1, -32 },
  { 1602, 25, 32, 26, 1, -32 },
  { 1702, 24, 32, 26, 1, -32 },
  { 1798, 24, 32, 26, 3, -32 },
  { 1894, 25, 33, 26, 1, -33 },
  { 1998, 23, 33, 26, 3, -33 },
  { 2093, 12, 25, 26, 7, -25 },
  { 2131, 16, 32, 26, 3, -25 },
  { 2195, 23, 25, 26, 3, -27 },
  { 2267, 22, 17, 26, 3, -23 },
  { 2314, 23, 25, 26, 1, -27 },
  { 2386, 20, 32, 26, 5, -32 },
  { 2466, 29, 41, 26, -1, -33 },
  { 2615, 24, 32, 26, -1, -32 },
  { 2711, 25, 32, 26, 1, -32 },
  { 2811, 24, 33, 26, 2, -33 },
  { 2910, 25, 32, 26, 1, -32 },
  { 3010, 24, 32, 26, 2, -32 },
  { 3106, 26, 32, 26, 1, -32 },
  { 3210, 24, 33, 26, 2, -33 },
  { 3309, 26, 32, 26, 1, -32 },
  { 3413, 24, 32, 26, 2, -32 },
  { 3509, 26, 32, 26, 0, -32 },
  { 3613, 27, 32, 26, 1, -32 },
  { 3721, 21, 32, 26, 2, -32 },
  { 3805, 28, 32, 26, 0, -32 },
  { 3917, 26, 32, 26, 1, -32 },
  { 4021, 24, 33, 26, 2, -33 },
  { 4120, 26, 32, 26, 1, -32 },
  { 4224, 24, 41, 26, 2, -33 },
  { 4347, 25, 32, 26, 1, -32 },
  { 4447, 25, 33, 26, 1, -33 },
  { 4551, 24, 32, 26, 4, -32 },
  { 4647, 26, 32, 26, 1, -32 },
  { 4751, 24, 32, 26, 4, -32 },
  { 4847, 28, 32, 26, 1, -32 },
  { 4959, 29, 32, 26, -1, -32 },
  { 5075, 25, 32, 26, 4, -32 },
  { 5175, 25, 32, 26, 1, -32 },
  { 5275, 20, 42, 26, 5, -37 },
  { 5380, 15, 42, 26, 6, -37 },
  { 5459, 20, 42, 26, 3, -37 },
  { 5564, 21, 17, 26, 3, -32 },
  { 5609, 22, 6, 26, 0, 1 },
  { 5626, 11, 7, 26, 10, -35 },
  { 5636, 24, 25, 26, 1, -25 },
  { 5711, 24, 32, 26, 1, -32 },
  { 5807, 23, 25, 26, 2, -25 },
  { 5879, 26, 32, 26, 1, -32 },
  { 5983, 23, 25, 26, 2, -25 },
  { 6055, 30, 40, 26, -3, -32 },
  { 6205, 23, 33, 26, 2, -25 },
  { 6300, 24, 32, 26, 1, -32 },
  { 6396, 23, 35, 26, 1, -35 },
  { 6497, 25, 43, 26, 0, -35 },
  { 6632, 26, 32, 26, 1, -32 },
  { 6736, 21, 32, 26, 3, -32 },
  { 6820, 26, 25, 26, 0, -25 },
  { 6902, 24, 25, 26, 1, -25 },
  { 6977, 23, 25, 26, 2, -25 },
  { 7049, 25, 33, 26, 0, -25 },
  { 7153, 24, 33, 26, 1, -25 },
  { 7252, 24, 25, 26, 2, -25 },
  { 7327, 24, 25, 26, 1, -25 },
  { 7402, 22, 31, 26, 3, -31 },
  { 7488, 23, 24, 26, 2, -24 },
  { 7557, 24, 24, 26, 3, -24 },
  { 7629, 26, 24, 26, 2, -24 },
  { 7707, 28, 24, 26, -1, -24 },
  { 7791, 23, 32, 26, 2, -24 },
  { 7883, 24, 24, 26, 1, -24 },
  { 7955, 24, 42, 26, 3, -37 },
  { 8081, 13, 42, 26, 7, -37 },
  { 8150, 23, 42, 26, 1, -37 },
  { 8271, 24, 11, 26, 2, -21 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC44PT7B_H_
