#ifndef _JETBRAINSMONO_EXTRABOLDITALIC23PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x10, 0x00, 0x07,
  0x3C, 0xF0, 0x7B, 0xDC, 0xF7, 0x3D, 0xCE, 0x73, 0xBC, 0xEE, 0x38, 0x03,
  0x9C, 0x0C, 0x60, 0x71, 0x81, 0x8E, 0x3F, 0xFC, 0xFF, 0xF0, 0xC7, 0x03,
  0x18, 0x1C, 0x60, 0x63, 0x81, 0x8C, 0x3F, 0xFE, 0xFF, 0xF0, 0xC6, 0x07,
  0x18, 0x1C, 0xE0, 0x63, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0xF8,
  0x0F, 0xF8, 0x7F, 0xE1, 0xDB, 0x8F, 0x6E, 0x3D, 0x00, 0xFC, 0x01, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x27, 0x9C, 0x9C, 0x72, 0xF1, 0xFF,
  0xC7, 0xFE, 0x07, 0xE0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0F, 0x03,
  0x8F, 0xC3, 0x86, 0x63, 0x87, 0x33, 0x83, 0x19, 0x81, 0xDD, 0x80, 0xFD,
  0x80, 0x1D, 0x80, 0x01, 0xC0, 0x01, 0xD8, 0x01, 0xFF, 0x01, 0xD9, 0x80,
  0xDC, 0xC0, 0xCC, 0x60, 0xC6, 0x30, 0xC3, 0xF0, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0xC0, 0xFF, 0x07, 0x9E, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x3F, 0x05, 0xFC, 0xE7, 0x7F, 0x1C, 0xFC, 0xF1, 0xE3, 0xC7, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3E, 0x70, 0x77, 0xFF, 0xFE, 0xE0, 0x00, 0xC0, 0xF0,
  0x7C, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xE0, 0xF8, 0x0E, 0x00,
  0x80, 0x0C, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x87,
  0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x03, 0x80, 0x38, 0x01, 0xC0, 0xCE, 0x67,
  0xAF, 0x7F, 0xFC, 0x18, 0x01, 0xE0, 0x3B, 0x83, 0xDE, 0x1C, 0x70, 0x43,
  0x00, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x3E, 0x79, 0xE3, 0x87, 0x1C, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x70, 0xE7, 0x87, 0x38, 0x39, 0xC1,
  0xCE, 0xCE, 0x77, 0x73, 0xBF, 0xBC, 0x39, 0xC1, 0xCE, 0x0E, 0x78, 0xF3,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x03, 0xC1, 0xF8, 0x7F, 0x1F, 0xE3, 0x38,
  0x47, 0x10, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78,
  0x70, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0x3F, 0xF0,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xC7, 0xFC, 0x3F, 0x00, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xCF, 0x78, 0xEF, 0x0E,
  0xF0, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0x80, 0x38, 0x03, 0x80, 0x7B, 0xC7, 0xFE, 0x7F,
  0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x1E, 0xFF, 0xC7, 0xFC, 0x3F,
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xBC, 0x7F, 0xEF, 0x9F, 0xF0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF, 0xE7,
  0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xEE, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x70, 0xE7,
  0x87, 0x3C, 0x38, 0xE3, 0x87, 0xFC, 0x1F, 0x81, 0xFF, 0x1C, 0x79, 0xE1,
  0xCE, 0x0E, 0x78, 0xF3, 0xFF, 0x9F, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xFE,
  0x7F, 0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEF, 0x1E, 0xFF, 0xE7, 0xDC,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x00, 0x38,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBC, 0xF0, 0x0E, 0x0F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3C, 0x3C, 0x78, 0x78, 0x70,
  0xE0, 0xE0, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xE7, 0xF1, 0xF0, 0x30, 0x07,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xE0, 0x08, 0x3F, 0xF7, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0, 0x20, 0x03,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xE0, 0x3E, 0x1F, 0xC7,
  0xF0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x7E, 0x1F, 0xE7, 0xF8, 0x1F, 0x03,
  0xC0, 0xF0, 0x78, 0xFE, 0x7F, 0x1F, 0x87, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xE3, 0xCE, 0x07, 0x38,
  0x1D, 0xC0, 0x77, 0x1F, 0xDC, 0xFF, 0x77, 0x1D, 0xDC, 0x76, 0x71, 0xB9,
  0xCE, 0xE7, 0x3B, 0x9C, 0xEE, 0x7F, 0xB8, 0xEE, 0xE0, 0x03, 0x80, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCF, 0x3F, 0xF3, 0xFF, 0x7F,
  0xF7, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0x70, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x87, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x87, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC3, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xC3, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF,
  0x80, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x0E, 0x78, 0xF3,
  0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x1E,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x71, 0xC3, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xFF, 0x9F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0x78, 0xF7, 0x87, 0xBC, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0xF3, 0x9F, 0xBC,
  0xFD, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0x1E,
  0x3C, 0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x3C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0x87, 0x1E, 0x1C, 0x78, 0x71, 0xE3, 0xC7,
  0x0F, 0x1C, 0x3C, 0xF0, 0xE0, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0x1E, 0x1E, 0x38, 0x78, 0x70, 0xE0, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xE7, 0x03,
  0xCF, 0x07, 0x9E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x3C, 0xF8, 0xF3, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0x73, 0xED, 0x9D,
  0xEE, 0x77, 0xB9, 0xCE, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xC1, 0xCF,
  0x07, 0x38, 0x1C, 0xE0, 0x70, 0x1E, 0x1C, 0x78, 0x71, 0xE1, 0xC7, 0xC7,
  0x3F, 0x38, 0xFC, 0xE3, 0xB3, 0x8E, 0xCE, 0x3B, 0xB8, 0xEE, 0xE7, 0x3B,
  0x1C, 0xFC, 0x71, 0xF1, 0xC7, 0xC7, 0x1F, 0x1C, 0x7C, 0xE1, 0xE0, 0x07,
  0xC0, 0xFF, 0x8F, 0xFC, 0x70, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1E,
  0x70, 0xF3, 0x87, 0xBC, 0x39, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xFF, 0x0F,
  0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x1F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCE, 0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x70, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF3,
  0x87, 0xBC, 0x39, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x87, 0x1F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x3E, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x1E, 0x70, 0x79, 0xE1, 0xC7, 0x87, 0x0E, 0x1C, 0x38,
  0xF0, 0xF0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x0E, 0x3C, 0x38, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x1E, 0x70,
  0x71, 0xC3, 0xC7, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00,
  0x38, 0x39, 0xC3, 0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x39, 0xC1, 0xCE,
  0x1E, 0x70, 0xF3, 0x87, 0xBC, 0x39, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xFF,
  0x0F, 0xF8, 0x3F, 0x00, 0xF0, 0x7F, 0x83, 0xBC, 0x3C, 0xE1, 0xE7, 0x0E,
  0x38, 0xF1, 0xC7, 0x0E, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x73, 0x9D, 0xCE, 0x76,
  0x39, 0xD9, 0xE6, 0x67, 0xB9, 0x96, 0xEE, 0xDB, 0xBB, 0x6C, 0xED, 0x73,
  0xA5, 0xCF, 0x97, 0x3E, 0x58, 0xF9, 0x63, 0x4F, 0x8F, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC0, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78,
  0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x70, 0x78, 0x78, 0xF8, 0x78,
  0xF0, 0x7F, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x9E, 0x1D, 0xE0, 0xEE, 0x07,
  0x70, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x02, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFC, 0x3F, 0x87, 0xF1, 0xFE,
  0x00, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x0F,
  0xE1, 0xFC, 0x7F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE1,
  0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x00, 0x07, 0x01, 0xF0, 0x3E, 0x0F, 0xC3,
  0xB8, 0x73, 0x9C, 0x73, 0x8E, 0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF1, 0xE3, 0xC0, 0x0E, 0x73, 0xF7, 0x3F, 0x77, 0x8F, 0x70, 0xF7, 0x0E,
  0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xEF, 0xFE, 0x7D, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xDE, 0x1F, 0xF8, 0xFF, 0xE7, 0x8F,
  0x38, 0x79, 0xC3, 0xCE, 0x1C, 0xF0, 0xE7, 0x87, 0x3C, 0x79, 0xFF, 0x8F,
  0xFC, 0xF7, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0xF7, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xFF, 0xC7, 0xFC, 0x3F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0xE7, 0x1F, 0xB8, 0xFD, 0xCF, 0x1E,
  0x70, 0xF3, 0x87, 0x3C, 0x39, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xFF, 0x9F,
  0xFC, 0x7D, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70, 0xF7, 0x1F,
  0xFF, 0xEF, 0x00, 0xE0, 0x0E, 0x02, 0xFB, 0xC7, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x07, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0x80, 0x00, 0x0E, 0x73, 0xF7, 0x3F, 0x77, 0x8F, 0x70, 0xF7, 0x0E,
  0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0xFE, 0x7F, 0xE7, 0xDC, 0x01, 0xC0, 0x1C,
  0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xDE, 0x1F, 0xF8, 0xFF, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0xCE, 0x1C, 0xF0,
  0xE7, 0x87, 0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xE0, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C, 0x73,
  0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0x38, 0x79, 0xE3, 0x87, 0x1C, 0x3C,
  0xE1, 0xE0, 0xFF, 0x3F, 0x8F, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFC, 0x7F, 0x0F, 0xC0,
  0x3B, 0x38, 0xDF, 0xE3, 0xBB, 0x9C, 0xEE, 0x73, 0x39, 0xCC, 0xE7, 0x33,
  0x9C, 0xCE, 0x77, 0x39, 0x9D, 0xCE, 0x67, 0x39, 0x9C, 0xE6, 0x70, 0x3D,
  0xE1, 0xFF, 0x8E, 0xFE, 0x78, 0xF3, 0x87, 0x9C, 0x3C, 0xE1, 0xCF, 0x0E,
  0x78, 0x73, 0xC7, 0x9C, 0x3C, 0xE1, 0xEF, 0x0E, 0x00, 0x07, 0x81, 0xFE,
  0x3F, 0xE7, 0x8F, 0x70, 0xF7, 0x0F, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E,
  0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x3D, 0xE1, 0xFF, 0x8E, 0xFE, 0x78, 0xF3,
  0x87, 0x9C, 0x3C, 0xE1, 0xCF, 0x0E, 0x78, 0x73, 0xC7, 0x9F, 0xF8, 0xFF,
  0xC7, 0x7C, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x73, 0xF7,
  0x3F, 0x77, 0x8F, 0x70, 0xF7, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E,
  0xFF, 0xEF, 0xFE, 0x7D, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x39,
  0xE1, 0xFF, 0x8F, 0xFC, 0xF1, 0xE7, 0x87, 0x3C, 0x39, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0xFF,
  0x8F, 0xFE, 0x70, 0xF3, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x73,
  0x83, 0x9E, 0x7C, 0xFF, 0xC3, 0xFC, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x07,
  0xFF, 0x7F, 0xFF, 0xFF, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xFE, 0x1F, 0xC0, 0xFC, 0x78, 0x77, 0x87, 0x78, 0x77,
  0x0F, 0x70, 0xF7, 0x0F, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xC7,
  0xF8, 0x3F, 0x00, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C,
  0x73, 0x87, 0x78, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x3C, 0x00, 0xE3,
  0x1F, 0x9C, 0x6E, 0x73, 0xB9, 0xCE, 0xEF, 0x33, 0xBD, 0xCE, 0xB7, 0x3E,
  0xD8, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0x3C, 0x3C,
  0xF1, 0xE1, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x38, 0xF0, 0xF0, 0x78, 0x77, 0x8F,
  0x70, 0xF7, 0x0F, 0x70, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xF1, 0xEF, 0xFE,
  0x7F, 0xE7, 0xDC, 0x01, 0xC0, 0x3C, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x3F,
  0xF3, 0xFF, 0x7F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xFF, 0xEF, 0xFC, 0xFF, 0xC0, 0x00, 0xF0, 0x3F, 0x03, 0xF0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x0F, 0xF0, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0x38, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38,
  0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x00,
  0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x00,
  0x3C, 0x0B, 0xF1, 0xBF, 0xDD, 0xCF, 0xEE, 0x7E, 0x00, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 10, 7, 14, 3, -17 },
  { 23, 14, 17, 14, 0, -17 },
  { 53, 14, 23, 14, 0, -20 },
  { 94, 17, 17, 14, -1, -17 },
  { 131, 14, 17, 14, 0, -17 },
  { 161, 4, 7, 14, 6, -17 },
  { 165, 10, 22, 14, 3, -19 },
  { 193, 10, 22, 14, 1, -19 },
  { 221, 13, 12, 14, 1, -14 },
  { 241, 12, 11, 14, 1, -13 },
  { 258, 7, 7, 14, 2, -3 },
  { 265, 8, 3, 14, 3, -9 },
  { 268, 5, 4, 14, 4, -4 },
  { 271, 15, 22, 14, 0, -19 },
  { 313, 13, 17, 14, 1, -17 },
  { 341, 11, 17, 14, 1, -17 },
  { 365, 12, 17, 14, 1, -17 },
  { 391, 12, 17, 14, 1, -17 },
  { 417, 12, 17, 14, 1, -17 },
  { 443, 12, 17, 14, 1, -17 },
  { 469, 12, 17, 14, 1, -17 },
  { 495, 12, 17, 14, 2, -17 },
  { 521, 13, 17, 14, 1, -17 },
  { 549, 12, 17, 14, 2, -17 },
  { 575, 6, 13, 14, 4, -13 },
  { 585, 8, 17, 14, 2, -13 },
  { 602, 11, 13, 14, 2, -14 },
  { 620, 12, 9, 14, 1, -12 },
  { 634, 12, 13, 14, 1, -14 },
  { 654, 10, 17, 14, 3, -17 },
  { 676, 14, 21, 14, 0, -17 },
  { 713, 12, 17, 14, 0, -17 },
  { 739, 14, 17, 14, 0, -17 },
  { 769, 13, 17, 14, 1, -17 },
  { 797, 14, 17, 14, 0, -17 },
  { 827, 13, 17, 14, 1, -17 },
  { 855, 13, 17, 14, 1, -17 },
  { 883, 13, 17, 14, 1, -17 },
  { 911, 14, 17, 14, 0, -17 },
  { 941, 13, 17, 14, 1, -17 },
  { 969, 14, 17, 14, 0, -17 },
  { 999, 15, 17, 14, 0, -17 },
  { 1031, 11, 17, 14, 1, -17 },
  { 1055, 14, 17, 14, 0, -17 },
  { 1085, 14, 17, 14, 0, -17 },
  { 1115, 13, 17, 14, 1, -17 },
  { 1143, 14, 17, 14, 0, -17 },
  { 1173, 13, 21, 14, 1, -17 },
  { 1208, 14, 17, 14, 0, -17 },
  { 1238, 14, 17, 14, 0, -17 },
  { 1268, 13, 17, 14, 2, -17 },
  { 1296, 13, 17, 14, 1, -17 },
  { 1324, 13, 17, 14, 2, -17 },
  { 1352, 14, 17, 14, 1, -17 },
  { 1382, 16, 17, 14, -1, -17 },
  { 1416, 13, 17, 14, 2, -17 },
  { 1444, 12, 17, 14, 1, -17 },
  { 1470, 11, 22, 14, 2, -19 },
  { 1501, 8, 22, 14, 3, -19 },
  { 1523, 11, 22, 14, 1, -19 },
  { 1554, 11, 9, 14, 2, -17 },
  { 1567, 11, 3, 14, 0, 1 },
  { 1572, 6, 3, 14, 5, -18 },
  { 1575, 12, 13, 14, 1, -13 },
  { 1595, 13, 17, 14, 0, -17 },
  { 1623, 12, 13, 14, 1, -13 },
  { 1643, 13, 17, 14, 1, -17 },
  { 1671, 12, 13, 14, 1, -13 },
  { 1691, 15, 21, 14, -1, -17 },
  { 1731, 12, 17, 14, 1, -13 },
  { 1757, 13, 17, 14, 0, -17 },
  { 1785, 11, 18, 14, 1, -18 },
  { 1810, 13, 22, 14, 0, -18 },
  { 1846, 13, 17, 14, 1, -17 },
  { 1874, 10, 17, 14, 2, -17 },
  { 1896, 14, 13, 14, 0, -13 },
  { 1919, 13, 13, 14, 0, -13 },
  { 1941, 12, 13, 14, 1, -13 },
  { 1961, 13, 17, 14, 0, -13 },
  { 1989, 12, 17, 14, 1, -13 },
  { 2015, 13, 13, 14, 1, -13 },
  { 2037, 13, 13, 14, 0, -13 },
  { 2059, 12, 16, 14, 1, -16 },
  { 2083, 12, 13, 14, 1, -13 },
  { 2103, 12, 13, 14, 2, -13 },
  { 2123, 14, 13, 14, 1, -13 },
  { 2146, 14, 13, 14, 0, -13 },
  { 2169, 12, 17, 14, 1, -13 },
  { 2195, 12, 13, 14, 1, -13 },
  { 2215, 12, 22, 14, 2, -19 },
  { 2248, 7, 22, 14, 4, -19 },
  { 2268, 13, 22, 14, 0, -19 },
  { 2304, 13, 6, 14, 1, -11 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC23PT7B_H_
