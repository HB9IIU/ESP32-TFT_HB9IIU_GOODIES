#ifndef _JETBRAINSMONO_EXTRABOLDITALIC10PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x6C, 0x30, 0x5A, 0xB4, 0x35, 0xF2, 0x92, 0xF9, 0x49, 0x00,
  0x10, 0x43, 0xDF, 0x70, 0xE2, 0xBA, 0x70, 0x80, 0x3B, 0x6C, 0x38, 0x18,
  0x1E, 0x2A, 0xCC, 0x39, 0xA2, 0x1B, 0xDB, 0x6F, 0x80, 0xE0, 0x19, 0x18,
  0x84, 0x23, 0x0C, 0x20, 0x63, 0x33, 0x32, 0x2C, 0x80, 0x11, 0x5F, 0x8C,
  0x58, 0x21, 0x3E, 0xC6, 0x00, 0x6B, 0x40, 0xF0, 0xF0, 0x0C, 0x21, 0x84,
  0x30, 0x86, 0x10, 0xC0, 0x3D, 0x34, 0xDF, 0x4B, 0x27, 0x00, 0x3A, 0xC4,
  0x21, 0x1B, 0xE0, 0x3D, 0xB0, 0xC6, 0x31, 0x8F, 0x80, 0x7C, 0x63, 0x0E,
  0x0B, 0x27, 0x00, 0x1C, 0xC2, 0x12, 0x7B, 0xE1, 0x80, 0x7D, 0x85, 0x9A,
  0x0B, 0x27, 0x00, 0x18, 0xC6, 0x1E, 0xCF, 0x27, 0x00, 0xFC, 0xC4, 0x66,
  0x23, 0x00, 0x3D, 0xB6, 0x9E, 0x4B, 0x27, 0x80, 0x7C, 0xE7, 0xE3, 0x33,
  0x00, 0x70, 0xB0, 0x2C, 0x06, 0xB4, 0x1B, 0xB1, 0xC3, 0x08, 0xF8, 0x3D,
  0xE0, 0x40, 0xF0, 0x8E, 0xE2, 0x00, 0x70, 0xC4, 0xE4, 0x03, 0x00, 0x7D,
  0x15, 0xFD, 0xA6, 0xF8, 0x30, 0x60, 0x39, 0x4A, 0xD7, 0xE7, 0x20, 0x7D,
  0xB4, 0x9E, 0x4F, 0x2F, 0x00, 0x3D, 0xB4, 0x10, 0x43, 0x27, 0x00, 0x7D,
  0xB4, 0xD3, 0x4B, 0x6F, 0x00, 0x7D, 0x86, 0x1E, 0x41, 0x0F, 0x80, 0x7D,
  0x84, 0x1E, 0x41, 0x0C, 0x00, 0x3D, 0xB4, 0x17, 0x4B, 0x27, 0x00, 0x6D,
  0xB7, 0xDE, 0x4B, 0x2D, 0x80, 0x7C, 0x41, 0x0C, 0x30, 0xCF, 0x80, 0x1C,
  0x30, 0x82, 0x0B, 0x67, 0x00, 0x6D, 0xA5, 0x9C, 0x5B, 0x6C, 0x80, 0x4C,
  0xCC, 0x88, 0xF0, 0x6D, 0xB7, 0x5F, 0xCF, 0x28, 0x80, 0x65, 0x97, 0xD7,
  0x5B, 0x6D, 0x80, 0x3D, 0xB4, 0xD3, 0x4B, 0x27, 0x00, 0x7D, 0x94, 0xDE,
  0x43, 0x0C, 0x00, 0x3D, 0xB4, 0xD3, 0x4B, 0x27, 0x04, 0x18, 0x7D, 0xB4,
  0xDE, 0x53, 0x6C, 0x80, 0x3D, 0xB6, 0x0E, 0x0B, 0x27, 0x00, 0xF9, 0x08,
  0xC6, 0x31, 0x00, 0x6D, 0xB4, 0xD3, 0x4B, 0x27, 0x00, 0xCE, 0xF5, 0xAF,
  0x71, 0x80, 0x56, 0xA9, 0xD3, 0xA7, 0x9B, 0x36, 0x00, 0x6C, 0xA3, 0x8C,
  0x71, 0x6C, 0x80, 0xCF, 0x47, 0x18, 0x61, 0x84, 0x00, 0x7C, 0x21, 0x8C,
  0x61, 0x0F, 0x80, 0x7B, 0x18, 0x84, 0x23, 0x18, 0xE0, 0xC4, 0x46, 0x62,
  0x23, 0x30, 0x73, 0x33, 0x22, 0x26, 0xE0, 0x32, 0xB5, 0x30, 0xFF, 0xC0,
  0xCC, 0x2D, 0xF4, 0x92, 0xD9, 0xE0, 0x61, 0xE7, 0x93, 0x4B, 0x2F, 0x80,
  0x11, 0xE4, 0x50, 0xC9, 0xC0, 0x0C, 0xB7, 0xD2, 0x4B, 0x67, 0x80, 0x11,
  0xE4, 0xDE, 0xC9, 0xC0, 0x0E, 0x30, 0xF9, 0xF1, 0x02, 0x04, 0x18, 0xE0,
  0x2D, 0xF4, 0x92, 0x79, 0xA1, 0x9C, 0x61, 0xE7, 0xD2, 0x4B, 0x2D, 0x80,
  0x18, 0x9C, 0xE1, 0x08, 0xDF, 0x0C, 0x23, 0x9E, 0x18, 0x61, 0x84, 0xF3,
  0x80, 0x61, 0xB4, 0x96, 0x73, 0x6C, 0x80, 0xE6, 0x66, 0x44, 0x70, 0x59,
  0xF5, 0xFB, 0xEA, 0xA0, 0x79, 0xF4, 0x92, 0xCB, 0x60, 0x11, 0xE4, 0xD2,
  0xC9, 0xC0, 0x79, 0xE4, 0xD2, 0xCB, 0xEC, 0x20, 0x2D, 0xF4, 0x92, 0xD9,
  0xA1, 0x86, 0x69, 0xF4, 0xD0, 0x43, 0x00, 0x31, 0xF4, 0x0E, 0xC9, 0xE0,
  0x67, 0xFE, 0x84, 0x21, 0xC0, 0x6D, 0x34, 0x92, 0x59, 0xC0, 0x8C, 0xF5,
  0xEE, 0x30, 0x55, 0x57, 0x7E, 0xDB, 0x60, 0x4D, 0xA3, 0x0C, 0x7B, 0x60,
  0x6D, 0x34, 0x92, 0xF9, 0xE1, 0x9C, 0x7D, 0xE1, 0x8C, 0x63, 0xE0, 0x19,
  0x8C, 0x4E, 0x11, 0x8C, 0x70, 0x69, 0x2D, 0xB4, 0x80, 0x71, 0x8C, 0x61,
  0x90, 0x8C, 0xE0, 0x65, 0xF9, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 2, -7 },
  { 4, 5, 3, 6, 1, -7 },
  { 6, 6, 7, 6, 0, -7 },
  { 12, 6, 10, 6, 0, -9 },
  { 20, 8, 7, 6, -1, -7 },
  { 27, 6, 7, 6, 0, -7 },
  { 33, 1, 3, 6, 3, -7 },
  { 34, 5, 9, 6, 1, -8 },
  { 40, 4, 9, 6, 1, -8 },
  { 45, 6, 5, 6, 0, -6 },
  { 49, 5, 5, 6, 1, -6 },
  { 53, 3, 4, 6, 1, -2 },
  { 55, 4, 1, 6, 1, -4 },
  { 56, 2, 2, 6, 2, -2 },
  { 57, 6, 9, 6, 0, -8 },
  { 64, 6, 7, 6, 0, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 6, 7, 6, 0, -7 },
  { 81, 6, 7, 6, 0, -7 },
  { 87, 6, 7, 6, 0, -7 },
  { 93, 6, 7, 6, 0, -7 },
  { 99, 6, 7, 6, 0, -7 },
  { 105, 5, 7, 6, 1, -7 },
  { 110, 6, 7, 6, 0, -7 },
  { 116, 5, 7, 6, 1, -7 },
  { 121, 2, 6, 6, 2, -6 },
  { 123, 3, 8, 6, 1, -6 },
  { 126, 5, 6, 6, 1, -6 },
  { 130, 5, 4, 6, 1, -5 },
  { 133, 6, 6, 6, 0, -6 },
  { 138, 5, 7, 6, 1, -7 },
  { 143, 6, 9, 6, 0, -7 },
  { 150, 5, 7, 6, 0, -7 },
  { 155, 6, 7, 6, 0, -7 },
  { 161, 6, 7, 6, 0, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 6, 7, 6, 0, -7 },
  { 179, 6, 7, 6, 0, -7 },
  { 185, 6, 7, 6, 0, -7 },
  { 191, 6, 7, 6, 0, -7 },
  { 197, 6, 7, 6, 0, -7 },
  { 203, 6, 7, 6, 0, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 4, 7, 6, 1, -7 },
  { 219, 6, 7, 6, 0, -7 },
  { 225, 6, 7, 6, 0, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 6, 7, 6, 0, -7 },
  { 243, 6, 9, 6, 0, -7 },
  { 250, 6, 7, 6, 0, -7 },
  { 256, 6, 7, 6, 0, -7 },
  { 262, 5, 7, 6, 1, -7 },
  { 267, 6, 7, 6, 0, -7 },
  { 273, 5, 7, 6, 1, -7 },
  { 278, 7, 7, 6, 0, -7 },
  { 285, 6, 7, 6, 0, -7 },
  { 291, 6, 7, 6, 1, -7 },
  { 297, 6, 7, 6, 0, -7 },
  { 303, 5, 9, 6, 1, -8 },
  { 309, 4, 9, 6, 1, -8 },
  { 314, 4, 9, 6, 1, -8 },
  { 319, 5, 4, 6, 1, -7 },
  { 322, 5, 2, 6, 0, 0 },
  { 324, 3, 2, 6, 2, -8 },
  { 325, 6, 6, 6, 0, -6 },
  { 330, 6, 7, 6, 0, -7 },
  { 336, 6, 6, 6, 0, -6 },
  { 341, 6, 7, 6, 0, -7 },
  { 347, 6, 6, 6, 0, -6 },
  { 352, 7, 9, 6, -1, -7 },
  { 360, 6, 8, 6, 0, -6 },
  { 366, 6, 7, 6, 0, -7 },
  { 372, 5, 8, 6, 0, -8 },
  { 377, 6, 10, 6, 0, -8 },
  { 385, 6, 7, 6, 0, -7 },
  { 391, 4, 7, 6, 1, -7 },
  { 395, 6, 6, 6, 0, -6 },
  { 400, 6, 6, 6, 0, -6 },
  { 405, 6, 6, 6, 0, -6 },
  { 410, 6, 8, 6, 0, -6 },
  { 416, 6, 8, 6, 0, -6 },
  { 422, 6, 6, 6, 0, -6 },
  { 427, 6, 6, 6, 0, -6 },
  { 432, 5, 7, 6, 1, -7 },
  { 437, 6, 6, 6, 0, -6 },
  { 442, 5, 6, 6, 1, -6 },
  { 446, 6, 6, 6, 0, -6 },
  { 451, 6, 6, 6, 0, -6 },
  { 456, 6, 8, 6, 0, -6 },
  { 462, 6, 6, 6, 0, -6 },
  { 467, 5, 9, 6, 1, -8 },
  { 473, 3, 9, 6, 2, -8 },
  { 477, 5, 9, 6, 0, -8 },
  { 483, 6, 3, 6, 0, -5 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC10PT7B_H_
