#ifndef _JETBRAINSMONO_EXTRABOLDITALIC24PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC0,
  0x00, 0x00, 0x38, 0xF9, 0xE0, 0xF3, 0xF9, 0xFC, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9D, 0xCE, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x70, 0x38, 0xC0, 0x71, 0x87,
  0xFF, 0xCF, 0xFF, 0x87, 0x18, 0x0C, 0x70, 0x38, 0xC0, 0x71, 0x80, 0xC7,
  0x0F, 0xFF, 0x9F, 0xFF, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0x80, 0xC7, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xF8, 0x3F, 0xF1, 0xEF,
  0xCF, 0x6F, 0x3D, 0x80, 0xF6, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x37, 0x80, 0xDE, 0x73, 0x79, 0xE9, 0xE7, 0xFF, 0x0F, 0xF8, 0x1F,
  0xC0, 0x18, 0x00, 0x60, 0x01, 0x00, 0x06, 0x01, 0x87, 0xC1, 0xC7, 0x71,
  0xC7, 0x39, 0xC3, 0x9D, 0xC1, 0xCC, 0xC0, 0xFE, 0xC0, 0x3E, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xEF, 0x00, 0xFF, 0xC0, 0xEC, 0xE0, 0x66, 0x70,
  0x67, 0x38, 0x63, 0x98, 0x60, 0xFC, 0x70, 0x7C, 0x00, 0x01, 0xE0, 0x1F,
  0xC0, 0xFF, 0x83, 0x9E, 0x1E, 0x38, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x3F,
  0x01, 0xFC, 0x77, 0xFB, 0x9C, 0xFE, 0x73, 0xF3, 0xC7, 0x8F, 0x1E, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFD, 0xE0, 0x7B, 0xDC, 0xE7, 0x7B, 0xDC, 0x00, 0xE0,
  0x3C, 0x1F, 0x07, 0xE1, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xF0,
  0x1F, 0x81, 0xF0, 0x1C, 0x00, 0x80, 0x0C, 0x01, 0xE0, 0x7E, 0x07, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xE0,
  0x30, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x86, 0x17, 0x33, 0xFD, 0x7D,
  0xFF, 0xC0, 0xE0, 0x0F, 0x81, 0xCE, 0x1E, 0x70, 0xE3, 0xC2, 0x08, 0x00,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF,
  0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x78, 0xF3, 0xC7,
  0x8E, 0x3C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xFF, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x87,
  0xFC, 0x7D, 0xF3, 0x87, 0xBC, 0x1D, 0xE1, 0xEE, 0x4F, 0x77, 0x73, 0xBB,
  0x9D, 0xDD, 0xE0, 0xEF, 0x0F, 0x70, 0x7B, 0xC7, 0x9F, 0xFC, 0x7F, 0xC1,
  0xF8, 0x00, 0x01, 0xE0, 0x7E, 0x1F, 0xC3, 0xFC, 0x3B, 0xC3, 0x3C, 0x23,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF7,
  0x87, 0xBC, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xCF, 0xFE, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x7B, 0xC7, 0x9F,
  0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1,
  0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1F,
  0xF8, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0x80, 0x1C, 0x00, 0xE2, 0x0F, 0xFC,
  0x7F, 0xF3, 0xEF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x7B, 0xC7, 0x9F,
  0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xDC, 0x7F, 0xE7, 0xFF, 0xF8, 0xFF, 0x07, 0xE0,
  0x7E, 0x0F, 0xF0, 0xFF, 0xFE, 0x7F, 0xC3, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0x0F, 0x78, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x79, 0xF3, 0x87, 0xBC, 0x3C,
  0xE1, 0xC7, 0xBE, 0x1F, 0xC0, 0xFE, 0x1F, 0x78, 0xE1, 0xEF, 0x0F, 0x78,
  0x7B, 0xC3, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x07, 0x81, 0xFE, 0x3F,
  0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xFF, 0xEF, 0xFE, 0x7D,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x3C,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBE, 0xF0, 0x0F, 0x0F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3C, 0x38, 0x78, 0x70,
  0xF0, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x3F, 0xCF, 0xE0, 0xF8,
  0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7C, 0x01, 0xC0, 0x04, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x7F,
  0xEF, 0xFE, 0x20, 0x03, 0x00, 0x3C, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xF0, 0x0F, 0x07, 0xF1, 0xFC, 0xFF, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x7C,
  0x0F, 0xF1, 0xFF, 0x3F, 0xE0, 0x3C, 0x03, 0x80, 0xF1, 0xFE, 0x3F, 0x87,
  0xE1, 0xF0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDC,
  0x3B, 0xB9, 0xF7, 0x73, 0x9C, 0xE7, 0x39, 0xDC, 0x73, 0x38, 0xEE, 0x71,
  0xDC, 0xE3, 0xB9, 0xFE, 0x73, 0xEC, 0xE1, 0xA1, 0xC0, 0x03, 0x80, 0x07,
  0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x1C,
  0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xE1, 0xCE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0,
  0x3F, 0x81, 0xFF, 0x8F, 0xFE, 0x71, 0xF3, 0x87, 0xBC, 0x3D, 0xE1, 0xEF,
  0x3E, 0x7F, 0xC3, 0xFF, 0x1C, 0x7C, 0xE1, 0xEF, 0x07, 0x78, 0x7B, 0xC3,
  0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x7D,
  0xF3, 0x87, 0xBC, 0x3D, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x7B, 0xC7, 0x9F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xE1,
  0xE7, 0x8F, 0x1F, 0xFC, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x7F, 0xF3, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x7F, 0x87, 0xFE, 0x7D, 0xF3, 0x87, 0xBC, 0x3D, 0xE0, 0x0F, 0x00, 0x73,
  0xFB, 0x9F, 0x9C, 0xFD, 0xE0, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9F, 0xFC,
  0x7F, 0xC1, 0xFC, 0x00, 0x3C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E, 0x1E, 0x38,
  0x79, 0xE1, 0xE7, 0x87, 0x9F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1C,
  0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x0E, 0x3C, 0x38, 0xE1, 0xE3, 0x87, 0x80,
  0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x73, 0xC3, 0xCF, 0x0F, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xE1, 0xE1, 0xC7, 0x87,
  0x9E, 0x0F, 0x3C, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xCF,
  0x07, 0x8E, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x70, 0x71, 0xE0, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE6, 0xE7, 0xCF,
  0x8F, 0xBF, 0x1F, 0xEE, 0x7B, 0xDC, 0xE7, 0x79, 0xCE, 0xF3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE0, 0x1E,
  0x1E, 0x3C, 0x3C, 0x7C, 0x70, 0xF8, 0xE1, 0xF1, 0xC7, 0x63, 0x8E, 0xC7,
  0x1D, 0xDE, 0x3B, 0xB8, 0x77, 0x70, 0xEE, 0xE3, 0xCD, 0xC7, 0x1B, 0x8E,
  0x3F, 0x1C, 0x7C, 0x38, 0xF8, 0x71, 0xF1, 0xE1, 0xE0, 0x03, 0xC0, 0x7F,
  0x87, 0xFC, 0x7D, 0xF3, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x70, 0x73,
  0x83, 0x9C, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9F, 0xFC, 0x7F,
  0xC1, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x38, 0x3D,
  0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x7F, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xC0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x7D, 0xF3, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x70, 0x73, 0x83, 0x9C, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9F,
  0xFC, 0x7F, 0xC1, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x1F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1C, 0x3C, 0xF0, 0x73, 0xC3, 0xCF,
  0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0E, 0x70, 0x79, 0xE1, 0xE7, 0x87,
  0x8E, 0x1C, 0x3C, 0x70, 0xF3, 0xC1, 0xE0, 0x01, 0xE0, 0x1F, 0xE0, 0xFF,
  0xC7, 0xDF, 0x3C, 0x3C, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x79, 0xC1, 0xE7, 0x87, 0x9F, 0xFC, 0x3F,
  0xE0, 0x7F, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x3C, 0xF0,
  0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78,
  0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0x9C, 0x1C,
  0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x73, 0x8E, 0xE7, 0x1D, 0xCE, 0x73, 0x9C, 0xE7, 0x79, 0xCC, 0xF3,
  0x99, 0xE6, 0x72, 0xDC, 0xED, 0xB9, 0xDB, 0x73, 0xB6, 0xC7, 0x4F, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC0, 0x0E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x07, 0x3C, 0x07, 0xBC, 0x07, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x78, 0x78, 0x38, 0xF8, 0x3C, 0xF0,
  0x3F, 0xC1, 0xE7, 0x07, 0x9E, 0x3C, 0x78, 0xE0, 0xE7, 0x83, 0x9C, 0x0E,
  0xF0, 0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xF8, 0xFE, 0x3F, 0x8F, 0xE0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C,
  0x0E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x1F, 0xC7, 0xF1, 0xFC,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE0, 0x07, 0x80, 0xF0, 0x3E, 0x0E, 0xE1, 0xDC, 0x73, 0x8E, 0x73, 0x8F,
  0xF0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF7, 0x9E, 0x70, 0x1F,
  0x79, 0xFF, 0xDF, 0xFC, 0xF1, 0xE7, 0x0F, 0x38, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF0, 0xE7, 0x8F, 0x3F, 0xF8, 0xFD, 0xC7, 0xDE, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3D, 0xF1, 0xFF, 0xCF, 0xFE, 0x78, 0xF3,
  0x83, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9F, 0xFC, 0xEF,
  0xC7, 0x7C, 0x00, 0x0F, 0xE1, 0xFF, 0x8F, 0xFC, 0xF0, 0xE7, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xF7, 0x8F, 0x3F, 0xF8, 0xFF, 0x83, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x7D, 0xE3,
  0xFF, 0x9F, 0xFC, 0x78, 0xF1, 0xC3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0x8F, 0x1E, 0x3F, 0xF8, 0x7E, 0xE1, 0xF7, 0x80, 0x0F, 0xE3, 0xFF,
  0x3C, 0xF7, 0x87, 0x70, 0x77, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x0E,
  0xFF, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFC, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFC, 0xF1, 0xE7, 0x0F, 0x38, 0x7B, 0xC3,
  0xDE, 0x1E, 0xF1, 0xE7, 0xFF, 0x1F, 0xB8, 0xFB, 0xC0, 0x1E, 0x00, 0xF1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3D, 0xF1, 0xFF, 0xCF, 0xFE, 0x78, 0xF3, 0x83, 0x9C, 0x3C, 0xE1,
  0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x00, 0x01,
  0xC0, 0x3E, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x3F,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x87, 0xFC, 0x7F, 0xC3, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE1, 0xF7, 0x87, 0x9E, 0x3C, 0x79, 0xE1, 0xEF, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0xC3, 0xCF, 0x0F, 0x1C, 0x3C, 0x78, 0xE1, 0xE3,
  0x83, 0xC0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFF,
  0x1F, 0xE1, 0xFC, 0x3F, 0xBC, 0xFF, 0xF3, 0xB9, 0xDE, 0xE7, 0x73, 0x9D,
  0xCE, 0xF7, 0x33, 0x9C, 0xCE, 0x73, 0x3B, 0xDC, 0xEE, 0x73, 0xB9, 0xDE,
  0xE6, 0x70, 0x7B, 0xE3, 0xFF, 0x9F, 0xFC, 0xF1, 0xE7, 0x07, 0x38, 0x79,
  0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0x3C, 0x39, 0xC3, 0xCE, 0x1E, 0x00,
  0x0F, 0xE3, 0xFF, 0x3F, 0xF7, 0x8F, 0x70, 0x77, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1E, 0xFF, 0xE7, 0xFC, 0x3F, 0x00, 0x3D, 0xF0, 0xFF, 0xE3,
  0xFF, 0x8F, 0x1E, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE3, 0xC7, 0xFF, 0x1D, 0xF8, 0x77, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFC, 0xF1, 0xE7, 0x0F, 0x38, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0xC7, 0xDE, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3B, 0xF1, 0xFF, 0xCF, 0xFE, 0xF0,
  0xF7, 0x87, 0xBC, 0x3D, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE3, 0xE7, 0x8F, 0x00, 0x3C,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x79, 0xC1, 0xE7, 0xFF, 0x1F,
  0xFC, 0x3F, 0xC0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x78, 0x7B, 0xC3, 0xDE, 0x1C,
  0xF0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x3F,
  0xF8, 0xFF, 0x83, 0xF0, 0x00, 0xE0, 0x7F, 0x87, 0xBC, 0x39, 0xE3, 0xCF,
  0x1E, 0x39, 0xE1, 0xCF, 0x0E, 0x70, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C,
  0x03, 0xE0, 0x00, 0xE3, 0x9F, 0x9E, 0x7E, 0x71, 0xB9, 0x4E, 0xED, 0x3B,
  0xB4, 0xCE, 0xD7, 0x3A, 0x5C, 0xF9, 0x73, 0xE5, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xC0, 0x3C, 0x3E, 0x3C, 0xF0, 0x7B, 0xC0, 0x77, 0x00, 0xFE, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xF3, 0x83, 0xC7,
  0x8F, 0x07, 0x80, 0x78, 0x7B, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x78,
  0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0xFF, 0x1F, 0xF8, 0x7B, 0xC0, 0x1E,
  0x00, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xF3, 0xFF, 0x7F, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x3F, 0xC1, 0xF8, 0x0F, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3F, 0x80,
  0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E,
  0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E,
  0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x87,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xC0, 0x00, 0x08, 0x03, 0xF1, 0xDF, 0xCF, 0xCE, 0x7E, 0x7F,
  0x71, 0xF8, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 18, 14, 4, -18 },
  { 17, 9, 8, 14, 4, -18 },
  { 26, 15, 18, 14, 0, -18 },
  { 60, 14, 24, 14, 0, -21 },
  { 102, 17, 18, 14, -1, -18 },
  { 141, 14, 18, 14, 0, -18 },
  { 173, 5, 8, 14, 6, -18 },
  { 178, 11, 23, 14, 3, -20 },
  { 210, 11, 23, 14, 1, -20 },
  { 242, 13, 13, 14, 1, -15 },
  { 264, 13, 12, 14, 1, -14 },
  { 284, 7, 8, 14, 2, -4 },
  { 291, 9, 4, 14, 3, -10 },
  { 296, 5, 5, 14, 4, -5 },
  { 300, 15, 23, 14, 0, -20 },
  { 344, 13, 18, 14, 1, -18 },
  { 374, 12, 18, 14, 1, -18 },
  { 401, 13, 18, 14, 1, -18 },
  { 431, 13, 18, 14, 1, -18 },
  { 461, 13, 18, 14, 1, -18 },
  { 491, 13, 18, 14, 1, -18 },
  { 521, 12, 18, 14, 1, -18 },
  { 548, 13, 18, 14, 2, -18 },
  { 578, 13, 18, 14, 1, -18 },
  { 608, 12, 18, 14, 2, -18 },
  { 635, 6, 13, 14, 4, -13 },
  { 645, 8, 17, 14, 2, -13 },
  { 662, 12, 14, 14, 2, -15 },
  { 683, 12, 10, 14, 1, -13 },
  { 698, 12, 14, 14, 1, -15 },
  { 719, 11, 18, 14, 3, -18 },
  { 744, 15, 22, 14, 0, -18 },
  { 786, 13, 18, 14, 0, -18 },
  { 816, 13, 18, 14, 1, -18 },
  { 846, 13, 18, 14, 1, -18 },
  { 876, 14, 18, 14, 0, -18 },
  { 908, 13, 18, 14, 1, -18 },
  { 938, 14, 18, 14, 1, -18 },
  { 970, 13, 18, 14, 1, -18 },
  { 1000, 14, 18, 14, 1, -18 },
  { 1032, 13, 18, 14, 1, -18 },
  { 1062, 14, 18, 14, 0, -18 },
  { 1094, 15, 18, 14, 0, -18 },
  { 1128, 11, 18, 14, 1, -18 },
  { 1153, 15, 18, 14, 0, -18 },
  { 1187, 15, 18, 14, 0, -18 },
  { 1221, 13, 18, 14, 1, -18 },
  { 1251, 14, 18, 14, 1, -18 },
  { 1283, 13, 22, 14, 1, -18 },
  { 1319, 14, 18, 14, 0, -18 },
  { 1351, 14, 18, 14, 0, -18 },
  { 1383, 13, 18, 14, 2, -18 },
  { 1413, 14, 18, 14, 1, -18 },
  { 1445, 14, 18, 14, 2, -18 },
  { 1477, 15, 18, 14, 1, -18 },
  { 1511, 16, 18, 14, -1, -18 },
  { 1547, 14, 18, 14, 2, -18 },
  { 1579, 13, 18, 14, 1, -18 },
  { 1609, 10, 23, 14, 3, -20 },
  { 1638, 9, 23, 14, 3, -20 },
  { 1664, 10, 23, 14, 2, -20 },
  { 1693, 11, 10, 14, 2, -18 },
  { 1707, 12, 3, 14, 0, 1 },
  { 1712, 5, 4, 14, 6, -19 },
  { 1715, 13, 13, 14, 1, -13 },
  { 1737, 13, 18, 14, 1, -18 },
  { 1767, 13, 13, 14, 1, -13 },
  { 1789, 14, 18, 14, 1, -18 },
  { 1821, 12, 13, 14, 1, -13 },
  { 1841, 16, 22, 14, -1, -18 },
  { 1885, 13, 17, 14, 1, -13 },
  { 1913, 13, 18, 14, 1, -18 },
  { 1943, 12, 19, 14, 1, -19 },
  { 1972, 13, 23, 14, 0, -19 },
  { 2010, 14, 18, 14, 1, -18 },
  { 2042, 11, 18, 14, 2, -18 },
  { 2067, 14, 13, 14, 0, -13 },
  { 2090, 13, 13, 14, 1, -13 },
  { 2112, 12, 13, 14, 1, -13 },
  { 2132, 14, 17, 14, 0, -13 },
  { 2162, 13, 17, 14, 1, -13 },
  { 2190, 13, 13, 14, 1, -13 },
  { 2212, 14, 13, 14, 0, -13 },
  { 2235, 13, 17, 14, 1, -17 },
  { 2263, 13, 13, 14, 1, -13 },
  { 2285, 13, 13, 14, 2, -13 },
  { 2307, 14, 13, 14, 1, -13 },
  { 2330, 15, 13, 14, 0, -13 },
  { 2355, 13, 17, 14, 1, -13 },
  { 2383, 12, 13, 14, 1, -13 },
  { 2403, 13, 23, 14, 2, -20 },
  { 2441, 7, 23, 14, 4, -20 },
  { 2462, 13, 23, 14, 0, -20 },
  { 2500, 13, 7, 14, 1, -12 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC24PT7B_H_
