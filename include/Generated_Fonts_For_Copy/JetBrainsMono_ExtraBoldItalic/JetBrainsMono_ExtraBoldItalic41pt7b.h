#ifndef _JETBRAINSMONO_EXTRABOLDITALIC41PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F,
  0xC3, 0xFC, 0x7F, 0x8F, 0xE0, 0xF8, 0x00, 0x7F, 0x1F, 0xBF, 0x0F, 0xDF,
  0x87, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0xC0, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3E, 0x21, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x77, 0xF1, 0xFC, 0xC7,
  0xE3, 0xF1, 0x8F, 0xC7, 0xE7, 0x00, 0x0F, 0xCE, 0x00, 0x1F, 0xDC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x67, 0xF0, 0x00, 0xC7, 0xE0, 0x03, 0x8F, 0xCF, 0xE7, 0x1F, 0x9F, 0xCE,
  0x7F, 0x3F, 0xDD, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x7C, 0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xF0, 0x0F, 0x01,
  0xF3, 0xE0, 0x78, 0x07, 0x87, 0x83, 0xC0, 0x3E, 0x1E, 0x1E, 0x00, 0xF0,
  0x78, 0xF8, 0x03, 0xC3, 0xC7, 0xC0, 0x0F, 0x0F, 0x3E, 0x00, 0x3C, 0x3C,
  0xF0, 0x00, 0xFF, 0xE7, 0x80, 0x01, 0xFF, 0xBC, 0x00, 0x03, 0xF9, 0xE0,
  0x00, 0x01, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x08, 0x00, 0x00, 0x7B, 0xFC, 0x00, 0x03, 0xDF, 0xF8, 0x00,
  0x1E, 0xFF, 0xE0, 0x00, 0xF3, 0xC7, 0xC0, 0x07, 0x9F, 0x0F, 0x00, 0x3E,
  0x78, 0x3C, 0x01, 0xF1, 0xE1, 0xE0, 0x0F, 0x87, 0x87, 0x80, 0x3C, 0x1E,
  0x1E, 0x01, 0xE0, 0x7C, 0xF8, 0x0F, 0x01, 0xFF, 0xC0, 0x78, 0x03, 0xFE,
  0x03, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x7E, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x0F, 0xF0, 0xFC, 0x7E,
  0xFD, 0xFB, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0xC1, 0xF0, 0x67, 0xC3, 0x87, 0x9F, 0x8E,
  0x7F, 0xFF, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x1F,
  0x9F, 0x80, 0xFC, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x1C, 0x06,
  0x00, 0x20, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x3F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x7E, 0x7E, 0x71, 0xF9, 0xFB, 0xE7, 0xE7, 0xEF, 0xDF, 0x9F,
  0xBF, 0x7E, 0x7E, 0xF9, 0xF1, 0xF1, 0xC7, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x01,
  0xF1, 0xF8, 0x0F, 0x1F, 0xC0, 0x60, 0xFC, 0x06, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xF8,
  0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xE1, 0xFC, 0x1F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x0C,
  0x00, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xE3, 0xFC, 0x20, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x07, 0xF7, 0xE0, 0x1F,
  0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F,
  0x80, 0xFE, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFE,
  0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0x8F, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFE, 0x03,
  0xF3, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFC, 0x3F, 0x87, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x0F,
  0xDF, 0x0F, 0x83, 0xFB, 0xE1, 0xF0, 0xFF, 0xBC, 0x3E, 0x3F, 0x3F, 0x87,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xC1,
  0xF0, 0xF8, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC3, 0xE3, 0xE0, 0xF0, 0x7C,
  0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xC3, 0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF,
  0x0F, 0x87, 0xFB, 0xE1, 0xF0, 0x7F, 0x7C, 0x3E, 0x03, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3E,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8,
  0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xC1, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07,
  0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xF1,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE1, 0xFF,
  0x9F, 0x8F, 0xFE, 0x7E, 0x3F, 0xF9, 0xF8, 0xFF, 0xEF, 0xE3, 0xFF, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01,
  0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x7F, 0x83,
  0xDC, 0x3F, 0xE0, 0xF7, 0x0F, 0xF8, 0x7D, 0xC7, 0xBE, 0x1F, 0x79, 0xFF,
  0x87, 0xDE, 0x77, 0xC1, 0xF7, 0xBD, 0xF0, 0x7D, 0xEF, 0x7C, 0x1F, 0x7F,
  0x9F, 0x07, 0xCF, 0xEF, 0xC3, 0xF3, 0xF3, 0xF0, 0xFC, 0xFC, 0xF8, 0x3F,
  0x3E, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x03,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x1F,
  0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3E,
  0x0F, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0x78, 0x7E, 0x1F, 0x78, 0x7C, 0x1F, 0x7C, 0x7C, 0x3F, 0x7C, 0x7C,
  0x3F, 0x7C, 0x7C, 0x3E, 0x7C, 0xFC, 0x3E, 0x3C, 0xFC, 0x3E, 0x3C, 0xFC,
  0x3E, 0x3E, 0xF8, 0x7E, 0x3E, 0xF8, 0x7E, 0x3E, 0xF8, 0x7E, 0x1E, 0xF8,
  0x7C, 0x1E, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0,
  0xFC, 0x1F, 0xF0, 0xFC, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7E,
  0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07,
  0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC3, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF9, 0xF8, 0x01, 0xF3,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x0F, 0x87, 0xCF, 0x87,
  0xE1, 0xF3, 0xE1, 0xF8, 0xFC, 0xF8, 0x7C, 0x3E, 0x3E, 0x1B, 0x0F, 0x8F,
  0x8F, 0xC3, 0xE3, 0xE3, 0xF0, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F,
  0x0F, 0x9D, 0xC7, 0xC3, 0xC7, 0x71, 0xE0, 0xF1, 0xDC, 0xF8, 0x3C, 0xF7,
  0x3E, 0x1F, 0x39, 0xCF, 0x87, 0xCE, 0x73, 0xC1, 0xF3, 0x9D, 0xF0, 0x7D,
  0xC7, 0x7C, 0x1F, 0x71, 0xDF, 0x07, 0xDC, 0x77, 0x81, 0xF7, 0x1D, 0xE0,
  0x7F, 0x87, 0xF8, 0x1E, 0xE3, 0xBE, 0x07, 0xB8, 0xEF, 0x01, 0xEE, 0x3B,
  0xC0, 0x7F, 0x0E, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE3,
  0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x07, 0xFD, 0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFC, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x1F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0x83, 0xFF, 0xBF, 0x07, 0xFE, 0xFC,
  0x07, 0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF1, 0xF0, 0x1F, 0x9F, 0xF0, 0x7E, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xF7, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F,
  0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x07,
  0xF1, 0xFF, 0xFF, 0x8F, 0xDF, 0xFE, 0x3F, 0x7F, 0xF0, 0xFD, 0xFF, 0x83,
  0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF7, 0xFC, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0xFC, 0x07, 0xE7,
  0xF0, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x7E, 0x03, 0xFE, 0xFE, 0x07, 0xFE, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB,
  0xF0, 0x3F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xC1, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x3F, 0xCF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x1F, 0xF7, 0xF0, 0xFF, 0xDF,
  0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x3F, 0xE7, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x83, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0x7E, 0x1F, 0xFD, 0xF8, 0x3F,
  0xEF, 0xC0, 0x3C, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF1,
  0xF0, 0x1F, 0x9F, 0xF0, 0x7E, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xE7, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0x01,
  0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0x83, 0xF8,
  0x1F, 0x83, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0x1C, 0x3C, 0x1F, 0x7E, 0x7E,
  0x1F, 0xFE, 0xFF, 0x1F, 0xFE, 0xFF, 0x1F, 0x9F, 0x3F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x3F, 0x3F, 0x1E, 0x3F, 0x3F, 0x1E, 0x3E, 0x3E, 0x1E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x7E, 0x7E, 0x3C, 0x7E,
  0x7E, 0x3C, 0x7C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x7C, 0xFC, 0x78, 0xFC, 0xFC, 0x78, 0xFC, 0xF8, 0x78, 0xF8,
  0xF8, 0xF8, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x7F, 0xC1, 0xFB, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x9F, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x07,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE7, 0xF8, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFD,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x80,
  0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x1F,
  0x9F, 0xF0, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0x7F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0,
  0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0x87, 0xEF, 0xFE, 0x0F, 0xDF, 0xF8, 0x1F,
  0x9F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFC, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0x83, 0xFF, 0xFE, 0x07,
  0xFE, 0xFC, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0xC1, 0xFB, 0xFF, 0x87, 0xDF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7E, 0x07, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xF0,
  0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0xFE, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8,
  0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x3C, 0xF8, 0xFC, 0x7C, 0xF8,
  0xFC, 0x7C, 0xF9, 0xDC, 0x7C, 0xF9, 0xDC, 0xF8, 0xF9, 0xDC, 0xF8, 0xFB,
  0x9C, 0xF8, 0xFB, 0x9C, 0xF0, 0xFB, 0x9D, 0xF0, 0xFB, 0x9D, 0xF0, 0xFF,
  0x1D, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8,
  0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF7, 0xF0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xBF, 0x1F, 0xFD, 0xF8, 0xFF, 0xDF, 0x81, 0xFC, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0xF9, 0xFF, 0xE1, 0xF7,
  0xFF, 0xC3, 0xEF, 0x8F, 0xCF, 0x9F, 0x1F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7C,
  0x1F, 0xF9, 0xF0, 0x3F, 0xE0, 0x00, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 17, 12, 25, 6, -30 },
  { 69, 26, 30, 25, 0, -30 },
  { 167, 23, 42, 25, 1, -36 },
  { 288, 30, 30, 25, -2, -30 },
  { 401, 24, 30, 25, 0, -30 },
  { 491, 7, 12, 25, 11, -30 },
  { 502, 19, 40, 25, 5, -35 },
  { 597, 18, 40, 25, 2, -35 },
  { 687, 22, 22, 25, 2, -25 },
  { 748, 21, 19, 25, 2, -23 },
  { 798, 13, 13, 25, 3, -6 },
  { 820, 15, 5, 25, 5, -16 },
  { 830, 9, 8, 25, 7, -8 },
  { 839, 26, 39, 25, 0, -34 },
  { 966, 22, 30, 25, 2, -30 },
  { 1049, 21, 30, 25, 1, -30 },
  { 1128, 23, 30, 25, 1, -30 },
  { 1215, 23, 30, 25, 1, -30 },
  { 1302, 22, 30, 25, 1, -30 },
  { 1385, 23, 30, 25, 1, -30 },
  { 1472, 22, 30, 25, 1, -30 },
  { 1555, 23, 30, 25, 3, -30 },
  { 1642, 23, 30, 25, 1, -30 },
  { 1729, 22, 30, 25, 3, -30 },
  { 1812, 11, 23, 25, 7, -23 },
  { 1844, 15, 30, 25, 3, -23 },
  { 1901, 21, 23, 25, 3, -25 },
  { 1962, 21, 16, 25, 2, -22 },
  { 2004, 22, 23, 25, 1, -25 },
  { 2068, 18, 30, 25, 5, -30 },
  { 2136, 27, 37, 25, -1, -30 },
  { 2261, 23, 30, 25, -1, -30 },
  { 2348, 24, 30, 25, 1, -30 },
  { 2438, 22, 30, 25, 2, -30 },
  { 2521, 24, 30, 25, 1, -30 },
  { 2611, 24, 30, 25, 1, -30 },
  { 2701, 24, 30, 25, 1, -30 },
  { 2791, 22, 30, 25, 2, -30 },
  { 2874, 24, 30, 25, 1, -30 },
  { 2964, 23, 30, 25, 1, -30 },
  { 3051, 24, 30, 25, 0, -30 },
  { 3141, 25, 30, 25, 1, -30 },
  { 3235, 19, 30, 25, 2, -30 },
  { 3307, 26, 30, 25, 0, -30 },
  { 3405, 24, 30, 25, 1, -30 },
  { 3495, 22, 30, 25, 2, -30 },
  { 3578, 24, 30, 25, 1, -30 },
  { 3668, 22, 37, 25, 2, -30 },
  { 3770, 24, 30, 25, 1, -30 },
  { 3860, 23, 30, 25, 1, -30 },
  { 3947, 22, 30, 25, 4, -30 },
  { 4030, 24, 30, 25, 1, -30 },
  { 4120, 23, 30, 25, 4, -30 },
  { 4207, 26, 30, 25, 1, -30 },
  { 4305, 27, 30, 25, -1, -30 },
  { 4407, 23, 30, 25, 4, -30 },
  { 4494, 23, 30, 25, 1, -30 },
  { 4581, 19, 39, 25, 4, -34 },
  { 4674, 14, 39, 25, 6, -34 },
  { 4743, 18, 39, 25, 3, -34 },
  { 4831, 20, 16, 25, 3, -30 },
  { 4871, 20, 6, 25, 0, 1 },
  { 4886, 9, 6, 25, 10, -32 },
  { 4893, 23, 23, 25, 1, -23 },
  { 4960, 22, 30, 25, 1, -30 },
  { 5043, 21, 23, 25, 2, -23 },
  { 5104, 24, 30, 25, 1, -30 },
  { 5194, 21, 23, 25, 2, -23 },
  { 5255, 27, 37, 25, -2, -30 },
  { 5380, 22, 30, 25, 2, -23 },
  { 5463, 22, 30, 25, 1, -30 },
  { 5546, 21, 33, 25, 1, -33 },
  { 5633, 23, 40, 25, 0, -33 },
  { 5748, 24, 30, 25, 1, -30 },
  { 5838, 19, 30, 25, 3, -30 },
  { 5910, 24, 23, 25, 0, -23 },
  { 5979, 22, 23, 25, 1, -23 },
  { 6043, 21, 23, 25, 2, -23 },
  { 6104, 23, 30, 25, 0, -23 },
  { 6191, 23, 30, 25, 1, -23 },
  { 6278, 22, 23, 25, 2, -23 },
  { 6342, 22, 23, 25, 1, -23 },
  { 6406, 22, 29, 25, 2, -29 },
  { 6486, 22, 23, 25, 2, -23 },
  { 6550, 22, 23, 25, 3, -23 },
  { 6614, 24, 23, 25, 2, -23 },
  { 6683, 26, 23, 25, -1, -23 },
  { 6758, 21, 30, 25, 2, -23 },
  { 6837, 22, 23, 25, 1, -23 },
  { 6901, 22, 39, 25, 3, -34 },
  { 7009, 12, 39, 25, 7, -34 },
  { 7068, 22, 39, 25, 1, -34 },
  { 7176, 23, 11, 25, 1, -20 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC41PT7B_H_
