#ifndef _JETBRAINSMONO_EXTRABOLDITALIC38PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xFE, 0x3F, 0x8F, 0xC3, 0xE0,
  0x7E, 0x3E, 0xF8, 0x7D, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xE7, 0x87, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xC1, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFD, 0x9F, 0x87, 0xE6, 0x7E, 0x1F, 0x19, 0xF8, 0x7C,
  0xE0, 0x01, 0xFB, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x18, 0xFC, 0x00, 0x63, 0xF3, 0xF1, 0x8F, 0xCF, 0xCE,
  0x3E, 0x3F, 0xB9, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x3F, 0xE0, 0x1E, 0x07, 0xFE, 0x03, 0xC0, 0x79, 0xF0, 0x78, 0x0F, 0x0F,
  0x0F, 0x00, 0xF0, 0xF1, 0xF0, 0x0F, 0x0F, 0x1E, 0x00, 0xF0, 0xE3, 0xC0,
  0x0F, 0x1E, 0x78, 0x00, 0xFB, 0xEF, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x7F,
  0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE1, 0x00, 0x00, 0x3D, 0xFC, 0x00, 0x07, 0xBF, 0xE0, 0x00,
  0xF7, 0xFF, 0x00, 0x1E, 0x78, 0xF0, 0x03, 0xC7, 0x0F, 0x00, 0x7C, 0xF0,
  0xF0, 0x07, 0x8F, 0x0F, 0x00, 0xF0, 0xF0, 0xE0, 0x1E, 0x0F, 0x1E, 0x03,
  0xC0, 0xFF, 0xE0, 0x78, 0x07, 0xFC, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8,
  0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x40, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x87, 0xCF, 0xFF, 0x3F, 0x3E, 0x7C, 0xF9, 0xF9, 0xFF, 0xC7,
  0xC3, 0xFF, 0x1F, 0x0F, 0xF8, 0x7C, 0x1F, 0xC1, 0xF0, 0x7F, 0x07, 0xC0,
  0xF8, 0x1F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xBF,
  0x07, 0xF8, 0x7C, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3,
  0xE7, 0xC0, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x20, 0x78, 0x17, 0x87, 0x0F, 0x7C, 0x73, 0xFF, 0xE6, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xB8,
  0x00, 0xFB, 0xC0, 0x1F, 0x3E, 0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0x87, 0xC1,
  0xF0, 0x1C, 0x1C, 0x00, 0x80, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7E,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x63, 0xE3, 0xE7, 0x9F, 0x1F,
  0x7C, 0xF8, 0xFB, 0xF7, 0xC7, 0xCF, 0x7E, 0x7E, 0x33, 0xF3, 0xF0, 0x1F,
  0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xE7, 0xE0, 0x78, 0xF8, 0x1C, 0x3F,
  0x03, 0x07, 0xE0, 0x40, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xE1, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x3F,
  0x8F, 0xE7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x8F, 0xE0, 0x7C, 0x7E, 0x07, 0xE3, 0xE0,
  0x3F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x3E, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x3E,
  0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFD, 0xF0,
  0x1F, 0xBF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0xFF, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7E, 0xFE, 0x07, 0xE7, 0xFB, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x1F,
  0xDF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x9F, 0xF7, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFE, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xBF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x07, 0xC0, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x30, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE0, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0x03,
  0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x0F, 0x81, 0xC7, 0x87, 0xC3, 0xFB, 0xC3, 0xC3, 0xFD, 0xE1, 0xE1,
  0xFF, 0xF0, 0xF1, 0xF0, 0xF8, 0xF8, 0xF0, 0x7C, 0x7C, 0x78, 0x3C, 0x3E,
  0x7C, 0x1E, 0x1F, 0x3E, 0x1F, 0x0F, 0x1F, 0x0F, 0x87, 0x8F, 0x87, 0xC7,
  0xC7, 0x83, 0xE3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF3, 0xF0, 0xF8, 0xFF, 0x78,
  0x78, 0x3F, 0xBC, 0x3C, 0x0F, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xF9, 0xE0, 0x07,
  0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x03,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x01, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x07, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8,
  0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xC1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x08, 0xFC, 0x7F, 0xC3, 0xE3, 0xFF, 0x0F, 0x8F, 0xFC, 0x7E, 0x3F,
  0xF1, 0xF8, 0xFF, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0,
  0x1F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xDE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xF3, 0xFE, 0x1F, 0xF3, 0xBE, 0x1F, 0xF7, 0xBC, 0x1E, 0x77, 0x3C, 0x1E,
  0x7F, 0x7C, 0x3E, 0x7F, 0x7C, 0x3E, 0x7E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3E,
  0x7C, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x7C, 0x3F, 0x81, 0xF0, 0xFE, 0x07, 0xC7, 0xF8,
  0x1F, 0x1F, 0xE0, 0x7C, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xBC, 0x3E,
  0x1E, 0xF0, 0xF8, 0x7B, 0xC3, 0xE3, 0xEF, 0x0F, 0x8F, 0xBE, 0x7C, 0x3E,
  0x79, 0xF0, 0xF9, 0xE7, 0xC3, 0xE7, 0x9F, 0x0F, 0x9E, 0x7C, 0x7C, 0x79,
  0xF1, 0xF1, 0xF7, 0xC7, 0xC3, 0xDE, 0x1F, 0x0F, 0x78, 0x7C, 0x3D, 0xE1,
  0xF0, 0xFF, 0x8F, 0xC3, 0xFE, 0x3E, 0x0F, 0xF8, 0xF8, 0x1F, 0xC3, 0xE0,
  0x7F, 0x0F, 0x81, 0xFC, 0x3E, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7E,
  0x0F, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x07, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F,
  0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x0F, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x7E, 0x07, 0xC1,
  0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0,
  0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x1E, 0x1F, 0x3E, 0x1E, 0x1F, 0x3E,
  0x3E, 0x1F, 0x3C, 0x3E, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x7E, 0x3E, 0x3C,
  0x7E, 0x3E, 0x3C, 0x7E, 0x3C, 0x3C, 0x6E, 0x3C, 0x7C, 0xEE, 0x7C, 0x7C,
  0xEE, 0x7C, 0x7C, 0xEE, 0x78, 0x7C, 0xCE, 0x78, 0x7D, 0xCE, 0xF8, 0x7D,
  0xCE, 0xF0, 0x79, 0xCE, 0xF0, 0x7B, 0x8C, 0xF0, 0x7B, 0x8D, 0xF0, 0x7B,
  0x8D, 0xE0, 0x7B, 0x8D, 0xE0, 0x7F, 0x1D, 0xE0, 0x7F, 0x1D, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80,
  0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xFD,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8,
  0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xC7, 0xC3, 0xF0, 0xF8, 0xF8, 0x3E,
  0x7E, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF8, 0x01, 0xF9, 0xF8, 0x3F, 0xEF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xBE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0x81, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0xE0, 0xFB, 0xFF, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0x7F, 0xC1, 0xF1, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x7E, 0x07, 0xFD, 0xF8, 0x3F, 0xF7, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xF7, 0xC1, 0xFF, 0xFF, 0x03, 0xFE, 0xFC, 0x07, 0xF3, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x87,
  0xF3, 0xF0, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x7E, 0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x3F, 0xEF,
  0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFC,
  0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x7F, 0x8F, 0xFF,
  0xFC, 0x7F, 0xF7, 0xC1, 0xFF, 0xBE, 0x07, 0xFB, 0xF0, 0x0F, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x1F, 0xBF, 0xE1, 0xF7, 0xFE, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x04, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F,
  0xE1, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03,
  0xF1, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0x78, 0xF8, 0x3F, 0xFB, 0xF8, 0x7B,
  0xF7, 0xF0, 0xFF, 0xFF, 0xE1, 0xF3, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x8F,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x79, 0xF0, 0xF9, 0xE3,
  0xE3, 0xE3, 0xC7, 0xC7, 0xC7, 0x8F, 0x8F, 0x8F, 0x1F, 0x1F, 0x1E, 0x3E,
  0x3E, 0x3C, 0x78, 0x7C, 0xF1, 0xF1, 0xF1, 0xE3, 0xE3, 0xE3, 0xC7, 0xC7,
  0xC7, 0x8F, 0x8F, 0x8F, 0x1F, 0x00, 0x1F, 0x9F, 0x81, 0xF3, 0xFE, 0x1F,
  0x7F, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x07,
  0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3,
  0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x3E, 0x7F, 0xC0, 0xFB, 0xFF,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xBF, 0xE0, 0x7E,
  0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x3F, 0xEF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3,
  0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F,
  0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xBE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xDF, 0x81, 0xFC, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F,
  0x8F, 0xE0, 0x3E, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x7F, 0x1F, 0x80,
  0xF8, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03,
  0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E,
  0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xF8, 0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x0F, 0x87, 0xBC, 0x3E,
  0x1E, 0xF0, 0xF8, 0xFB, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x6E, 0x7C,
  0xF3, 0xB9, 0xE3, 0xCE, 0xE7, 0x8F, 0x3B, 0x9E, 0x3D, 0xCE, 0xF8, 0xF7,
  0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x63, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x00,
  0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x03, 0xF1, 0xF8,
  0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0,
  0x0F, 0xC7, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E,
  0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x07, 0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC1,
  0xFF, 0x7E, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x83, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xF7, 0xCF, 0xCF, 0xBC, 0x3F,
  0xF9, 0xE1, 0xFF, 0xDF, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 15, 12, 23, 6, -28 },
  { 59, 24, 28, 23, 0, -28 },
  { 143, 22, 38, 23, 1, -33 },
  { 248, 28, 28, 23, -2, -28 },
  { 346, 22, 28, 23, 0, -28 },
  { 423, 7, 12, 23, 10, -28 },
  { 434, 17, 37, 23, 5, -32 },
  { 513, 17, 37, 23, 2, -32 },
  { 592, 20, 20, 23, 2, -23 },
  { 642, 19, 19, 23, 2, -22 },
  { 688, 11, 12, 23, 3, -6 },
  { 705, 14, 5, 23, 5, -15 },
  { 714, 8, 7, 23, 6, -7 },
  { 721, 24, 36, 23, 0, -32 },
  { 829, 21, 28, 23, 1, -28 },
  { 903, 19, 28, 23, 1, -28 },
  { 970, 21, 28, 23, 1, -28 },
  { 1044, 21, 28, 23, 1, -28 },
  { 1118, 21, 28, 23, 1, -28 },
  { 1192, 21, 28, 23, 1, -28 },
  { 1266, 20, 28, 23, 1, -28 },
  { 1336, 21, 28, 23, 3, -28 },
  { 1410, 21, 28, 23, 1, -28 },
  { 1484, 20, 28, 23, 3, -28 },
  { 1554, 11, 21, 23, 6, -21 },
  { 1583, 14, 27, 23, 3, -21 },
  { 1631, 19, 21, 23, 3, -23 },
  { 1681, 19, 15, 23, 2, -20 },
  { 1717, 20, 21, 23, 1, -23 },
  { 1770, 18, 28, 23, 4, -28 },
  { 1833, 25, 35, 23, -1, -28 },
  { 1943, 21, 28, 23, -1, -28 },
  { 2017, 22, 28, 23, 1, -28 },
  { 2094, 22, 28, 23, 1, -28 },
  { 2171, 22, 28, 23, 1, -28 },
  { 2248, 22, 28, 23, 1, -28 },
  { 2325, 22, 28, 23, 1, -28 },
  { 2402, 22, 28, 23, 1, -28 },
  { 2479, 22, 28, 23, 1, -28 },
  { 2556, 22, 28, 23, 1, -28 },
  { 2633, 23, 28, 23, 0, -28 },
  { 2714, 23, 28, 23, 1, -28 },
  { 2795, 18, 28, 23, 2, -28 },
  { 2858, 24, 28, 23, 0, -28 },
  { 2942, 22, 28, 23, 1, -28 },
  { 3019, 21, 28, 23, 1, -28 },
  { 3093, 22, 28, 23, 1, -28 },
  { 3170, 21, 35, 23, 1, -28 },
  { 3262, 22, 28, 23, 1, -28 },
  { 3339, 22, 28, 23, 1, -28 },
  { 3416, 21, 28, 23, 3, -28 },
  { 3490, 22, 28, 23, 1, -28 },
  { 3567, 21, 28, 23, 4, -28 },
  { 3641, 24, 28, 23, 1, -28 },
  { 3725, 25, 28, 23, -1, -28 },
  { 3813, 22, 28, 23, 3, -28 },
  { 3890, 21, 28, 23, 1, -28 },
  { 3964, 17, 36, 23, 4, -32 },
  { 4041, 14, 36, 23, 5, -32 },
  { 4104, 18, 36, 23, 2, -32 },
  { 4185, 18, 15, 23, 3, -28 },
  { 4219, 19, 5, 23, 0, 1 },
  { 4231, 9, 5, 23, 9, -30 },
  { 4237, 21, 21, 23, 1, -21 },
  { 4293, 21, 28, 23, 1, -28 },
  { 4367, 21, 21, 23, 1, -21 },
  { 4423, 22, 28, 23, 1, -28 },
  { 4500, 20, 21, 23, 1, -21 },
  { 4553, 25, 35, 23, -2, -28 },
  { 4663, 21, 28, 23, 1, -21 },
  { 4737, 20, 28, 23, 1, -28 },
  { 4807, 19, 30, 23, 1, -30 },
  { 4879, 21, 37, 23, 0, -30 },
  { 4977, 22, 28, 23, 1, -28 },
  { 5054, 18, 28, 23, 3, -28 },
  { 5117, 23, 21, 23, 0, -21 },
  { 5178, 20, 21, 23, 1, -21 },
  { 5231, 20, 21, 23, 1, -21 },
  { 5284, 22, 28, 23, 0, -21 },
  { 5361, 21, 28, 23, 1, -21 },
  { 5435, 22, 21, 23, 1, -21 },
  { 5493, 21, 21, 23, 1, -21 },
  { 5549, 20, 27, 23, 2, -27 },
  { 5617, 21, 21, 23, 1, -21 },
  { 5673, 20, 21, 23, 3, -21 },
  { 5726, 22, 21, 23, 2, -21 },
  { 5784, 24, 21, 23, -1, -21 },
  { 5847, 21, 28, 23, 1, -21 },
  { 5921, 20, 21, 23, 1, -21 },
  { 5974, 20, 36, 23, 3, -32 },
  { 6064, 12, 36, 23, 6, -32 },
  { 6118, 21, 36, 23, 0, -32 },
  { 6213, 21, 9, 23, 1, -18 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC38PT7B_H_
