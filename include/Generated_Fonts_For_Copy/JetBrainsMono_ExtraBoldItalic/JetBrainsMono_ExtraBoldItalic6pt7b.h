#ifndef _JETBRAINSMONO_EXTRABOLDITALIC6PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7E, 0xEA, 0x25, 0x62, 0xE4, 0xD6, 0x6E, 0x65, 0xAE,
  0x80, 0x6A, 0x90, 0x44, 0x95, 0x00, 0x2B, 0x6A, 0x7C, 0x70, 0xC0, 0x80,
  0x12, 0x24, 0x48, 0x7E, 0xAE, 0x64, 0xF0, 0x62, 0x4E, 0x6C, 0xF0, 0x2F,
  0x90, 0x76, 0x2E, 0x6E, 0xF0, 0x7A, 0x44, 0x66, 0xAE, 0x7E, 0x24, 0xC8,
  0x61, 0x60, 0x2F, 0x10, 0x7C, 0x8D, 0xC0, 0xFA, 0xFB, 0xDE, 0xC0, 0x6F,
  0xD0, 0x76, 0xAE, 0x78, 0x8E, 0x7A, 0xAE, 0x76, 0x8E, 0x76, 0x88, 0x78,
  0xAE, 0x56, 0xAA, 0x74, 0x4E, 0x32, 0x2E, 0x76, 0xAA, 0x4A, 0x70, 0x7D,
  0xAA, 0x5E, 0xAA, 0x6A, 0xAE, 0x7A, 0xC8, 0x6A, 0xAE, 0x20, 0x7E, 0xAA,
  0x74, 0x2E, 0xF2, 0x40, 0x5A, 0xAE, 0xBB, 0x40, 0xBD, 0xEA, 0x76, 0x6A,
  0xFA, 0x40, 0x72, 0x4E, 0xEA, 0xB0, 0xA9, 0x50, 0x64, 0x95, 0x80, 0x7C,
  0xE0, 0xC0, 0x77, 0x80, 0x4E, 0xF0, 0x73, 0x80, 0x16, 0xAE, 0x7F, 0x80,
  0x7E, 0x44, 0xC0, 0x77, 0xF0, 0x4E, 0xD0, 0x21, 0xAE, 0x21, 0x93, 0x80,
  0x5A, 0xEA, 0xE9, 0x30, 0xFE, 0xE0, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0,
  0x77, 0x90, 0x78, 0x80, 0xEF, 0x80, 0x5D, 0x30, 0xF7, 0x80, 0xB6, 0x40,
  0xDE, 0xA0, 0xF4, 0xA0, 0xF5, 0xF0, 0x6B, 0x80, 0x32, 0x6A, 0x42, 0x5A,
  0xA0, 0x49, 0xA5, 0x00, 0xD2,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 4, 4, 4, 0, -4 },
  { 20, 3, 2, 4, 0, -3 },
  { 21, 2, 2, 4, 0, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 4, 6, 4, 0, -5 },
  { 27, 4, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 4, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 4, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 4, 4, 4, 0, -4 },
  { 43, 4, 4, 4, 0, -4 },
  { 45, 4, 4, 4, 0, -4 },
  { 47, 2, 3, 4, 1, -3 },
  { 48, 3, 4, 4, 0, -3 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 3, 2, 4, 0, -3 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 4, 5, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 4, 4, 4, 0, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 4, 5, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 3, 4, 4, 1, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 3, 4, 4, 1, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 4, 4, 4, 0, -4 },
  { 108, 3, 4, 4, 1, -4 },
  { 110, 4, 4, 4, 0, -4 },
  { 112, 2, 6, 4, 1, -5 },
  { 114, 2, 6, 4, 1, -5 },
  { 116, 3, 6, 4, 0, -5 },
  { 119, 3, 2, 4, 0, -4 },
  { 120, 3, 1, 4, 0, 0 },
  { 121, 2, 1, 4, 1, -5 },
  { 122, 3, 3, 4, 0, -3 },
  { 124, 3, 4, 4, 0, -4 },
  { 126, 3, 3, 4, 0, -3 },
  { 128, 4, 4, 4, 0, -4 },
  { 130, 3, 3, 4, 0, -3 },
  { 132, 4, 5, 4, 0, -4 },
  { 135, 3, 4, 4, 0, -3 },
  { 137, 3, 4, 4, 0, -4 },
  { 139, 3, 5, 4, 0, -5 },
  { 141, 3, 6, 4, 0, -5 },
  { 144, 4, 4, 4, 0, -4 },
  { 146, 3, 4, 4, 0, -4 },
  { 148, 4, 3, 4, 0, -3 },
  { 150, 3, 3, 4, 0, -3 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 4, 4, 0, -3 },
  { 156, 3, 4, 4, 0, -3 },
  { 158, 4, 3, 4, 0, -3 },
  { 160, 3, 3, 4, 0, -3 },
  { 162, 3, 4, 4, 0, -4 },
  { 164, 3, 3, 4, 0, -3 },
  { 166, 4, 3, 4, 0, -3 },
  { 168, 4, 3, 4, 0, -3 },
  { 170, 4, 3, 4, 0, -3 },
  { 172, 3, 4, 4, 0, -3 },
  { 174, 3, 3, 4, 0, -3 },
  { 176, 4, 6, 4, 0, -5 },
  { 179, 2, 6, 4, 1, -5 },
  { 181, 3, 6, 4, 0, -5 },
  { 184, 4, 2, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC6PT7B_H_
