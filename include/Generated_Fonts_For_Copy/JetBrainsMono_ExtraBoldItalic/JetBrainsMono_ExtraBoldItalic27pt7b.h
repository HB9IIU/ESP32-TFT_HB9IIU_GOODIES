#ifndef _JETBRAINSMONO_EXTRABOLDITALIC27PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3,
  0x88, 0x00, 0x00, 0x71, 0xF3, 0xE7, 0x80, 0x79, 0xEF, 0x3D, 0xE7, 0xF8,
  0xFF, 0x3F, 0xE7, 0xBC, 0xF7, 0x9E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1,
  0xC0, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x0E,
  0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC7, 0x07, 0xFF, 0xF3,
  0xFF, 0xF8, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x70, 0x0E, 0x38,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1F, 0x80, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x9E, 0xDF, 0x3D, 0x9E, 0x7B, 0x00, 0xF6, 0x01, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0x7C, 0x06, 0x7B, 0xC9,
  0xE7, 0xD7, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x3F, 0x03, 0x83, 0xFC, 0x38,
  0x18, 0xE3, 0x80, 0xC7, 0x38, 0x0E, 0x3B, 0x80, 0x73, 0xB8, 0x01, 0xFF,
  0x80, 0x0F, 0xB8, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xDE, 0x00,
  0x1D, 0xF8, 0x01, 0xDD, 0xE0, 0x1C, 0xC7, 0x01, 0xCE, 0x30, 0x1C, 0x71,
  0x80, 0xC3, 0x9C, 0x0E, 0x1F, 0xC1, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0x3E, 0x0F, 0x1E, 0x0E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0x8F, 0x7B, 0xDE, 0x7B, 0xDC, 0x79,
  0xFC, 0x70, 0xF8, 0xF0, 0xF0, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0x3C, 0x7B, 0xDE, 0xFF, 0x7B, 0xDE, 0x00, 0x30, 0x0E, 0x03, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x0C, 0x00, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x7F, 0x07, 0xC0, 0x78, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0x8C, 0x67, 0x9B, 0xFF, 0xAF, 0xDF,
  0xFF, 0x01, 0xC0, 0x0F, 0xC0, 0x39, 0xC0, 0xF3, 0xC3, 0xC7, 0x83, 0x8E,
  0x02, 0x08, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0x70, 0xF0, 0x7F, 0xDF,
  0xF7, 0xFF, 0xFF, 0x3D, 0xF7, 0xDF, 0x78, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x83,
  0xCE, 0x07, 0xBC, 0x0E, 0x7B, 0xBC, 0xF7, 0x79, 0xEE, 0xF3, 0xDD, 0xE7,
  0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE1, 0xFF,
  0x81, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xE7, 0x83, 0x1E, 0x08, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xEF,
  0x87, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x3C, 0xF8, 0xF9,
  0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xF7,
  0xC7, 0xDE, 0x1E, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1,
  0xF1, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x3C, 0xF8,
  0xF9, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF0, 0xFF,
  0xE7, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF8,
  0xF9, 0xFF, 0xC7, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0xEF, 0x83, 0xDE, 0x0F, 0x3C, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFB, 0xF3, 0xC3, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x3E, 0x1F,
  0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1F,
  0x78, 0x3C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xBF, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF8, 0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xBC, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x3F, 0x3F,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7C, 0x7C, 0x7C, 0x78,
  0x07, 0x83, 0xF0, 0xFC, 0x3E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x1F, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x1F, 0x83, 0xFE, 0x3F, 0xC3, 0xFC, 0x0F, 0x80,
  0x3C, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x01,
  0xC0, 0x01, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x30, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x1E, 0x03, 0xF8,
  0x3F, 0xC7, 0xFC, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x3F,
  0x03, 0xFC, 0x3F, 0xE7, 0xFF, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x3F,
  0xE3, 0xFC, 0x3F, 0x83, 0xE0, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xE3, 0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x1E, 0xF1, 0xFE, 0x79, 0xFB,
  0x38, 0xE7, 0x9C, 0xF1, 0xCE, 0x70, 0xE7, 0x38, 0xF3, 0x9C, 0x7B, 0xCE,
  0x39, 0xC7, 0x1C, 0xE3, 0xFE, 0x71, 0xF7, 0x38, 0x20, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xF7,
  0x01, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x3C, 0x70, 0x78, 0xF0, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7F, 0xC0,
  0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xC3, 0xE7, 0x83,
  0xCF, 0x0F, 0x9E, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC3, 0xC7, 0xC7,
  0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF,
  0x87, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x1F, 0x78, 0x3C, 0xF8, 0xF8, 0xFF,
  0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF3, 0xC3, 0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x3E, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x1F, 0x78, 0x3C, 0xFF,
  0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF8,
  0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xF9, 0xE7, 0xF3, 0xCF, 0xE7,
  0x9F, 0xDF, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE1, 0xFF,
  0x80, 0xFE, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x1E, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xC7, 0x87, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0,
  0x3C, 0xF8, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1E,
  0x0F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C,
  0xF8, 0x3C, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x79,
  0xE0, 0x79, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x78, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xB3, 0xF1, 0xD9,
  0xF8, 0xEC, 0xDC, 0x76, 0xFE, 0x3B, 0xEF, 0x1D, 0xF7, 0x9E, 0xF3, 0x8F,
  0x39, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C,
  0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x8F, 0x83, 0x87,
  0xE1, 0xC3, 0xF1, 0xE1, 0xF8, 0xF0, 0xFC, 0x78, 0x7E, 0x3C, 0x7F, 0x9C,
  0x3D, 0xCE, 0x1E, 0xEF, 0x0F, 0x77, 0x87, 0x3B, 0xC3, 0x9D, 0xE3, 0xC7,
  0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0x78, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x1E,
  0x0F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC3, 0xE7,
  0x83, 0xCF, 0x0F, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xDF, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE1,
  0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3E, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xC3, 0xE7, 0x83, 0xCF, 0x0F, 0xBC, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xDF, 0x0F, 0x3C, 0x1E,
  0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xF3, 0xC3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x3C,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x0F, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xE7, 0x83, 0xC0, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x78, 0x3C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1E,
  0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x87, 0x3C,
  0x1C, 0xF0, 0x73, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x71, 0xE7, 0xB8, 0xF3, 0xDC, 0x79, 0xCE, 0x28,
  0xE7, 0x3C, 0x73, 0x9E, 0x79, 0xCF, 0x38, 0xEF, 0x9C, 0x76, 0xCE, 0x3B,
  0x6F, 0x1D, 0xB7, 0x1F, 0x9B, 0x8E, 0xCD, 0xC7, 0x67, 0xC3, 0xB3, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x1E, 0x00, 0x0F,
  0x03, 0xC3, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x9E, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x1E,
  0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xE3, 0xE0, 0x78, 0xF8, 0x1F, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3D, 0xE0,
  0x1D, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0xF8, 0xFF,
  0x8F, 0xF0, 0xFF, 0x00, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F, 0x70, 0xF3, 0xC7, 0x9E,
  0x78, 0x73, 0xC3, 0xBC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8,
  0xF0, 0xF0, 0x0F, 0x9E, 0x3F, 0xF8, 0xFF, 0xF1, 0xF7, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7,
  0xCF, 0xFF, 0x8F, 0xEE, 0x0F, 0xBC, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF7, 0xC3, 0xFF, 0x8F, 0xFF, 0x7E, 0xFD, 0xF0,
  0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF8,
  0xFB, 0xFF, 0xCF, 0xFE, 0x3D, 0xF0, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF,
  0x9F, 0x78, 0x3D, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x07, 0xBE, 0x3E, 0x7F, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xF7, 0xC7, 0xFF, 0x1F, 0xFE,
  0x3E, 0xFC, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x9F, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF8, 0xF9, 0xFF, 0xF1, 0xFD, 0xC1, 0xF7, 0x80, 0x07,
  0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3E, 0x1E, 0x7F, 0xF1, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xBE, 0x3F, 0xF8, 0xFF, 0xF1, 0xF7, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xF3, 0xE3, 0xFF,
  0xC7, 0xF7, 0x87, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF7, 0xC3, 0xFF, 0x8F, 0xFF, 0x7E, 0xFD, 0xF0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x79, 0xE1, 0xEF, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x0F, 0xBC, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x1F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x1F, 0x3C, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0x79, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0xF1,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0x7F, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0xF8, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3B, 0xDE, 0x3B, 0xDF, 0x3F, 0xFF,
  0x39, 0xCF, 0x39, 0xCF, 0x79, 0xCE, 0x79, 0xCE, 0x79, 0xCE, 0x71, 0x9E,
  0x73, 0x9E, 0x73, 0x9E, 0xF3, 0x9C, 0xF3, 0x9C, 0xF3, 0x9C, 0xF3, 0x3C,
  0x3D, 0xF0, 0xFF, 0xE3, 0xBF, 0xDF, 0xBF, 0x7C, 0x3D, 0xE0, 0xF7, 0x83,
  0xDE, 0x1E, 0x78, 0x7B, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3,
  0xEF, 0x0F, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0xBF, 0x78, 0x3D,
  0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xBE, 0x3E,
  0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x77, 0xF9,
  0xF9, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0xF8,
  0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1E, 0xF8, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x9E, 0x3F, 0xF8,
  0xFF, 0xF1, 0xF7, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0xF8,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F, 0xBC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0xF8,
  0x7B, 0xF8, 0xFF, 0xF9, 0xF3, 0xF3, 0xC3, 0xE7, 0x87, 0xDE, 0x0F, 0xBC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0xDF, 0x0F, 0x78, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0xBC, 0x1E,
  0xFF, 0xFB, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0x3C, 0x1E, 0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xE1,
  0xE7, 0xC7, 0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0xF0, 0x3F, 0xE0,
  0x7B, 0xC1, 0xF7, 0x83, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0,
  0x79, 0xE0, 0xF7, 0x80, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xF1, 0xC7, 0xF3, 0xC7, 0xF3, 0xCE, 0xF3, 0xCE, 0xF6, 0xCE,
  0xE6, 0xDC, 0xE6, 0xDC, 0xE4, 0xDC, 0xEC, 0xFC, 0xEC, 0xF8, 0xEC, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0, 0xF1, 0xF0, 0x3E, 0x1F, 0x1E, 0x1E,
  0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x78, 0x7C,
  0xF8, 0x3C, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE1,
  0xF7, 0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xE3, 0xEF, 0xFF, 0x9F, 0xDE, 0x7F,
  0xF8, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xF1, 0xFF, 0x87, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0xFE, 0x3D, 0xFE, 0x7F, 0xBE, 0xEE, 0x3F,
  0xDC, 0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 5, -20 },
  { 19, 11, 8, 16, 4, -20 },
  { 30, 17, 20, 16, 0, -20 },
  { 73, 15, 27, 16, 1, -23 },
  { 124, 21, 20, 16, -2, -20 },
  { 177, 16, 20, 16, 0, -20 },
  { 217, 5, 8, 16, 7, -20 },
  { 222, 12, 26, 16, 4, -23 },
  { 261, 12, 26, 16, 1, -23 },
  { 300, 15, 14, 16, 1, -16 },
  { 327, 14, 13, 16, 1, -15 },
  { 350, 8, 8, 16, 2, -4 },
  { 358, 10, 4, 16, 3, -11 },
  { 363, 6, 5, 16, 4, -5 },
  { 367, 17, 25, 16, 0, -22 },
  { 421, 15, 20, 16, 1, -20 },
  { 459, 14, 20, 16, 1, -20 },
  { 494, 15, 20, 16, 1, -20 },
  { 532, 15, 20, 16, 1, -20 },
  { 570, 14, 20, 16, 1, -20 },
  { 605, 15, 20, 16, 1, -20 },
  { 643, 14, 20, 16, 1, -20 },
  { 678, 15, 20, 16, 2, -20 },
  { 716, 15, 20, 16, 1, -20 },
  { 754, 14, 20, 16, 2, -20 },
  { 789, 8, 15, 16, 4, -15 },
  { 804, 10, 19, 16, 2, -15 },
  { 828, 14, 15, 16, 2, -16 },
  { 855, 13, 10, 16, 2, -14 },
  { 872, 14, 15, 16, 1, -16 },
  { 899, 12, 20, 16, 3, -20 },
  { 929, 17, 25, 16, 0, -20 },
  { 983, 15, 20, 16, -1, -20 },
  { 1021, 15, 20, 16, 1, -20 },
  { 1059, 15, 20, 16, 1, -20 },
  { 1097, 15, 20, 16, 1, -20 },
  { 1135, 15, 20, 16, 1, -20 },
  { 1173, 16, 20, 16, 1, -20 },
  { 1213, 15, 20, 16, 1, -20 },
  { 1251, 15, 20, 16, 1, -20 },
  { 1289, 15, 20, 16, 1, -20 },
  { 1327, 16, 20, 16, 0, -20 },
  { 1367, 16, 20, 16, 1, -20 },
  { 1407, 13, 20, 16, 1, -20 },
  { 1440, 17, 20, 16, 0, -20 },
  { 1483, 17, 20, 16, 0, -20 },
  { 1526, 15, 20, 16, 1, -20 },
  { 1564, 16, 20, 16, 1, -20 },
  { 1604, 15, 25, 16, 1, -20 },
  { 1651, 15, 20, 16, 1, -20 },
  { 1689, 15, 20, 16, 1, -20 },
  { 1727, 15, 20, 16, 2, -20 },
  { 1765, 16, 20, 16, 1, -20 },
  { 1805, 14, 20, 16, 3, -20 },
  { 1840, 17, 20, 16, 1, -20 },
  { 1883, 18, 20, 16, -1, -20 },
  { 1928, 16, 20, 16, 2, -20 },
  { 1968, 15, 20, 16, 1, -20 },
  { 2006, 12, 25, 16, 3, -22 },
  { 2044, 9, 25, 16, 4, -22 },
  { 2073, 12, 25, 16, 2, -22 },
  { 2111, 13, 11, 16, 2, -20 },
  { 2129, 13, 3, 16, 0, 1 },
  { 2134, 7, 4, 16, 6, -21 },
  { 2138, 15, 15, 16, 1, -15 },
  { 2167, 14, 20, 16, 1, -20 },
  { 2202, 14, 15, 16, 1, -15 },
  { 2229, 15, 20, 16, 1, -20 },
  { 2267, 14, 15, 16, 1, -15 },
  { 2294, 19, 25, 16, -2, -20 },
  { 2354, 15, 20, 16, 1, -15 },
  { 2392, 14, 20, 16, 1, -20 },
  { 2427, 14, 21, 16, 1, -21 },
  { 2464, 15, 26, 16, 0, -21 },
  { 2513, 16, 20, 16, 1, -20 },
  { 2553, 13, 20, 16, 2, -20 },
  { 2586, 16, 15, 16, 0, -15 },
  { 2616, 14, 15, 16, 1, -15 },
  { 2643, 14, 15, 16, 1, -15 },
  { 2670, 15, 20, 16, 0, -15 },
  { 2708, 15, 20, 16, 1, -15 },
  { 2746, 15, 15, 16, 1, -15 },
  { 2775, 14, 15, 16, 1, -15 },
  { 2802, 14, 19, 16, 2, -19 },
  { 2836, 15, 15, 16, 1, -15 },
  { 2865, 15, 15, 16, 2, -15 },
  { 2894, 16, 15, 16, 1, -15 },
  { 2924, 16, 15, 16, 0, -15 },
  { 2954, 14, 20, 16, 1, -15 },
  { 2989, 14, 15, 16, 1, -15 },
  { 3016, 15, 25, 16, 2, -22 },
  { 3063, 8, 25, 16, 4, -22 },
  { 3088, 15, 25, 16, 0, -22 },
  { 3135, 15, 7, 16, 1, -13 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC27PT7B_H_
