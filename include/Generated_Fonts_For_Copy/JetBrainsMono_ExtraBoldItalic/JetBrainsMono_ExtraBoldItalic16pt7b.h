#ifndef _JETBRAINSMONO_EXTRABOLDITALIC16PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x77, 0x66, 0x66, 0x00, 0xEC, 0x66, 0xDD, 0xBF, 0x6C, 0xC0,
  0x0C, 0xC3, 0x20, 0x99, 0xFF, 0x7F, 0xC4, 0xC3, 0x30, 0xC8, 0xFF, 0x99,
  0x86, 0x43, 0x30, 0x02, 0x00, 0x80, 0xF0, 0x7E, 0x3D, 0x8D, 0x07, 0x40,
  0xF8, 0x1F, 0x02, 0xE0, 0xB9, 0xAC, 0x7F, 0x0F, 0x81, 0x00, 0x40, 0x1C,
  0x33, 0xE6, 0x36, 0xC2, 0x68, 0x3D, 0x01, 0xA0, 0x06, 0x00, 0xFC, 0x1A,
  0x43, 0x64, 0x66, 0xCC, 0x38, 0x0E, 0x0F, 0x8E, 0xE6, 0x03, 0x81, 0xC1,
  0xF6, 0xDF, 0xEF, 0x73, 0x3F, 0xCF, 0x70, 0x6F, 0xFC, 0x02, 0x0C, 0x79,
  0xC3, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x06, 0x0F, 0x0E, 0x0C, 0x20,
  0x60, 0xF0, 0xE0, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE3, 0x9E, 0x38,
  0x40, 0x0C, 0x18, 0x59, 0xEF, 0x7E, 0x38, 0x6C, 0xEE, 0x44, 0x1C, 0x18,
  0x18, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x3B, 0x98, 0xCC, 0x00, 0xFF, 0xF0,
  0xFF, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x1E, 0x3F, 0x73,
  0x63, 0xE3, 0xFB, 0xDB, 0xC7, 0xC6, 0xC6, 0xFE, 0x7C, 0x0E, 0x3E, 0x7C,
  0x6C, 0x8C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0xFF, 0xFE, 0x0F, 0x0F, 0xCE,
  0xEE, 0x30, 0x18, 0x18, 0x1C, 0x3C, 0x38, 0x38, 0x1F, 0xDF, 0xE0, 0x1F,
  0x9F, 0xC0, 0xE0, 0xE0, 0xC0, 0x78, 0x1E, 0x07, 0x03, 0x31, 0x9F, 0xC7,
  0xC0, 0x07, 0x0E, 0x0C, 0x18, 0x38, 0x77, 0xE7, 0xC6, 0xFE, 0xFE, 0x06,
  0x0E, 0x7F, 0x7F, 0x60, 0x60, 0x6C, 0x7E, 0xE7, 0x07, 0x06, 0xC6, 0xFE,
  0x7C, 0x07, 0x03, 0x03, 0x83, 0x83, 0x81, 0xF9, 0xFE, 0xC7, 0x63, 0xB1,
  0x9F, 0xC7, 0xC0, 0x7F, 0xBF, 0xDF, 0xFC, 0x60, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x1C, 0x1C, 0x00, 0x0F, 0x0F, 0xCE, 0x66, 0x33, 0x39, 0xF8,
  0xFC, 0xE6, 0x63, 0xB1, 0x9F, 0xC7, 0xC0, 0x1E, 0x1F, 0x98, 0xDC, 0x6E,
  0x37, 0x39, 0xFC, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x00, 0x77, 0x60, 0x00,
  0x4E, 0xE0, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x0E, 0x71, 0x86, 0x30, 0x01,
  0x07, 0x1F, 0x7C, 0xE0, 0xF0, 0x7C, 0x1E, 0x06, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0xFE, 0x40, 0x70, 0x7C, 0x1F, 0x07, 0x1E, 0x7C, 0xF0, 0x80, 0x78,
  0xF9, 0xF8, 0x70, 0xEF, 0x9E, 0x30, 0x00, 0x03, 0x87, 0x00, 0x0F, 0x07,
  0xE3, 0x0D, 0x83, 0x66, 0xDB, 0x74, 0xCB, 0x26, 0xD9, 0xB6, 0x6C, 0xFB,
  0x00, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0xD8,
  0xCC, 0x7E, 0x7F, 0x31, 0xB8, 0xD8, 0x70, 0x3E, 0x0F, 0xE3, 0x18, 0xC6,
  0x33, 0x9F, 0xC7, 0xF1, 0x8E, 0x63, 0x98, 0xE7, 0xF3, 0xF8, 0x1E, 0x1F,
  0x9C, 0xCC, 0x6E, 0x07, 0x03, 0x81, 0x80, 0xC1, 0x63, 0x3F, 0x8F, 0x80,
  0x3E, 0x0F, 0xE3, 0xF8, 0xC6, 0x71, 0x9C, 0x67, 0x19, 0x8E, 0x63, 0x99,
  0xC7, 0xF3, 0xF0, 0x7F, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0xF3, 0xF9, 0xC0,
  0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF3, 0xF8, 0xC0, 0x30, 0x1F,
  0xE7, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x1E, 0x1F, 0x9C, 0xCC,
  0x6E, 0x07, 0x03, 0xBD, 0x9E, 0xC7, 0x63, 0x3F, 0x8F, 0x80, 0x39, 0xCC,
  0x73, 0x18, 0xC6, 0x31, 0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x18, 0xC6, 0x33,
  0x9C, 0x7F, 0x7F, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0xFE,
  0xFE, 0x0F, 0x87, 0xC3, 0xE0, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0xE3, 0x73,
  0xBF, 0x8F, 0x80, 0x38, 0xCC, 0x73, 0x38, 0xCC, 0x37, 0x1F, 0x87, 0xE1,
  0x98, 0x67, 0x19, 0xC6, 0x33, 0x8E, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0xE1, 0xC3, 0xFF, 0xF0, 0x39, 0xCE, 0x77, 0xBD, 0xEB, 0x6F, 0x9B,
  0xE6, 0xD9, 0x86, 0x61, 0xB8, 0xEC, 0x33, 0x0C, 0x38, 0xCE, 0x73, 0x98,
  0xE6, 0x6D, 0x9B, 0x66, 0xD9, 0xB6, 0x65, 0x19, 0xCE, 0x73, 0x1C, 0x1E,
  0x3F, 0x73, 0x63, 0xE3, 0xE3, 0xE7, 0xC7, 0xC6, 0xC6, 0xFE, 0x7C, 0x3F,
  0x0F, 0xE3, 0x3C, 0xC7, 0x31, 0xDC, 0xE7, 0xF1, 0xF8, 0x60, 0x18, 0x06,
  0x03, 0x80, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xE3, 0xE7, 0xC7, 0xC6, 0xC6,
  0xFE, 0x7C, 0x1C, 0x0C, 0x0E, 0x3E, 0x0F, 0xE3, 0x38, 0xC7, 0x31, 0x9F,
  0xE7, 0xF1, 0xF8, 0x66, 0x19, 0xC6, 0x73, 0x8C, 0x0F, 0x07, 0xE3, 0x98,
  0xC0, 0x30, 0x0F, 0x81, 0xF0, 0x0E, 0x03, 0x98, 0xC7, 0xF0, 0xF8, 0x7F,
  0xBF, 0xFF, 0xE3, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06,
  0x00, 0x73, 0xB1, 0xD8, 0xCC, 0x6E, 0x37, 0x1B, 0x9D, 0x8E, 0xC6, 0x63,
  0x3F, 0x8F, 0x80, 0xC3, 0xC7, 0xC6, 0xC6, 0xCE, 0xCC, 0xCC, 0xD8, 0xD8,
  0xF8, 0xF0, 0x70, 0xCC, 0xF3, 0x6D, 0xDB, 0x56, 0xDD, 0xB7, 0xCF, 0xF3,
  0xBC, 0xEA, 0x2A, 0x8C, 0xE3, 0x38, 0x31, 0xCE, 0x63, 0xB8, 0x6C, 0x1E,
  0x03, 0x81, 0xE0, 0x78, 0x3E, 0x1D, 0xC6, 0x33, 0x8E, 0xE1, 0xD8, 0xE6,
  0x31, 0xDC, 0x36, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x7F, 0x7F, 0x7F, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xFE, 0xFE,
  0x3E, 0x7C, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1F,
  0x3E, 0x00, 0xE1, 0x86, 0x18, 0x71, 0xC3, 0x0C, 0x30, 0xE3, 0x86, 0x18,
  0x71, 0xC0, 0x3E, 0x7C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x70,
  0xC1, 0x9F, 0x3E, 0x00, 0x0C, 0x1C, 0x1E, 0x36, 0x76, 0x67, 0xC3, 0xFF,
  0xFF, 0xFF, 0xCE, 0x70, 0x3B, 0x7F, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0xFE,
  0xF6, 0x38, 0x18, 0x0C, 0x06, 0xE3, 0xFB, 0x9D, 0xCE, 0xC7, 0x63, 0x31,
  0x9F, 0xDF, 0xC0, 0x3E, 0x7F, 0xE7, 0xE0, 0xC0, 0xC1, 0xC6, 0xFE, 0x7C,
  0x03, 0x81, 0xC0, 0xC7, 0x67, 0xF7, 0x3B, 0x9D, 0x8E, 0xC6, 0x63, 0x3F,
  0x9E, 0xC0, 0x3E, 0x7F, 0xE7, 0xC3, 0xFF, 0xC0, 0xC0, 0xFE, 0x7C, 0x01,
  0xE0, 0x7C, 0x1C, 0x03, 0x03, 0xFC, 0x7F, 0x83, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC1, 0xF0, 0x3C, 0x00, 0x3B, 0x7F, 0xE7, 0xE7,
  0xC7, 0xC6, 0xFE, 0xF6, 0x26, 0x0E, 0xFC, 0xF8, 0x38, 0x18, 0x0C, 0x06,
  0xE3, 0xFB, 0x9D, 0xCE, 0xC7, 0x63, 0x31, 0x98, 0xDC, 0xE0, 0x02, 0x03,
  0x81, 0x80, 0x03, 0xE1, 0xF0, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x0F, 0xFF,
  0xF0, 0x01, 0x01, 0xC0, 0xC0, 0x03, 0xF1, 0xF8, 0x0C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x73, 0xF1, 0xF0, 0x38, 0x0C, 0x03, 0x00, 0xC7,
  0x33, 0x9C, 0xC7, 0x71, 0xF8, 0x7E, 0x19, 0xC6, 0x73, 0x8E, 0x7C, 0xF8,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x3F, 0x1E, 0x6D, 0xBF,
  0xDB, 0x6D, 0xB6, 0xDB, 0x4F, 0x27, 0x96, 0xDB, 0x00, 0x37, 0x1F, 0xDC,
  0xEE, 0x76, 0x3B, 0x19, 0x8C, 0xC6, 0xE7, 0x00, 0x3E, 0x7F, 0xE7, 0xE7,
  0xC7, 0xC6, 0xC6, 0xFE, 0x7C, 0x37, 0x1F, 0xDC, 0xEE, 0x76, 0x3B, 0x19,
  0x8C, 0xFE, 0xFE, 0x70, 0x38, 0x18, 0x00, 0x3B, 0x7F, 0xE7, 0xE7, 0xC7,
  0xC6, 0xC6, 0xFE, 0xF6, 0x0E, 0x0E, 0x0C, 0x6E, 0x3F, 0x98, 0xDC, 0x6E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0x1F, 0xDC, 0x6E, 0x03, 0xF0,
  0x1F, 0x8C, 0xFE, 0x7E, 0x00, 0x18, 0x18, 0xFF, 0xFF, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x3E, 0x3E, 0x63, 0x63, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0xFE,
  0x7C, 0xE3, 0xF1, 0x99, 0xCC, 0xC6, 0xE3, 0x61, 0xB0, 0xF0, 0x38, 0x00,
  0xC9, 0xEC, 0xF6, 0x5B, 0x6E, 0xB7, 0x5B, 0xB9, 0xDC, 0xCE, 0x00, 0x71,
  0xCE, 0xE3, 0xF0, 0x78, 0x1C, 0x07, 0x83, 0x61, 0xDC, 0xE3, 0x00, 0x63,
  0xE3, 0xE7, 0xC7, 0xC6, 0xC6, 0xFE, 0xF6, 0x0E, 0x0E, 0xFC, 0xF8, 0x3F,
  0x9F, 0xC0, 0xC1, 0xC1, 0xC1, 0xC1, 0xC0, 0xFE, 0xFF, 0x00, 0x07, 0x87,
  0xC3, 0x81, 0x80, 0xC0, 0x61, 0xF1, 0xF0, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0xC0, 0xF0, 0x30, 0x33, 0x37, 0x76, 0x66, 0x6E, 0xEE, 0xCC, 0xC0, 0x3C,
  0x1E, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x3E, 0x1F, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x87, 0x83, 0x80, 0x70, 0xFB, 0xDB, 0xCF,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 7, 5, 10, 2, -12 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 10, 16, 10, 0, -14 },
  { 47, 12, 12, 10, -1, -12 },
  { 65, 9, 12, 10, 0, -12 },
  { 79, 3, 5, 10, 4, -12 },
  { 81, 7, 16, 10, 2, -14 },
  { 95, 7, 16, 10, 1, -14 },
  { 109, 8, 9, 10, 1, -10 },
  { 118, 8, 8, 10, 1, -9 },
  { 126, 5, 5, 10, 1, -2 },
  { 130, 6, 2, 10, 2, -6 },
  { 132, 3, 3, 10, 3, -3 },
  { 134, 10, 15, 10, 0, -13 },
  { 153, 8, 12, 10, 1, -12 },
  { 165, 8, 12, 10, 1, -12 },
  { 177, 9, 12, 10, 0, -12 },
  { 191, 9, 12, 10, 0, -12 },
  { 205, 8, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 1, -12 },
  { 229, 9, 12, 10, 0, -12 },
  { 243, 9, 12, 10, 1, -12 },
  { 257, 9, 12, 10, 0, -12 },
  { 271, 9, 12, 10, 1, -12 },
  { 285, 4, 9, 10, 3, -9 },
  { 290, 6, 12, 10, 1, -9 },
  { 299, 8, 9, 10, 1, -10 },
  { 308, 8, 6, 10, 1, -8 },
  { 314, 8, 9, 10, 1, -10 },
  { 323, 7, 12, 10, 2, -12 },
  { 334, 10, 15, 10, 0, -12 },
  { 353, 9, 12, 10, 0, -12 },
  { 367, 10, 12, 10, 0, -12 },
  { 382, 9, 12, 10, 1, -12 },
  { 396, 10, 12, 10, 0, -12 },
  { 411, 9, 12, 10, 1, -12 },
  { 425, 10, 12, 10, 0, -12 },
  { 440, 9, 12, 10, 1, -12 },
  { 454, 10, 12, 10, 0, -12 },
  { 469, 8, 12, 10, 1, -12 },
  { 481, 9, 12, 10, 0, -12 },
  { 495, 10, 12, 10, 0, -12 },
  { 510, 7, 12, 10, 1, -12 },
  { 521, 10, 12, 10, 0, -12 },
  { 536, 10, 12, 10, 0, -12 },
  { 551, 8, 12, 10, 1, -12 },
  { 563, 10, 12, 10, 0, -12 },
  { 578, 8, 15, 10, 1, -12 },
  { 593, 10, 12, 10, 0, -12 },
  { 608, 10, 12, 10, 0, -12 },
  { 623, 9, 12, 10, 1, -12 },
  { 637, 9, 12, 10, 1, -12 },
  { 651, 8, 12, 10, 2, -12 },
  { 663, 10, 12, 10, 1, -12 },
  { 678, 10, 12, 10, 0, -12 },
  { 693, 10, 12, 10, 1, -12 },
  { 708, 8, 12, 10, 1, -12 },
  { 720, 7, 15, 10, 2, -13 },
  { 734, 6, 15, 10, 2, -13 },
  { 746, 7, 15, 10, 1, -13 },
  { 760, 8, 7, 10, 1, -12 },
  { 767, 8, 3, 10, 0, 0 },
  { 770, 4, 3, 10, 4, -13 },
  { 772, 8, 9, 10, 1, -9 },
  { 781, 9, 12, 10, 0, -12 },
  { 795, 8, 9, 10, 1, -9 },
  { 804, 9, 12, 10, 1, -12 },
  { 818, 8, 9, 10, 1, -9 },
  { 827, 11, 15, 10, -1, -12 },
  { 848, 8, 12, 10, 1, -9 },
  { 860, 9, 12, 10, 0, -12 },
  { 874, 9, 13, 10, 0, -13 },
  { 889, 9, 16, 10, 0, -13 },
  { 907, 10, 12, 10, 0, -12 },
  { 922, 8, 12, 10, 1, -12 },
  { 934, 9, 9, 10, 0, -9 },
  { 945, 9, 9, 10, 0, -9 },
  { 956, 8, 9, 10, 1, -9 },
  { 965, 9, 12, 10, 0, -9 },
  { 979, 8, 12, 10, 1, -9 },
  { 991, 9, 9, 10, 1, -9 },
  { 1002, 9, 9, 10, 0, -9 },
  { 1013, 8, 11, 10, 1, -11 },
  { 1024, 8, 9, 10, 1, -9 },
  { 1033, 9, 9, 10, 1, -9 },
  { 1044, 9, 9, 10, 1, -9 },
  { 1055, 10, 9, 10, 0, -9 },
  { 1067, 8, 12, 10, 1, -9 },
  { 1079, 9, 9, 10, 0, -9 },
  { 1090, 9, 15, 10, 1, -13 },
  { 1107, 4, 15, 10, 3, -13 },
  { 1115, 9, 15, 10, 0, -13 },
  { 1132, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC16PT7B_H_
