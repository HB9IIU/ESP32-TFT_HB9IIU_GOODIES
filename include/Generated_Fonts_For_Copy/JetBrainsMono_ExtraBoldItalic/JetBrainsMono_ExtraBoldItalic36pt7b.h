#ifndef _JETBRAINSMONO_EXTRABOLDITALIC36PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x7E, 0x3E,
  0xFC, 0x7D, 0xF1, 0xFB, 0xE3, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x47, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x07, 0x83, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0x83, 0x80, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xBF, 0x1F,
  0x3B, 0xF1, 0xF3, 0x1F, 0x3F, 0x30, 0x03, 0xF3, 0x00, 0x3F, 0xB0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x7F, 0xC0, 0x0E, 0xFE, 0x00, 0xE7, 0xE0, 0x0C, 0x7E, 0xFC, 0xC7,
  0xCF, 0xCC, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0xF0, 0x1F,
  0xF8, 0x3C, 0x07, 0x8F, 0x07, 0x00, 0xF1, 0xE1, 0xE0, 0x1E, 0x3C, 0x78,
  0x03, 0x87, 0x9E, 0x00, 0x70, 0xE7, 0x80, 0x0F, 0xFD, 0xE0, 0x01, 0xFF,
  0x78, 0x00, 0x1F, 0xDE, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0xF7,
  0xFC, 0x00, 0x3D, 0xE3, 0xC0, 0x0F, 0x3C, 0x78, 0x01, 0xC7, 0x0F, 0x00,
  0x78, 0xE1, 0xE0, 0x1E, 0x1C, 0x38, 0x07, 0x83, 0x8F, 0x01, 0xE0, 0x7F,
  0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF1, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE3, 0xE7,
  0xDF, 0x3E, 0x7C, 0xFD, 0xF3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF0, 0xF8, 0x7F,
  0x87, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xF8, 0xF8, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF,
  0x9F, 0x3E, 0x78, 0xF3, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x20, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x04, 0x0F,
  0x02, 0xE1, 0xE3, 0x9F, 0x39, 0xFF, 0xF7, 0x7F, 0xFF, 0x7F, 0xEF, 0xFF,
  0xF0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0x8F,
  0x83, 0xF1, 0xF0, 0x7C, 0x3F, 0x07, 0x03, 0x80, 0x60, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x3C, 0x7E, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xE6, 0x3E, 0x3E, 0xF3, 0xE3, 0xEF,
  0xBE, 0x3E, 0xFB, 0xE7, 0xCF, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F, 0x87,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1,
  0xF3, 0xE0, 0x70, 0xF8, 0x18, 0x3E, 0x08, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F,
  0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xE1, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x3F, 0x87, 0xC7, 0xF0, 0x7C, 0x7E, 0x07, 0xC7,
  0xC0, 0x7C, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF3, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xF3, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0xFC, 0x0F, 0xBF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC3, 0xFB, 0xF0, 0x3F, 0x7C, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0xFC, 0xFC, 0x3F,
  0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xBF, 0x03, 0xF7, 0xC0, 0xFC, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x3E, 0x1F, 0x87, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF,
  0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFE, 0x1F, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E, 0x07,
  0xEF, 0xE3, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1E, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x87, 0xE3, 0xFC, 0xFE, 0x3F, 0x87, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE1, 0xF0, 0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x90, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0xFE,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x1E, 0x07, 0x9E, 0x1E, 0x1F, 0xDE, 0x1E, 0x1F, 0xDE, 0x1E, 0x3E, 0x7E,
  0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C,
  0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x7C, 0x78, 0x78, 0x7C, 0xF8, 0x78,
  0x7C, 0xF8, 0xF8, 0x78, 0x7F, 0xF8, 0x78, 0x7F, 0x78, 0x78, 0x3E, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F,
  0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x7F, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC,
  0x7E, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0x81, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8,
  0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0,
  0xF8, 0x1F, 0x87, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE3, 0xFE,
  0x3E, 0x3F, 0xE7, 0xE3, 0xFE, 0x7E, 0x7F, 0xE7, 0xC0, 0x7E, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x81, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x81,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8,
  0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0,
  0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7F, 0x9F, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x3E,
  0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x1F,
  0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xF0, 0xFF, 0x0F, 0xE1, 0xEE, 0x3F, 0xC3, 0xDC, 0x77, 0x87, 0xB9, 0xFF,
  0x0F, 0x73, 0xBC, 0x1E, 0xE7, 0x78, 0x3D, 0xDE, 0xF0, 0xFB, 0xBB, 0xE1,
  0xF7, 0xF7, 0xC3, 0xEF, 0xCF, 0x87, 0xCF, 0x9F, 0x0F, 0x9E, 0x7C, 0x1E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0xFE, 0x07,
  0xC7, 0xF0, 0x3E, 0x3F, 0xC1, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F,
  0x87, 0xC7, 0xFC, 0x3E, 0x3E, 0xF1, 0xF1, 0xF7, 0x8F, 0x0F, 0xBC, 0x78,
  0x7D, 0xE7, 0xC3, 0xCF, 0x3E, 0x1E, 0x79, 0xF1, 0xF1, 0xEF, 0x8F, 0x8F,
  0x7C, 0x7C, 0x7B, 0xC3, 0xE3, 0xDE, 0x1F, 0x1E, 0xF0, 0xF0, 0xFF, 0x8F,
  0x83, 0xFC, 0x7C, 0x1F, 0xE3, 0xE0, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x3F,
  0x87, 0x80, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F,
  0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7F,
  0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF9,
  0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x3F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x0F, 0xC7, 0xC0, 0xF8, 0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0xFF, 0x0F, 0x81, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7E, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E,
  0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x1F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC,
  0xFF, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0,
  0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C,
  0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3C, 0x3C, 0x3E, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE3, 0xE3, 0xE3, 0xC6, 0xC7, 0xC7, 0x8D,
  0x8F, 0x1F, 0x3F, 0x1E, 0x3E, 0x7E, 0x3C, 0x7C, 0xFC, 0xF8, 0xF1, 0xB9,
  0xE1, 0xE7, 0x73, 0xC3, 0xCE, 0xE7, 0x87, 0x9D, 0xDF, 0x0F, 0x33, 0xBC,
  0x1E, 0xE7, 0x78, 0x3D, 0xCE, 0xF0, 0x7B, 0x1D, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x6F, 0x03, 0xF8, 0xDE, 0x07, 0x61, 0xB8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xF8, 0x01,
  0xF1, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xCF, 0xC0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x7E,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFB, 0xE0, 0x1F, 0x9F, 0x01,
  0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07,
  0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x1F, 0x1E, 0x1F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xEF, 0x80, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x03, 0xF3, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0xC7, 0xF3, 0xF8, 0x7F, 0xFF, 0x87, 0xFE, 0xF8, 0x3F, 0xEF, 0x81,
  0xF9, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0xFB, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0xCF,
  0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E,
  0x07, 0xE7, 0xE0, 0xFD, 0xFE, 0x7F, 0x3F, 0xFF, 0xE7, 0xDF, 0xF8, 0xFB,
  0xFE, 0x1F, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x9F, 0x03, 0xF3, 0xF9, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0xFF,
  0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x0F, 0xC3,
  0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x3F,
  0x9F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFD, 0xF0, 0x3F, 0xEF, 0x80, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8,
  0x7E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x13, 0xF0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7,
  0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xE1, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xEF, 0x83, 0xFC, 0xF8, 0x0F, 0x8F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0xFB,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7C, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0xC0,
  0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xFD, 0xF8, 0x1F, 0x3F, 0x03,
  0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x07,
  0xE3, 0xE0, 0x7E, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E,
  0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xC3,
  0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7,
  0xC0, 0x7E, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1E,
  0x78, 0xF0, 0xF7, 0xDF, 0xC7, 0xFE, 0xFE, 0x3F, 0xFF, 0xF3, 0xE3, 0xCF,
  0x9F, 0x1C, 0x7C, 0xF8, 0xE3, 0xE7, 0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x9F, 0x1E, 0x7C, 0xF8, 0xE3, 0xE7, 0xC7, 0x1F, 0x3E, 0x78, 0xF9,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF8, 0xF3, 0xE7, 0xC7, 0x1F, 0x3E, 0x38,
  0xF9, 0xF3, 0xC7, 0xC0, 0x1F, 0x1F, 0x03, 0xEF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3F, 0x3E,
  0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0xF8,
  0x1F, 0x9F, 0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xE0,
  0x3E, 0x7C, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7E, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x1F, 0x9F, 0x03, 0xF3, 0xF9, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0xFB, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F,
  0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xE7, 0xF9, 0xFC, 0x7F, 0xFF, 0xC7, 0xDF,
  0xF8, 0x7D, 0xFF, 0x07, 0xCF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x7F, 0xBF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x7E,
  0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xF3,
  0xF8, 0x7F, 0xFF, 0x87, 0xFE, 0xF8, 0x3F, 0xEF, 0x81, 0xF9, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x1F, 0x9F, 0x81, 0xF3, 0xFE, 0x1F, 0x7F, 0xE1, 0xFF, 0xFF,
  0x1F, 0xCF, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3F,
  0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3,
  0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x0F, 0x87, 0xF3, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F, 0x1F, 0x07,
  0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3F, 0x7E,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0xF0, 0xFF, 0x87,
  0x87, 0xBC, 0x3C, 0x3D, 0xE3, 0xE1, 0xEF, 0x1F, 0x1E, 0x78, 0xD8, 0xF3,
  0xCE, 0xC7, 0x9E, 0x76, 0x7C, 0xF3, 0x33, 0xC7, 0x99, 0x9E, 0x3D, 0xCC,
  0xF1, 0xEE, 0x6F, 0x0F, 0x67, 0x78, 0x7F, 0x3B, 0xC3, 0xF9, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0x0F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x1F,
  0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xE0, 0x1F,
  0x87, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xF0, 0x1F, 0x80, 0x1F,
  0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3,
  0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C,
  0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x81, 0xFC, 0xF8, 0x04, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x20, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x1F, 0x78,
  0xF9, 0xF7, 0x8F, 0xFE, 0xF8, 0x7F, 0xEF, 0x83, 0xFC, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 26, 22, 6, -26 },
  { 34, 15, 11, 22, 5, -26 },
  { 55, 23, 26, 22, 0, -26 },
  { 130, 20, 36, 22, 1, -31 },
  { 220, 27, 26, 22, -2, -26 },
  { 308, 21, 27, 22, 0, -27 },
  { 379, 7, 11, 22, 9, -26 },
  { 389, 16, 35, 22, 5, -30 },
  { 459, 16, 35, 22, 2, -30 },
  { 529, 19, 19, 22, 2, -22 },
  { 575, 18, 18, 22, 2, -21 },
  { 616, 11, 11, 22, 3, -5 },
  { 632, 14, 5, 22, 4, -14 },
  { 641, 8, 7, 22, 6, -7 },
  { 648, 23, 34, 22, 0, -30 },
  { 746, 20, 27, 22, 1, -27 },
  { 814, 18, 26, 22, 1, -26 },
  { 873, 20, 27, 22, 1, -27 },
  { 941, 20, 26, 22, 1, -26 },
  { 1006, 20, 26, 22, 1, -26 },
  { 1071, 20, 26, 22, 1, -26 },
  { 1136, 19, 26, 22, 1, -26 },
  { 1198, 19, 26, 22, 3, -26 },
  { 1260, 20, 27, 22, 1, -27 },
  { 1328, 19, 27, 22, 3, -27 },
  { 1393, 10, 20, 22, 6, -20 },
  { 1418, 13, 26, 22, 3, -20 },
  { 1461, 19, 20, 22, 2, -22 },
  { 1509, 18, 14, 22, 2, -19 },
  { 1541, 19, 20, 22, 1, -22 },
  { 1589, 16, 26, 22, 4, -26 },
  { 1641, 24, 33, 22, -1, -27 },
  { 1740, 20, 26, 22, -1, -26 },
  { 1805, 21, 26, 22, 1, -26 },
  { 1874, 20, 27, 22, 1, -27 },
  { 1942, 21, 26, 22, 1, -26 },
  { 2011, 21, 26, 22, 1, -26 },
  { 2080, 21, 26, 22, 1, -26 },
  { 2149, 20, 27, 22, 1, -27 },
  { 2217, 21, 26, 22, 1, -26 },
  { 2286, 20, 26, 22, 1, -26 },
  { 2351, 21, 26, 22, 0, -26 },
  { 2420, 22, 26, 22, 1, -26 },
  { 2492, 17, 26, 22, 2, -26 },
  { 2548, 23, 26, 22, 0, -26 },
  { 2623, 21, 26, 22, 1, -26 },
  { 2692, 20, 27, 22, 1, -27 },
  { 2760, 21, 26, 22, 1, -26 },
  { 2829, 20, 33, 22, 1, -27 },
  { 2912, 21, 26, 22, 1, -26 },
  { 2981, 20, 27, 22, 1, -27 },
  { 3049, 20, 26, 22, 3, -26 },
  { 3114, 21, 26, 22, 1, -26 },
  { 3183, 20, 26, 22, 3, -26 },
  { 3248, 23, 26, 22, 1, -26 },
  { 3323, 24, 26, 22, -1, -26 },
  { 3401, 21, 26, 22, 3, -26 },
  { 3470, 20, 26, 22, 1, -26 },
  { 3535, 16, 34, 22, 4, -30 },
  { 3603, 13, 34, 22, 5, -30 },
  { 3659, 17, 34, 22, 2, -30 },
  { 3732, 17, 14, 22, 3, -26 },
  { 3762, 18, 5, 22, 0, 1 },
  { 3774, 9, 5, 22, 8, -28 },
  { 3780, 20, 20, 22, 1, -20 },
  { 3830, 19, 26, 22, 1, -26 },
  { 3892, 19, 20, 22, 1, -20 },
  { 3940, 21, 26, 22, 1, -26 },
  { 4009, 19, 20, 22, 1, -20 },
  { 4057, 24, 32, 22, -2, -26 },
  { 4153, 20, 26, 22, 1, -20 },
  { 4218, 19, 26, 22, 1, -26 },
  { 4280, 18, 29, 22, 1, -29 },
  { 4346, 20, 35, 22, 0, -29 },
  { 4434, 21, 26, 22, 1, -26 },
  { 4503, 17, 26, 22, 3, -26 },
  { 4559, 21, 20, 22, 0, -20 },
  { 4612, 19, 20, 22, 1, -20 },
  { 4660, 19, 20, 22, 1, -20 },
  { 4708, 20, 26, 22, 0, -20 },
  { 4773, 20, 26, 22, 1, -20 },
  { 4838, 20, 20, 22, 1, -20 },
  { 4888, 20, 20, 22, 1, -20 },
  { 4938, 19, 25, 22, 2, -25 },
  { 4998, 20, 20, 22, 1, -20 },
  { 5048, 19, 20, 22, 3, -20 },
  { 5096, 21, 20, 22, 2, -20 },
  { 5149, 23, 20, 22, -1, -20 },
  { 5207, 20, 26, 22, 1, -20 },
  { 5272, 19, 20, 22, 1, -20 },
  { 5320, 19, 34, 22, 3, -30 },
  { 5401, 11, 34, 22, 6, -30 },
  { 5448, 20, 34, 22, 0, -30 },
  { 5533, 20, 9, 22, 1, -17 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC36PT7B_H_
