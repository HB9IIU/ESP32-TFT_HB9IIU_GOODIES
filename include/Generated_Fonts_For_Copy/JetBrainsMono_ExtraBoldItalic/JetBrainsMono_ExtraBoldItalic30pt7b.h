#ifndef _JETBRAINSMONO_EXTRABOLDITALIC30PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x8F,
  0xC3, 0xC0, 0x7C, 0xFB, 0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xE3, 0xCE, 0x3C, 0xF1, 0xE0, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x78, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3E, 0xCF, 0x9F, 0x67, 0xCF, 0x30, 0x07, 0xD8, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x6F, 0x80, 0x33, 0xCF, 0xB1, 0xE7, 0xD9, 0xF3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x1E, 0x0F, 0xE0, 0x70, 0x3D, 0xE1, 0xE0, 0x71,
  0xC7, 0x80, 0xE3, 0x8E, 0x01, 0xC7, 0x38, 0x07, 0x1C, 0xE0, 0x07, 0xFB,
  0x80, 0x0F, 0xEE, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x1D, 0xFC, 0x00, 0x77, 0xF8, 0x01, 0xDC, 0x70,
  0x07, 0x38, 0xE0, 0x1C, 0x71, 0xC0, 0x70, 0xE3, 0x81, 0xE1, 0xEF, 0x03,
  0x83, 0xFC, 0x1E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x1F, 0x7D, 0xE7, 0x9E,
  0x7F, 0xC7, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x07, 0xCF,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xE3, 0xC0, 0x7B, 0xDF, 0xFF, 0xFB,
  0xDE, 0xF0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xC0, 0x08,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x04, 0x3C, 0x23, 0x9C,
  0x73, 0xE6, 0xFB, 0xFA, 0xFE, 0x7F, 0xFC, 0x01, 0xC0, 0x03, 0xF0, 0x03,
  0xBC, 0x03, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xE0, 0x60, 0xC0, 0x10, 0x40,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0,
  0x78, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x39, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0xE7, 0x9F, 0xF7, 0xCF, 0x7B, 0xE7, 0x9D,
  0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1E, 0x1F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0x9F, 0x0E, 0x3E, 0x10, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE1,
  0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3C, 0xFF, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3D, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xC7, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0xFC,
  0x3D, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x3E, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0x81, 0xF3, 0xC0,
  0xF3, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF1, 0xF0, 0x78,
  0xF0, 0x3C, 0x7C, 0x3E, 0x3F, 0x3E, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0E, 0x3F, 0x3F, 0x3F, 0x3E, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC, 0x78, 0x01,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x08, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF,
  0xC0, 0x10, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x3F,
  0xC0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x01, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xC3, 0xE1,
  0xE0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xC1, 0xCE, 0x38, 0xFD, 0xCF,
  0x1F, 0xF9, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7, 0x9C, 0x3C, 0xE3, 0x87, 0x1C,
  0xF0, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0x9E, 0x79, 0xF3, 0xCF, 0xEE, 0x70,
  0xFB, 0x8E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xBC, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0x07, 0xCF, 0x03, 0xEF,
  0x81, 0xF7, 0xC0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x3E, 0x3C,
  0x3E, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x87, 0xC7, 0xE3, 0xC0, 0xF1,
  0xE0, 0x7C, 0xF0, 0x3E, 0x78, 0x1E, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE3, 0xE1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x1F, 0x3C, 0x0F, 0x1E,
  0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x78,
  0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x3F,
  0xCF, 0x9F, 0xE7, 0x8F, 0xF3, 0xC7, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x78, 0xF8, 0x3C, 0x78, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E,
  0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE3, 0xE0, 0x78, 0xF8, 0x1E,
  0x3E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x8F, 0x83, 0xE3, 0xC0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE1, 0xE0,
  0xF8, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF0, 0x3E, 0x3C,
  0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0x03, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF8, 0xDC, 0x3F, 0x3F, 0x8F, 0x67, 0xF1, 0xED, 0xDE,
  0x3D, 0xBB, 0xC7, 0xBE, 0x70, 0xF7, 0xDE, 0x1E, 0xFB, 0xC7, 0x9E, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x00, 0x0F, 0x83,
  0xC3, 0xE0, 0xF0, 0xFC, 0x3C, 0x7F, 0x0F, 0x1F, 0xC3, 0xC7, 0xF0, 0xF1,
  0xFC, 0x78, 0x7F, 0x1E, 0x1D, 0xE7, 0x8F, 0x79, 0xE3, 0xCE, 0x78, 0xF3,
  0x9E, 0x3C, 0xE7, 0x0F, 0x3F, 0xC3, 0xCF, 0xF1, 0xE1, 0xFC, 0x78, 0x7F,
  0x1E, 0x1F, 0xC7, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x3E, 0x0F, 0x80,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xE1, 0xF9, 0xF0, 0x7C,
  0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF,
  0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF1, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xE1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x78,
  0x1F, 0x3C, 0x0F, 0x1E, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x81, 0xE3, 0xC0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3C, 0xF8, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78,
  0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x78, 0xF1, 0xEF,
  0x1E, 0x3D, 0xE3, 0xC7, 0x3C, 0xF9, 0xE7, 0x9B, 0x3C, 0xF3, 0xE7, 0x1E,
  0x7C, 0xE3, 0x9F, 0xBC, 0x73, 0x67, 0x8E, 0x6C, 0xE1, 0xCD, 0x9C, 0x3B,
  0xB3, 0x87, 0x66, 0xF0, 0xEC, 0xDC, 0x3F, 0x9B, 0x87, 0xE3, 0x70, 0xFC,
  0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C,
  0x03, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x0F, 0xBE, 0x01, 0xF1, 0xE0, 0x1F,
  0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF0, 0x0F, 0xFC,
  0x0F, 0xBE, 0x07, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0,
  0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xF8, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0,
  0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xF7, 0x81, 0xEF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0xF7, 0xC1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0xF1, 0xF1, 0xF1, 0xE0,
  0x03, 0x8F, 0x0F, 0xEF, 0x1F, 0xEF, 0x3F, 0xFF, 0x3E, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xBC, 0x3F, 0x7C, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x78, 0x3E, 0xFC,
  0x3D, 0xFE, 0x3F, 0xFE, 0x3E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xFF, 0xFC,
  0xF7, 0xF8, 0xF7, 0xF8, 0xF3, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3E, 0x3F, 0x7C, 0x1F, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x1C, 0x78, 0x3F, 0xBC, 0x3F, 0xDE, 0x3F, 0xFF, 0x1F,
  0x1F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFB,
  0xC1, 0xFB, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3C,
  0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x3C, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0x8F, 0x0F, 0xEF, 0x1F, 0xEF, 0x3F, 0xFF, 0x3E, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xFC, 0x7E,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xBC, 0x1F, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x78, 0x3E, 0xFC, 0x3D, 0xFE,
  0x3F, 0xFE, 0x3E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E,
  0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF0, 0x7C, 0xF0, 0x7C, 0x00, 0x30, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x0F,
  0x0F, 0x83, 0xC7, 0xC1, 0xF3, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x80, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x1C, 0xC7, 0x0F, 0x7B,
  0xE3, 0xFE, 0xF8, 0xFB, 0xDF, 0x3C, 0xE3, 0x8F, 0x39, 0xE3, 0x8E, 0x79,
  0xE3, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xE7, 0x9C, 0x79, 0xE7, 0x3C, 0x79,
  0xCF, 0x3C, 0x73, 0xCF, 0x1C, 0xF3, 0xCE, 0x3C, 0xF3, 0x8F, 0x00, 0x3E,
  0x78, 0x3C, 0xFC, 0x3D, 0xFE, 0x3F, 0xFE, 0x3E, 0x3F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0x01, 0xF0, 0x07,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0x3C, 0x0F, 0x3F, 0x07,
  0xBF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE7, 0xC1, 0xE3, 0xFF,
  0xF1, 0xEF, 0xF0, 0xF7, 0xF8, 0x79, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x03, 0x8F, 0x0F, 0xEF, 0x1F, 0xEF,
  0x3F, 0xFF, 0x3E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xBC,
  0x7F, 0xBC, 0x3F, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x1E, 0x38, 0x0F, 0x7F, 0x0F, 0xFF, 0xC7, 0xBF, 0xE3, 0xF1,
  0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x3E, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3C,
  0x1F, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x1E, 0xF0, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x3E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x3C, 0xF0, 0x3D,
  0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x70, 0xE3, 0xDC, 0x78, 0xF7, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0xE7,
  0x9C, 0xD9, 0xCF, 0x36, 0x73, 0xCD, 0xBC, 0xF6, 0x6F, 0x3D, 0x9B, 0x8F,
  0x67, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xE3,
  0xE0, 0xF8, 0xF8, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x03,
  0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3E,
  0x7C, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78,
  0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xFC, 0x7C, 0x7F, 0xFC, 0x7F,
  0xBC, 0x3F, 0x3C, 0x1E, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83,
  0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x1F, 0x87, 0xBF, 0xC3, 0x9F, 0xF1, 0xCE, 0x7D, 0xEF,
  0x1F, 0xF7, 0x8F, 0xF0, 0x03, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 22, 18, 5, -22 },
  { 26, 13, 9, 18, 4, -22 },
  { 41, 19, 22, 18, 0, -22 },
  { 94, 17, 30, 18, 1, -26 },
  { 158, 23, 22, 18, -2, -22 },
  { 222, 18, 22, 18, 0, -22 },
  { 272, 5, 9, 18, 8, -22 },
  { 278, 13, 29, 18, 4, -25 },
  { 326, 13, 29, 18, 2, -25 },
  { 374, 17, 16, 18, 1, -18 },
  { 408, 15, 14, 18, 2, -17 },
  { 435, 9, 10, 18, 2, -5 },
  { 447, 11, 4, 18, 4, -12 },
  { 453, 6, 6, 18, 5, -6 },
  { 458, 19, 28, 18, 0, -25 },
  { 525, 17, 22, 18, 1, -22 },
  { 572, 15, 22, 18, 1, -22 },
  { 614, 17, 22, 18, 1, -22 },
  { 661, 16, 22, 18, 1, -22 },
  { 705, 16, 22, 18, 1, -22 },
  { 749, 17, 22, 18, 1, -22 },
  { 796, 16, 22, 18, 1, -22 },
  { 840, 17, 22, 18, 2, -22 },
  { 887, 17, 22, 18, 1, -22 },
  { 934, 16, 22, 18, 2, -22 },
  { 978, 8, 17, 18, 5, -17 },
  { 995, 11, 22, 18, 2, -17 },
  { 1026, 15, 17, 18, 2, -18 },
  { 1058, 15, 12, 18, 2, -16 },
  { 1081, 16, 17, 18, 1, -18 },
  { 1115, 14, 22, 18, 3, -22 },
  { 1154, 19, 27, 18, 0, -22 },
  { 1219, 17, 22, 18, -1, -22 },
  { 1266, 17, 22, 18, 1, -22 },
  { 1313, 17, 22, 18, 1, -22 },
  { 1360, 17, 22, 18, 1, -22 },
  { 1407, 17, 22, 18, 1, -22 },
  { 1454, 17, 22, 18, 1, -22 },
  { 1501, 17, 22, 18, 1, -22 },
  { 1548, 17, 22, 18, 1, -22 },
  { 1595, 17, 22, 18, 1, -22 },
  { 1642, 18, 22, 18, 0, -22 },
  { 1692, 18, 22, 18, 1, -22 },
  { 1742, 14, 22, 18, 2, -22 },
  { 1781, 19, 22, 18, 0, -22 },
  { 1834, 18, 22, 18, 0, -22 },
  { 1884, 17, 22, 18, 1, -22 },
  { 1931, 17, 22, 18, 1, -22 },
  { 1978, 17, 27, 18, 1, -22 },
  { 2036, 17, 22, 18, 1, -22 },
  { 2083, 17, 22, 18, 1, -22 },
  { 2130, 16, 22, 18, 3, -22 },
  { 2174, 17, 22, 18, 1, -22 },
  { 2221, 16, 22, 18, 3, -22 },
  { 2265, 19, 22, 18, 1, -22 },
  { 2318, 20, 22, 18, -1, -22 },
  { 2373, 17, 22, 18, 3, -22 },
  { 2420, 17, 22, 18, 1, -22 },
  { 2467, 14, 28, 18, 3, -25 },
  { 2516, 11, 28, 18, 4, -25 },
  { 2555, 14, 28, 18, 2, -25 },
  { 2604, 15, 12, 18, 2, -22 },
  { 2627, 15, 4, 18, 0, 1 },
  { 2635, 7, 5, 18, 7, -24 },
  { 2640, 16, 17, 18, 1, -17 },
  { 2674, 16, 22, 18, 1, -22 },
  { 2718, 16, 17, 18, 1, -17 },
  { 2752, 17, 22, 18, 1, -22 },
  { 2799, 16, 17, 18, 1, -17 },
  { 2833, 21, 27, 18, -2, -22 },
  { 2904, 16, 22, 18, 1, -17 },
  { 2948, 16, 22, 18, 1, -22 },
  { 2992, 15, 24, 18, 1, -24 },
  { 3037, 17, 29, 18, 0, -24 },
  { 3099, 18, 22, 18, 1, -22 },
  { 3149, 14, 22, 18, 2, -22 },
  { 3188, 18, 17, 18, 0, -17 },
  { 3227, 16, 17, 18, 1, -17 },
  { 3261, 16, 17, 18, 1, -17 },
  { 3295, 17, 22, 18, 0, -17 },
  { 3342, 16, 22, 18, 1, -17 },
  { 3386, 17, 17, 18, 1, -17 },
  { 3423, 16, 17, 18, 1, -17 },
  { 3457, 15, 21, 18, 2, -21 },
  { 3497, 16, 17, 18, 1, -17 },
  { 3531, 16, 17, 18, 2, -17 },
  { 3565, 18, 17, 18, 1, -17 },
  { 3604, 19, 17, 18, -1, -17 },
  { 3645, 16, 22, 18, 1, -17 },
  { 3689, 16, 17, 18, 1, -17 },
  { 3723, 16, 28, 18, 2, -25 },
  { 3779, 9, 28, 18, 5, -25 },
  { 3811, 16, 28, 18, 0, -25 },
  { 3867, 17, 7, 18, 1, -14 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC30PT7B_H_
