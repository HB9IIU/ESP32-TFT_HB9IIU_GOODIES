#ifndef _JETBRAINSMONO_EXTRABOLDITALIC49PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F,
  0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE2, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF3, 0x8F, 0xF0, 0xFF, 0x38, 0xFF,
  0x0F, 0xE3, 0x8F, 0xF0, 0xFE, 0x38, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0xFF,
  0x78, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xEF,
  0xFC, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0xE3, 0xFC, 0x00, 0x1E, 0x3F, 0xC7,
  0xF1, 0xC3, 0xF8, 0x7F, 0x1C, 0x3F, 0x87, 0xF9, 0xC7, 0xF8, 0x7F, 0xDC,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0x7C,
  0xFC, 0x00, 0x0F, 0xC3, 0xE7, 0xC0, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x01,
  0xFF, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0xE7, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x00,
  0x00, 0x03, 0xE7, 0xFE, 0x00, 0x00, 0x3E, 0xFF, 0xF8, 0x00, 0x03, 0xE7,
  0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x3E, 0x00, 0x03, 0xF3, 0xE1, 0xF0, 0x00,
  0x3F, 0x1E, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x1F, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x0F, 0xE3, 0xF9,
  0xFC, 0x7E, 0x1F, 0xCF, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF,
  0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x01, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xF8, 0x3F, 0x80, 0x3F, 0xBF, 0xDF,
  0xEF, 0xE7, 0xF3, 0xF9, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x03, 0xE0, 0x31, 0xF0, 0x7C,
  0x1E, 0x3F, 0x0F, 0x0F, 0xCF, 0xF9, 0xE7, 0xF9, 0xFF, 0xB9, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0x0E, 0x01, 0xE0, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF3, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0xF8, 0xFE, 0x3F, 0xBF, 0x1F, 0x87, 0xF7, 0xF7, 0xF0, 0xFC, 0xFE, 0xFE,
  0x3F, 0x9F, 0x9F, 0xC7, 0xF1, 0xF3, 0xF8, 0xFE, 0x08, 0x7F, 0x1F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xE7,
  0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0x07, 0xF0, 0x0E, 0x07, 0xF0, 0x18, 0x0F,
  0xF0, 0x10, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0xFF,
  0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF1,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xF0, 0x07, 0xF7, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0x80, 0x3F, 0xDF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC7, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x83,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x03,
  0xFE, 0x7F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFB, 0xF8, 0x0F, 0xFD, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x7E, 0x0F, 0x81, 0xFF, 0x7E,
  0x1F, 0x83, 0xFF, 0x7E, 0x1F, 0x83, 0xFF, 0xFE, 0x1F, 0x87, 0xF1, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC,
  0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8,
  0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xFF, 0xF0, 0x7E, 0x0F, 0xFD, 0xF0, 0x7E, 0x0F, 0xF9, 0xF0,
  0x7E, 0x07, 0xF3, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07,
  0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87,
  0xF0, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0xC7, 0xF0,
  0xFF, 0xF8, 0xFE, 0x1F, 0xFE, 0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0xFF, 0xF8,
  0xFE, 0x1F, 0xFF, 0x1F, 0xC3, 0xFF, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xDE, 0x1E, 0xFC, 0x1F, 0xBC, 0x7F, 0xF0, 0x3F, 0x78, 0xF7,
  0xE0, 0x7E, 0xF3, 0xEF, 0xC0, 0xFD, 0xE7, 0xDF, 0x83, 0xFB, 0xCF, 0x3F,
  0x07, 0xF7, 0xBE, 0xFE, 0x0F, 0xCF, 0xF9, 0xF8, 0x1F, 0x9F, 0xF3, 0xF0,
  0x3F, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x3F, 0x83,
  0xF8, 0xFC, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xC1, 0xFF, 0x00,
  0xFE, 0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8,
  0x3F, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x7F,
  0xF8, 0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0, 0xFD, 0xF0,
  0x7E, 0x0F, 0xEF, 0x87, 0xF0, 0x7E, 0x7C, 0x3F, 0x83, 0xF3, 0xF1, 0xFC,
  0x1F, 0x9F, 0x8F, 0xC0, 0xFC, 0x7C, 0x7E, 0x07, 0xE3, 0xE3, 0xF0, 0x7F,
  0x1F, 0x1F, 0x83, 0xF8, 0xFD, 0xFC, 0x1F, 0xC7, 0xEF, 0xE0, 0xFC, 0x3F,
  0x7E, 0x07, 0xE0, 0xFB, 0xF0, 0x3F, 0x07, 0xDF, 0x83, 0xF8, 0x3E, 0xFC,
  0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF8, 0x3F,
  0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F, 0xE0, 0xFE, 0x03,
  0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0x80, 0x7F, 0xC1, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03,
  0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x0F,
  0xCF, 0xC3, 0xF8, 0x3F, 0x3F, 0x0F, 0xE1, 0xF8, 0xF8, 0x3F, 0x87, 0xE3,
  0xE0, 0xFE, 0x1F, 0x8F, 0x87, 0xF8, 0x7E, 0x7E, 0x1F, 0xE3, 0xF1, 0xF8,
  0x77, 0x8F, 0xC7, 0xE1, 0xDE, 0x3F, 0x1F, 0x8F, 0x70, 0xFC, 0x7E, 0x3D,
  0xC3, 0xE1, 0xF8, 0xE7, 0x1F, 0x87, 0xE7, 0x9C, 0x7E, 0x1F, 0x9E, 0x71,
  0xF8, 0x7E, 0x79, 0xC7, 0xC1, 0xF1, 0xC7, 0x3F, 0x07, 0xCF, 0x3C, 0xFC,
  0x1F, 0x3C, 0xF3, 0xE0, 0x7C, 0xF3, 0xCF, 0x81, 0xF3, 0x8F, 0x7E, 0x07,
  0xDE, 0x3D, 0xF8, 0x3F, 0x78, 0xF7, 0xC0, 0xFD, 0xC3, 0xDF, 0x03, 0xFF,
  0x0F, 0x7C, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFB, 0x83,
  0xFE, 0x03, 0xEE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x07,
  0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE7,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x40, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xF9,
  0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xF1, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x7E, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0xE7, 0xF0, 0x7F, 0xFD, 0xFC, 0x3F,
  0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xF8,
  0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xEF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFC, 0x0F, 0xFE,
  0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xFC, 0x07, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xEF, 0xFF, 0x03,
  0xF9, 0xFF, 0xC0, 0x7F, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC,
  0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x03, 0xFF,
  0x9F, 0xC0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0xDF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF8,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xF9,
  0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFC,
  0x7F, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0xE7, 0xF0, 0x7F, 0xFD, 0xFC, 0x3F, 0xFF,
  0x7F, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0x83,
  0xFF, 0xEF, 0xE0, 0x7F, 0xF7, 0xF8, 0x0F, 0xF1, 0xFC, 0x00, 0x40, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xFC, 0x07, 0xF7,
  0xFF, 0xC0, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC3, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F,
  0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xCF, 0x87, 0xE0, 0x7E, 0xFE, 0x7F, 0x83, 0xFF, 0xF7,
  0xFC, 0x1F, 0x7F, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF1, 0xFC,
  0x7E, 0x1F, 0x0F, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC,
  0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xF8,
  0x7F, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x87, 0xE3, 0xF8, 0x7C, 0x7F, 0x1F, 0xC7, 0xC3, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C,
  0x3F, 0x1F, 0xC3, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x87, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFE, 0x07, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8,
  0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF,
  0xE0, 0x3F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x3F, 0xF8, 0x07, 0xF7, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xBF, 0xFC, 0x07, 0xFB, 0xFF, 0x80, 0x7F, 0x1F, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFD, 0xFC, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8,
  0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFD, 0xFC, 0x0F, 0xFE, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xE3, 0xFE, 0x01, 0xFC, 0xFF, 0xF0, 0x3F,
  0xBF, 0xFE, 0x07, 0xEF, 0xFF, 0xE1, 0xFD, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFC, 0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xC7, 0xF8, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF,
  0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8,
  0x7F, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x81, 0xFB, 0xE0,
  0x7C, 0x0F, 0xDF, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x07, 0xE7, 0xC1, 0xF8,
  0x3F, 0x3E, 0x0F, 0xC1, 0xF3, 0xF0, 0xFE, 0x1F, 0x9F, 0x87, 0x70, 0xFC,
  0xFC, 0x3B, 0x87, 0xC7, 0xE3, 0xDC, 0x7E, 0x3F, 0x1C, 0xE3, 0xF1, 0xF8,
  0xE7, 0x1F, 0x8F, 0xCF, 0x38, 0xF8, 0x7E, 0x79, 0xCF, 0xC3, 0xF3, 0x8E,
  0x7E, 0x1F, 0xBC, 0x73, 0xE0, 0xFD, 0xE3, 0xBF, 0x07, 0xEE, 0x1D, 0xF8,
  0x3F, 0x70, 0xEF, 0x81, 0xFF, 0x87, 0x7C, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F,
  0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0xC0, 0x7F, 0xE7, 0xF0,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x1F,
  0x9F, 0xFF, 0x03, 0xF7, 0xFF, 0xF0, 0xFC, 0xFF, 0xFE, 0x1F, 0x9F, 0x9F,
  0xE3, 0xF7, 0xE1, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x9F, 0x83, 0xFF, 0xF3,
  0xF0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 14, 36, 29, 8, -36 },
  { 64, 21, 15, 29, 7, -36 },
  { 104, 31, 36, 29, 0, -36 },
  { 244, 28, 50, 29, 1, -43 },
  { 419, 37, 36, 29, -3, -36 },
  { 586, 29, 36, 29, 0, -36 },
  { 717, 9, 15, 29, 13, -36 },
  { 734, 22, 47, 29, 6, -41 },
  { 864, 22, 47, 29, 2, -41 },
  { 994, 27, 26, 29, 2, -30 },
  { 1082, 25, 24, 29, 3, -28 },
  { 1157, 16, 15, 29, 3, -7 },
  { 1187, 18, 7, 29, 6, -20 },
  { 1203, 11, 9, 29, 8, -9 },
  { 1216, 32, 46, 29, -1, -41 },
  { 1400, 27, 36, 29, 2, -36 },
  { 1522, 24, 36, 29, 2, -36 },
  { 1630, 28, 36, 29, 1, -36 },
  { 1756, 28, 36, 29, 1, -36 },
  { 1882, 26, 36, 29, 2, -36 },
  { 1999, 27, 36, 29, 2, -36 },
  { 2121, 26, 36, 29, 1, -36 },
  { 2238, 26, 36, 29, 4, -36 },
  { 2355, 28, 36, 29, 1, -36 },
  { 2481, 26, 36, 29, 3, -36 },
  { 2598, 13, 27, 29, 8, -27 },
  { 2642, 17, 35, 29, 4, -27 },
  { 2717, 26, 28, 29, 3, -30 },
  { 2808, 24, 19, 29, 3, -26 },
  { 2865, 25, 28, 29, 2, -30 },
  { 2953, 22, 36, 29, 6, -36 },
  { 3052, 32, 45, 29, -1, -36 },
  { 3232, 27, 36, 29, -1, -36 },
  { 3354, 28, 36, 29, 1, -36 },
  { 3480, 27, 36, 29, 2, -36 },
  { 3602, 28, 36, 29, 1, -36 },
  { 3728, 28, 36, 29, 2, -36 },
  { 3854, 29, 36, 29, 1, -36 },
  { 3985, 27, 36, 29, 2, -36 },
  { 4107, 29, 36, 29, 1, -36 },
  { 4238, 27, 36, 29, 2, -36 },
  { 4360, 29, 37, 29, 0, -36 },
  { 4495, 30, 36, 29, 1, -36 },
  { 4630, 23, 36, 29, 2, -36 },
  { 4734, 31, 36, 29, 0, -36 },
  { 4874, 29, 36, 29, 1, -36 },
  { 5005, 27, 36, 29, 2, -36 },
  { 5127, 29, 36, 29, 1, -36 },
  { 5258, 27, 45, 29, 2, -36 },
  { 5410, 29, 36, 29, 1, -36 },
  { 5541, 28, 36, 29, 1, -36 },
  { 5667, 27, 36, 29, 4, -36 },
  { 5789, 28, 36, 29, 2, -36 },
  { 5915, 27, 36, 29, 5, -36 },
  { 6037, 30, 36, 29, 2, -36 },
  { 6172, 32, 36, 29, -1, -36 },
  { 6316, 28, 36, 29, 4, -36 },
  { 6442, 27, 36, 29, 2, -36 },
  { 6564, 23, 46, 29, 5, -41 },
  { 6697, 17, 46, 29, 7, -41 },
  { 6795, 22, 46, 29, 3, -41 },
  { 6922, 24, 19, 29, 3, -36 },
  { 6979, 24, 7, 29, 0, 1 },
  { 7000, 12, 6, 29, 11, -38 },
  { 7009, 26, 27, 29, 2, -27 },
  { 7097, 27, 36, 29, 1, -36 },
  { 7219, 26, 27, 29, 2, -27 },
  { 7307, 28, 36, 29, 2, -36 },
  { 7433, 25, 27, 29, 2, -27 },
  { 7518, 33, 45, 29, -3, -36 },
  { 7704, 26, 36, 29, 2, -27 },
  { 7821, 27, 36, 29, 1, -36 },
  { 7943, 25, 39, 29, 1, -39 },
  { 8065, 27, 48, 29, 0, -39 },
  { 8227, 29, 36, 29, 1, -36 },
  { 8358, 23, 36, 29, 4, -36 },
  { 8462, 29, 27, 29, 0, -27 },
  { 8560, 27, 27, 29, 1, -27 },
  { 8652, 25, 27, 29, 2, -27 },
  { 8737, 28, 36, 29, 0, -27 },
  { 8863, 26, 36, 29, 2, -27 },
  { 8980, 27, 27, 29, 2, -27 },
  { 9072, 27, 27, 29, 1, -27 },
  { 9164, 25, 34, 29, 3, -34 },
  { 9271, 26, 27, 29, 2, -27 },
  { 9359, 27, 27, 29, 3, -27 },
  { 9451, 29, 27, 29, 2, -27 },
  { 9549, 31, 27, 29, -1, -27 },
  { 9654, 26, 36, 29, 2, -27 },
  { 9771, 27, 27, 29, 1, -27 },
  { 9863, 26, 46, 29, 4, -41 },
  { 10013, 15, 46, 29, 8, -41 },
  { 10100, 26, 46, 29, 1, -41 },
  { 10250, 27, 13, 29, 2, -24 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC49PT7B_H_
