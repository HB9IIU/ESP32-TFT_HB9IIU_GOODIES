#ifndef _JETBRAINSMONO_EXTRABOLDITALIC47PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x8F, 0xEF,
  0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x3F, 0xBF,
  0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE7, 0x3F, 0xC3, 0xF8,
  0xE7, 0xF0, 0x7F, 0x38, 0xFE, 0x1F, 0xE7, 0x00, 0x03, 0xFC, 0xE0, 0x00,
  0x7F, 0x9C, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xCF,
  0xF8, 0x00, 0x38, 0xFF, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0xE3, 0xF8, 0x7F,
  0x1C, 0x7F, 0x1F, 0xE3, 0x8F, 0xE1, 0xFE, 0xE7, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x7C, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x1F,
  0x3F, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0x1E, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x3E,
  0x00, 0x1F, 0x07, 0x8F, 0x80, 0x03, 0xE1, 0xF3, 0xE0, 0x00, 0x7F, 0xFE,
  0xF8, 0x00, 0x07, 0xFF, 0xBE, 0x00, 0x00, 0x7F, 0xEF, 0x80, 0x00, 0x07,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x40, 0x00, 0x00, 0x7C, 0xFF,
  0x00, 0x00, 0x1F, 0x7F, 0xF0, 0x00, 0x07, 0xDF, 0xFF, 0x00, 0x01, 0xF3,
  0xF7, 0xE0, 0x00, 0x7C, 0xF8, 0x7C, 0x00, 0x0F, 0x9F, 0x0F, 0x80, 0x03,
  0xE3, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xFF,
  0xC0, 0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x07, 0xF3, 0xFF, 0xF8,
  0xFE, 0x3F, 0x9F, 0x9F, 0xC3, 0xF1, 0xFD, 0xF8, 0x7F, 0x0F, 0xFF, 0x87,
  0xF0, 0xFF, 0xF0, 0x7F, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7E, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFC, 0x3F, 0x80, 0x3F, 0x9F, 0xCF, 0xEF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0x01, 0xF0, 0x18, 0xF8,
  0x7C, 0x3E, 0x3F, 0x1E, 0x1F, 0x9F, 0xE7, 0x9F, 0xE7, 0xFC, 0xDF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0xFE, 0x03,
  0xF0, 0x3F, 0x00, 0x38, 0x07, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xFB, 0xFF, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0xC3, 0xF8, 0xFC, 0xF8,
  0xFC, 0x3F, 0x3F, 0x3F, 0x1F, 0xDF, 0xDF, 0xC7, 0xF7, 0xF7, 0xF1, 0xFC,
  0xFD, 0xFC, 0x7F, 0x1E, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0x8F, 0xE0, 0x3E, 0x1F, 0xC0, 0x70, 0x3F, 0x80, 0xC0,
  0x7F, 0x01, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x1F, 0xCF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xCF, 0x80, 0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xF8, 0x0F, 0xF7, 0xF8,
  0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC7,
  0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03,
  0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0x80, 0xFF, 0xBF, 0x80, 0x0E,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE2, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0xFC, 0xFC, 0x7E, 0x07, 0xFB, 0xF1, 0xF8, 0x3F, 0xE7, 0x87, 0xE1,
  0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE1, 0xF0, 0xFC,
  0x1F, 0x87, 0xC3, 0xE0, 0x7E, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x7E, 0x07,
  0xC3, 0xF1, 0xF8, 0x1F, 0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x1F, 0x83, 0xF0,
  0xF8, 0x7C, 0x0F, 0xC7, 0xE1, 0xF0, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0xFF, 0xE1, 0xF8, 0x7F, 0xEF, 0x87, 0xC0, 0xFF, 0x3E, 0x1F, 0x01,
  0xF9, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0xC3, 0xF8, 0x07, 0xF8, 0x7F,
  0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x3F, 0x87, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xF8,
  0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x8F, 0xFF, 0x9F, 0xE3, 0xFF, 0xC7, 0xF0, 0xFF, 0xF1, 0xFC,
  0x3F, 0xFC, 0x7F, 0x0F, 0xFF, 0x1F, 0xC3, 0xFF, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x81,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01,
  0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F, 0x7C,
  0x0F, 0xBC, 0x3D, 0xF0, 0x3E, 0xF1, 0xEF, 0xC0, 0xFB, 0xE7, 0xBF, 0x07,
  0xE7, 0xBE, 0xFC, 0x1F, 0x9E, 0xF3, 0xF0, 0x7E, 0x7F, 0xDF, 0x81, 0xF9,
  0xFE, 0x7E, 0x07, 0xE7, 0xF9, 0xF8, 0x1F, 0x9F, 0xE7, 0xE0, 0x7E, 0x7F,
  0x1F, 0x83, 0xF9, 0xFC, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x7E, 0x07, 0xFC, 0x07,
  0xE0, 0x7F, 0xC0, 0x7E, 0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0xC0, 0x7E, 0x0F,
  0xFE, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x0F, 0xBE, 0x0F, 0xC0, 0xFB, 0xE0,
  0xFC, 0x1F, 0xBE, 0x0F, 0xC1, 0xFB, 0xE0, 0xFC, 0x1F, 0xBF, 0x1F, 0xC1,
  0xF9, 0xF1, 0xFC, 0x1F, 0x9F, 0x1F, 0x81, 0xF9, 0xF1, 0xF8, 0x1F, 0x9F,
  0x1F, 0x83, 0xF9, 0xF9, 0xF8, 0x3F, 0x1F, 0x9F, 0x83, 0xF0, 0xF9, 0xF8,
  0x3F, 0x0F, 0x9F, 0x03, 0xF0, 0xFB, 0xF0, 0x3F, 0x0F, 0xBF, 0x07, 0xF0,
  0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF,
  0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0xFE,
  0x03, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xC0, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8,
  0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8,
  0x0F, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x87, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC1, 0xF9, 0xF0, 0x7E, 0x0F,
  0xCF, 0x83, 0xF0, 0x7C, 0x7C, 0x1F, 0x87, 0xE3, 0xE1, 0xFC, 0x3F, 0x3F,
  0x0E, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7E, 0x3F,
  0xC7, 0xE3, 0xF1, 0xFE, 0x3F, 0x1F, 0x8E, 0xF1, 0xF0, 0xFC, 0xF7, 0x8F,
  0x87, 0xC7, 0xBC, 0xFC, 0x3E, 0x39, 0xC7, 0xE1, 0xF1, 0xCE, 0x3E, 0x0F,
  0x9E, 0x71, 0xF0, 0x7C, 0xF3, 0x9F, 0x83, 0xE7, 0x1C, 0xFC, 0x1F, 0x38,
  0xE7, 0xC0, 0xFB, 0xC7, 0x3E, 0x0F, 0xDE, 0x3B, 0xF0, 0x7E, 0xE1, 0xDF,
  0x03, 0xF7, 0x0E, 0xF8, 0x1F, 0x78, 0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x07,
  0xDC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xEF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF8,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F,
  0x00, 0xFD, 0xFC, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0xE7, 0xF0, 0x3F, 0xFD, 0xFC, 0x1F, 0xFF,
  0x7F, 0x0F, 0xFF, 0xDF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xEF, 0xE0, 0xFF, 0xFB, 0xF0, 0x1F, 0xFD, 0xFC, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFF, 0x80, 0xFE, 0xFF,
  0xF0, 0x3F, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3,
  0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0x83, 0xFB, 0xFF, 0xE0, 0xFE, 0x7F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0xCF, 0xE0, 0x7F,
  0xFB, 0xF8, 0x3F, 0xFE, 0xFE, 0x1F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xC3,
  0xFC, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xC1, 0xFF, 0xF7, 0xE0, 0x3F, 0xFB,
  0xF8, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0x81, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xE1, 0xFF, 0xF7, 0xF1,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFE, 0x01,
  0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xE0, 0xFF, 0xE7, 0xF0, 0x3F,
  0xE3, 0xF0, 0x03, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE3, 0xFC, 0x07, 0xF3, 0xFF, 0x03, 0xFB, 0xFF, 0xC1, 0xFB, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFC,
  0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0x8F, 0xC0,
  0xFB, 0xF9, 0xFE, 0x0F, 0xBF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xF8, 0x7C, 0x7E, 0x1F, 0x87, 0xC7, 0xE1, 0xF8, 0x78, 0x7E,
  0x1F, 0x8F, 0x87, 0xE1, 0xF8, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xF0,
  0xF8, 0xFE, 0x3F, 0x0F, 0x8F, 0xC3, 0xF0, 0xF0, 0xFC, 0x3F, 0x1F, 0x0F,
  0xC3, 0xF1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF1, 0xFC, 0x7E,
  0x1F, 0x1F, 0x87, 0xE1, 0xF1, 0xF8, 0x7E, 0x3E, 0x1F, 0x87, 0xE3, 0xE1,
  0xF8, 0xFE, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F,
  0xC3, 0xE3, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF3, 0xFF, 0x03, 0xFB, 0xFF,
  0xC1, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xC1,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0xFE,
  0x7F, 0xE0, 0x1F, 0xDF, 0xFE, 0x03, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xDF, 0xFF,
  0x03, 0xFB, 0xFF, 0xE0, 0x7F, 0x3F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x81, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xE1,
  0xFF, 0xF7, 0xF1, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xFC,
  0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F,
  0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF7, 0xF0, 0xFF, 0xFB, 0xF0, 0x3F, 0xFB, 0xF8, 0x0F, 0xF1, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC3, 0xFC, 0x03, 0xF3, 0xFF, 0x81, 0xFD, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x81, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x08,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F,
  0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1,
  0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x0F, 0x83, 0xFF, 0xC1, 0xF8, 0x3E,
  0xFC, 0x1F, 0x83, 0xEF, 0xC1, 0xF8, 0x7E, 0xFC, 0x3F, 0x87, 0xCF, 0xC3,
  0xF8, 0x7C, 0xFC, 0x3F, 0x8F, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0x77, 0x8F,
  0x8F, 0xC7, 0x79, 0xF8, 0xFC, 0xF7, 0x9F, 0x8F, 0xCE, 0x79, 0xF0, 0xFC,
  0xE7, 0x9F, 0x0F, 0xDE, 0x73, 0xF0, 0xFD, 0xE7, 0x3E, 0x0F, 0xDC, 0x73,
  0xE0, 0xFD, 0xC7, 0x7E, 0x0F, 0xFC, 0x77, 0xC0, 0xFF, 0x87, 0x7C, 0x0F,
  0xB8, 0x77, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xDF, 0xC1, 0xFF, 0xCF, 0xE0, 0xFF, 0xCF, 0xE0, 0x1F,
  0xC7, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFC, 0xFF,
  0xF0, 0x3E, 0x7F, 0xFE, 0x0F, 0x9F, 0xFF, 0xC7, 0xEF, 0xC7, 0xF1, 0xFB,
  0xF0, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0x3F, 0x07, 0xFF, 0x8F, 0x80, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 8, -34 },
  { 57, 19, 14, 28, 7, -34 },
  { 91, 29, 34, 28, 0, -34 },
  { 215, 27, 48, 28, 1, -41 },
  { 377, 35, 35, 28, -3, -35 },
  { 531, 28, 35, 28, 0, -35 },
  { 654, 9, 14, 28, 12, -34 },
  { 670, 21, 46, 28, 6, -40 },
  { 791, 21, 46, 28, 2, -40 },
  { 912, 26, 25, 28, 2, -29 },
  { 994, 25, 23, 28, 2, -27 },
  { 1066, 15, 15, 28, 3, -7 },
  { 1095, 17, 7, 28, 6, -19 },
  { 1110, 10, 9, 28, 8, -9 },
  { 1122, 31, 44, 28, -1, -39 },
  { 1293, 26, 35, 28, 2, -35 },
  { 1407, 23, 34, 28, 2, -34 },
  { 1505, 26, 35, 28, 1, -35 },
  { 1619, 26, 34, 28, 1, -34 },
  { 1730, 26, 34, 28, 1, -34 },
  { 1841, 26, 34, 28, 2, -34 },
  { 1952, 25, 34, 28, 1, -34 },
  { 2059, 25, 34, 28, 4, -34 },
  { 2166, 27, 35, 28, 1, -35 },
  { 2285, 25, 35, 28, 3, -35 },
  { 2395, 13, 26, 28, 8, -26 },
  { 2438, 17, 34, 28, 4, -26 },
  { 2511, 24, 27, 28, 3, -29 },
  { 2592, 23, 19, 28, 3, -25 },
  { 2647, 24, 27, 28, 2, -29 },
  { 2728, 22, 34, 28, 5, -34 },
  { 2822, 30, 43, 28, -1, -35 },
  { 2984, 26, 34, 28, -1, -34 },
  { 3095, 27, 34, 28, 1, -34 },
  { 3210, 26, 35, 28, 2, -35 },
  { 3324, 27, 34, 28, 1, -34 },
  { 3439, 26, 34, 28, 2, -34 },
  { 3550, 28, 34, 28, 1, -34 },
  { 3669, 26, 35, 28, 2, -35 },
  { 3783, 27, 34, 28, 1, -34 },
  { 3898, 26, 34, 28, 2, -34 },
  { 4009, 28, 35, 28, 0, -34 },
  { 4132, 29, 34, 28, 1, -34 },
  { 4256, 22, 34, 28, 2, -34 },
  { 4350, 30, 34, 28, 0, -34 },
  { 4478, 28, 34, 28, 1, -34 },
  { 4597, 26, 35, 28, 2, -35 },
  { 4711, 28, 34, 28, 1, -34 },
  { 4830, 26, 43, 28, 2, -35 },
  { 4970, 27, 34, 28, 1, -34 },
  { 5085, 27, 35, 28, 1, -35 },
  { 5204, 26, 34, 28, 4, -34 },
  { 5315, 27, 34, 28, 2, -34 },
  { 5430, 25, 34, 28, 5, -34 },
  { 5537, 29, 34, 28, 2, -34 },
  { 5661, 31, 34, 28, -1, -34 },
  { 5793, 27, 34, 28, 4, -34 },
  { 5908, 27, 34, 28, 1, -34 },
  { 6023, 21, 44, 28, 5, -39 },
  { 6139, 17, 44, 28, 6, -39 },
  { 6233, 21, 44, 28, 3, -39 },
  { 6349, 23, 18, 28, 3, -34 },
  { 6401, 23, 7, 28, 0, 1 },
  { 6422, 11, 7, 28, 11, -37 },
  { 6432, 26, 26, 28, 1, -26 },
  { 6517, 26, 34, 28, 1, -34 },
  { 6628, 25, 26, 28, 2, -26 },
  { 6710, 26, 34, 28, 2, -34 },
  { 6821, 24, 26, 28, 2, -26 },
  { 6899, 32, 42, 28, -3, -34 },
  { 7067, 25, 34, 28, 2, -26 },
  { 7174, 25, 34, 28, 1, -34 },
  { 7281, 24, 37, 28, 1, -37 },
  { 7392, 26, 45, 28, 0, -37 },
  { 7539, 28, 34, 28, 1, -34 },
  { 7658, 21, 34, 28, 4, -34 },
  { 7748, 28, 26, 28, 0, -26 },
  { 7839, 25, 26, 28, 1, -26 },
  { 7921, 24, 26, 28, 2, -26 },
  { 7999, 27, 34, 28, 0, -26 },
  { 8114, 25, 34, 28, 2, -26 },
  { 8221, 26, 26, 28, 2, -26 },
  { 8306, 26, 26, 28, 1, -26 },
  { 8391, 24, 33, 28, 3, -33 },
  { 8490, 25, 26, 28, 2, -26 },
  { 8572, 26, 26, 28, 3, -26 },
  { 8657, 28, 26, 28, 2, -26 },
  { 8748, 29, 26, 28, -1, -26 },
  { 8843, 25, 34, 28, 2, -26 },
  { 8950, 25, 26, 28, 1, -26 },
  { 9032, 25, 44, 28, 4, -39 },
  { 9170, 14, 44, 28, 8, -39 },
  { 9247, 25, 44, 28, 1, -39 },
  { 9385, 26, 12, 28, 2, -23 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC47PT7B_H_
