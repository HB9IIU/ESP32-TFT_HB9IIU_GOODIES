#ifndef _JETBRAINSMONO_EXTRABOLDITALIC8PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xFA, 0xA0, 0x29, 0xD4, 0xAF, 0x50, 0x11, 0x9E,
  0xC3, 0x59, 0xC8, 0x6E, 0xC5, 0x0C, 0x6A, 0xC0, 0x32, 0x91, 0xFB, 0x78,
  0xE8, 0x16, 0x4C, 0x88, 0xE4, 0x42, 0x11, 0x32, 0x6C, 0x27, 0xC8, 0xA0,
  0x21, 0x7C, 0x40, 0xE0, 0xE0, 0x70, 0x08, 0xC4, 0x42, 0x21, 0x10, 0x32,
  0xDE, 0xED, 0x38, 0x37, 0x32, 0x2F, 0x32, 0xC4, 0x64, 0x78, 0x78, 0x8C,
  0x2D, 0x38, 0x19, 0x19, 0xAF, 0x08, 0x7A, 0x1C, 0x2D, 0x38, 0x12, 0x7D,
  0x97, 0xFB, 0x24, 0x48, 0x32, 0xD4, 0xE9, 0x38, 0x69, 0xBE, 0x4C, 0x40,
  0x60, 0x40, 0x68, 0x1E, 0x86, 0x20, 0x70, 0xF0, 0x47, 0x1E, 0x80, 0xE2,
  0x6C, 0x08, 0x32, 0x6F, 0x5A, 0xDB, 0x80, 0x33, 0x55, 0xF9, 0x72, 0xDC,
  0xAD, 0x78, 0x32, 0xD0, 0x8D, 0x38, 0x72, 0xD6, 0xAD, 0x78, 0x7A, 0x1C,
  0xE4, 0x78, 0x7A, 0x10, 0xEC, 0x40, 0x32, 0xD2, 0xED, 0x38, 0x4A, 0xDC,
  0xED, 0x48, 0x79, 0x08, 0x42, 0x78, 0x38, 0xC4, 0x29, 0x70, 0x4A, 0x9C,
  0xED, 0x48, 0x64, 0x44, 0x4F, 0x4A, 0xDB, 0x79, 0x48, 0x4B, 0x5E, 0xEB,
  0x58, 0x32, 0xD6, 0xAD, 0x38, 0x72, 0x56, 0xEC, 0x40, 0x32, 0xD6, 0xAD,
  0x38, 0xC0, 0x72, 0xD6, 0xEF, 0x48, 0x32, 0xD8, 0x69, 0x38, 0xF4, 0x44,
  0x4C, 0x4A, 0xD6, 0xAD, 0x38, 0x9B, 0xAA, 0xCC, 0x6B, 0x6B, 0xED, 0x68,
  0x4B, 0x8C, 0xC5, 0x48, 0x9A, 0xA4, 0x4C, 0x78, 0x8C, 0xC4, 0x78, 0x74,
  0x44, 0xC8, 0x8C, 0x99, 0x24, 0x99, 0x64, 0xB4, 0x96, 0x6E, 0x80, 0xF0,
  0xC0, 0x7A, 0xB4, 0xE0, 0x42, 0x1C, 0xAD, 0x58, 0x72, 0x34, 0xE0, 0x08,
  0xDC, 0xAD, 0x38, 0x77, 0xC7, 0x19, 0x1F, 0x46, 0x23, 0x00, 0x7A, 0xB4,
  0xE7, 0x00, 0x42, 0x1C, 0xAD, 0x48, 0x31, 0x62, 0x2F, 0x10, 0x71, 0x33,
  0xE0, 0x42, 0x54, 0xEF, 0x48, 0xC9, 0x2C, 0xC0, 0x7D, 0xED, 0x60, 0x72,
  0xB5, 0x20, 0x75, 0xD7, 0x72, 0xB5, 0x68, 0x00, 0x7A, 0xB4, 0xE3, 0x00,
  0x7A, 0xD1, 0x80, 0x7B, 0x05, 0xE0, 0x21, 0x7C, 0xC6, 0x38, 0x5A, 0xB4,
  0xE0, 0xBA, 0xEC, 0xAD, 0x75, 0xA0, 0x59, 0x19, 0xA0, 0x5A, 0xBC, 0xA7,
  0x00, 0x79, 0x11, 0xE0, 0x12, 0x66, 0xC4, 0x46, 0x6D, 0x24, 0x96, 0x62,
  0x22, 0x36, 0x4C, 0x6D, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 4, 3, 5, 1, -6 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 2, 3, 5, 2, -6 },
  { 25, 4, 8, 5, 1, -7 },
  { 29, 4, 8, 5, 0, -7 },
  { 33, 5, 4, 5, 0, -5 },
  { 36, 5, 4, 5, 0, -5 },
  { 39, 2, 2, 5, 1, -1 },
  { 40, 3, 1, 5, 1, -3 },
  { 41, 2, 2, 5, 1, -2 },
  { 42, 5, 8, 5, 0, -7 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 4, 6, 5, 0, -6 },
  { 73, 4, 6, 5, 1, -6 },
  { 76, 5, 6, 5, 0, -6 },
  { 80, 4, 6, 5, 1, -6 },
  { 83, 3, 4, 5, 1, -4 },
  { 85, 3, 5, 5, 1, -4 },
  { 87, 4, 5, 5, 1, -5 },
  { 90, 4, 3, 5, 0, -4 },
  { 92, 4, 5, 5, 0, -5 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 5, 7, 5, 0, -6 },
  { 103, 4, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 7, 5, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 4, 6, 5, 1, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 4, 6, 5, 1, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 5, 6, 5, 0, -6 },
  { 196, 4, 6, 5, 1, -6 },
  { 199, 5, 6, 5, 0, -6 },
  { 203, 4, 8, 5, 1, -7 },
  { 207, 3, 8, 5, 1, -7 },
  { 210, 3, 8, 5, 1, -7 },
  { 213, 3, 3, 5, 1, -6 },
  { 215, 4, 1, 5, 0, 0 },
  { 216, 2, 1, 5, 2, -6 },
  { 217, 5, 4, 5, 0, -4 },
  { 220, 5, 6, 5, 0, -6 },
  { 224, 5, 4, 5, 0, -4 },
  { 227, 5, 6, 5, 0, -6 },
  { 231, 4, 4, 5, 0, -4 },
  { 233, 5, 7, 5, 0, -6 },
  { 238, 5, 5, 5, 0, -4 },
  { 242, 5, 6, 5, 0, -6 },
  { 246, 4, 6, 5, 0, -6 },
  { 249, 4, 7, 5, 0, -6 },
  { 253, 5, 6, 5, 0, -6 },
  { 257, 3, 6, 5, 1, -6 },
  { 260, 5, 4, 5, 0, -4 },
  { 263, 5, 4, 5, 0, -4 },
  { 266, 4, 4, 5, 0, -4 },
  { 268, 5, 5, 5, 0, -4 },
  { 272, 5, 5, 5, 0, -4 },
  { 276, 5, 4, 5, 0, -4 },
  { 279, 5, 4, 5, 0, -4 },
  { 282, 5, 6, 5, 0, -6 },
  { 286, 5, 4, 5, 0, -4 },
  { 289, 4, 4, 5, 1, -4 },
  { 291, 5, 4, 5, 0, -4 },
  { 294, 5, 4, 5, 0, -4 },
  { 297, 5, 5, 5, 0, -4 },
  { 301, 5, 4, 5, 0, -4 },
  { 304, 4, 8, 5, 1, -7 },
  { 308, 3, 8, 5, 1, -7 },
  { 311, 4, 8, 5, 0, -7 },
  { 315, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC8PT7B_H_
