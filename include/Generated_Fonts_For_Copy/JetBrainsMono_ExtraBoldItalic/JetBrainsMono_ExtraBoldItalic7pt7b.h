#ifndef _JETBRAINSMONO_EXTRABOLDITALIC7PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xB4, 0x37, 0x6F, 0xA0, 0x27, 0x67, 0x5E, 0x40, 0xFF,
  0x08, 0xEB, 0x00, 0x74, 0xDA, 0xF0, 0xC0, 0x2A, 0x49, 0x90, 0x44, 0x92,
  0xE0, 0x2F, 0x60, 0x2F, 0x60, 0x78, 0xC0, 0xC0, 0x11, 0x22, 0x44, 0x80,
  0x75, 0xB9, 0x60, 0x6A, 0x22, 0xF0, 0x71, 0x24, 0xF0, 0x72, 0x31, 0xE0,
  0x36, 0x5F, 0x20, 0x74, 0x71, 0xE0, 0x34, 0x79, 0x60, 0xF5, 0x28, 0x75,
  0x69, 0xE0, 0x75, 0x72, 0x40, 0x43, 0x43, 0x80, 0x34, 0xE1, 0x70, 0xF0,
  0x43, 0x68, 0xE7, 0x08, 0x79, 0xBD, 0xBC, 0x26, 0x5F, 0x90, 0x75, 0x69,
  0xE0, 0x74, 0x49, 0x60, 0x75, 0x59, 0xE0, 0x74, 0x7C, 0xF0, 0x74, 0x78,
  0x80, 0x74, 0x79, 0x60, 0x55, 0x79, 0xB0, 0x72, 0x22, 0xE0, 0x31, 0x19,
  0xE0, 0x57, 0x6A, 0xB0, 0x44, 0x44, 0xF0, 0x5B, 0xB9, 0x90, 0x55, 0xBB,
  0xB0, 0x75, 0x59, 0x60, 0x75, 0x78, 0x80, 0x75, 0x59, 0x62, 0x75, 0x7A,
  0xB0, 0x74, 0x71, 0xE0, 0xE9, 0x28, 0x55, 0x59, 0x60, 0xBA, 0xCC, 0xC0,
  0xAD, 0xBD, 0xEA, 0x00, 0x56, 0x26, 0xB0, 0xBA, 0xCC, 0x80, 0x72, 0x24,
  0xF0, 0x6A, 0x49, 0x30, 0xAD, 0x54, 0x72, 0x22, 0x22, 0xE0, 0x25, 0xD0,
  0xE0, 0x80, 0x75, 0x9F, 0x47, 0x59, 0xE0, 0x75, 0x96, 0x17, 0x59, 0xF0,
  0x75, 0xA7, 0x32, 0xF4, 0x4C, 0x75, 0x97, 0xE0, 0x47, 0x59, 0xB0, 0x22,
  0x62, 0x2F, 0x11, 0x72, 0x22, 0xE0, 0x45, 0x6A, 0xB0, 0xCB, 0x4E, 0x7B,
  0xBD, 0x75, 0x9B, 0x75, 0x96, 0x75, 0x9E, 0x80, 0x75, 0x9F, 0x20, 0x75,
  0x48, 0x74, 0x3E, 0x2F, 0x44, 0x70, 0x55, 0x96, 0xD5, 0x66, 0xBB, 0xFE,
  0x56, 0x6B, 0x5D, 0x96, 0xE0, 0x72, 0x4F, 0x29, 0x44, 0x90, 0x55, 0x68,
  0x62, 0x63, 0x44, 0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 7, 4, 1, -6 },
  { 22, 3, 7, 4, 0, -6 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 3, 2, 4, 0, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 2, 1, 4, 1, -1 },
  { 32, 4, 7, 4, 0, -6 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 3, 5, 4, 1, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 2, 4, 4, 1, -4 },
  { 66, 2, 5, 4, 1, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 4, 3, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 4, 6, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 6, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 3, 5, 4, 1, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 1, -5 },
  { 144, 5, 5, 4, 0, -5 },
  { 148, 4, 5, 4, 0, -5 },
  { 151, 4, 5, 4, 1, -5 },
  { 154, 4, 5, 4, 0, -5 },
  { 157, 3, 7, 4, 1, -6 },
  { 160, 2, 7, 4, 1, -6 },
  { 162, 4, 7, 4, 0, -6 },
  { 166, 4, 3, 4, 0, -5 },
  { 168, 3, 1, 4, 0, 0 },
  { 169, 1, 1, 4, 2, -6 },
  { 170, 4, 4, 4, 0, -4 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 4, 5, 4, 0, -5 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 4, 6, 4, 0, -5 },
  { 185, 4, 5, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 4, 6, 4, 0, -6 },
  { 194, 4, 7, 4, 0, -6 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 3, 5, 4, 1, -5 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 4, 5, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 5, 4, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 5, 4, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 3, 7, 4, 1, -6 },
  { 238, 2, 7, 4, 1, -6 },
  { 240, 4, 7, 4, 0, -6 },
  { 244, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC7PT7B_H_
