#ifndef _JETBRAINSMONO_EXTRABOLDITALIC43PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x78, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFD, 0xCF, 0xE0, 0xFC, 0xE7, 0xF0, 0xFE, 0x71, 0xF8, 0x7F,
  0x38, 0x00, 0x3F, 0x9C, 0x00, 0x1F, 0xCE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0xFE,
  0x00, 0x0E, 0x3F, 0x00, 0x07, 0x1F, 0x8F, 0xE3, 0x8F, 0xC7, 0xF1, 0x8F,
  0xE3, 0xF9, 0xC7, 0xF1, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x3F,
  0xC0, 0x0F, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x0F, 0x80, 0x3E,
  0x3E, 0x07, 0x80, 0x1E, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x07, 0x80, 0x0F,
  0x87, 0x87, 0xC0, 0x07, 0xC3, 0xC7, 0xC0, 0x03, 0xC1, 0xE7, 0xC0, 0x01,
  0xF1, 0xF7, 0xC0, 0x00, 0xFF, 0xF7, 0xC0, 0x00, 0x3F, 0xF3, 0xC0, 0x00,
  0x0F, 0xF3, 0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x03, 0xEF, 0xFC, 0x00, 0x01, 0xEF, 0xFE, 0x00, 0x01, 0xE7, 0xDF,
  0x80, 0x01, 0xE7, 0xC3, 0xC0, 0x01, 0xE3, 0xC1, 0xE0, 0x01, 0xF1, 0xE1,
  0xF0, 0x01, 0xF0, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x78, 0x01, 0xF0, 0x7C,
  0x3C, 0x00, 0xF0, 0x3F, 0x7E, 0x00, 0xF0, 0x0F, 0xFE, 0x00, 0xF0, 0x03,
  0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x0F, 0xCF, 0xDF, 0xCF, 0xC7, 0xE7, 0xEF, 0xC7, 0xE1, 0xFF, 0xE3,
  0xF0, 0xFF, 0xE1, 0xF8, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xF0, 0x1F, 0xF0, 0xFC, 0x3F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x8F, 0x0F, 0x0F, 0x3F,
  0x9E, 0x7F, 0x7F, 0xB9, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xE7,
  0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x3F,
  0x01, 0xE0, 0x78, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE7, 0x1F,
  0x9F, 0x9F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xF9, 0xF9,
  0xF9, 0xF7, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC,
  0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x03, 0xF3,
  0xF8, 0x1E, 0x1F, 0xC0, 0xC0, 0xFC, 0x04, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFC, 0x3F, 0xC0, 0xFC, 0x3F,
  0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0x80, 0x0F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x7E, 0x03, 0xFB, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x03, 0xFD, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x3F,
  0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x1F, 0xF7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFF,
  0x01, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F,
  0x9F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xDF, 0x80, 0x3C, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1,
  0xFE, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x10,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE1, 0xF8, 0x3F, 0x3E, 0x1F, 0x07, 0xFB, 0xE1, 0xF0, 0xFF, 0xDE, 0x1F,
  0x0F, 0xCF, 0xE1, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x07, 0xE3, 0xF1, 0xF0,
  0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x3F, 0x07, 0xC3,
  0xE3, 0xE0, 0x7C, 0x3E, 0x3E, 0x0F, 0xC3, 0xE3, 0xE0, 0xF8, 0x7E, 0x3E,
  0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0xFF, 0x87, 0xC1, 0xFE, 0xF8,
  0x7C, 0x1F, 0xCF, 0x87, 0xC0, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0,
  0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0x83, 0xFE, 0x0F,
  0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x03, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x1F, 0xFC, 0x7F, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC,
  0x7E, 0x1F, 0xFC, 0xFE, 0x21, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1D, 0xF0, 0x7F, 0xC7, 0xBE, 0x1F, 0xF8, 0xFF, 0xC3, 0xF7, 0x3D, 0xF8,
  0x7C, 0xE7, 0xBE, 0x0F, 0x9F, 0xE7, 0xC1, 0xF3, 0xFC, 0xF8, 0x3E, 0x7F,
  0xBF, 0x07, 0xCF, 0xE7, 0xE1, 0xF9, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x07,
  0xE7, 0xE7, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x1F, 0x87, 0xF8, 0x0F, 0xC3, 0xFE, 0x07, 0xE1, 0xFF, 0x03, 0xF0,
  0xFF, 0x81, 0xF8, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x3F, 0xF8, 0x7E,
  0x1F, 0x7C, 0x3F, 0x0F, 0xBE, 0x1F, 0x87, 0xDF, 0x0F, 0xC3, 0xEF, 0x87,
  0xC1, 0xF3, 0xC3, 0xE1, 0xF9, 0xF3, 0xF0, 0xFC, 0xF9, 0xF8, 0x7E, 0x7C,
  0xFC, 0x3F, 0x3E, 0x7E, 0x1F, 0x9F, 0x3E, 0x0F, 0x87, 0x9F, 0x0F, 0xC3,
  0xEF, 0x87, 0xE1, 0xF7, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7D, 0xF0, 0xFC,
  0x1F, 0xF8, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x3F, 0x03, 0xFE, 0x1F,
  0x81, 0xFF, 0x0F, 0xC0, 0xFF, 0x87, 0xE0, 0x3F, 0xC3, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01,
  0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1,
  0xFC, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7E, 0x0F, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x07,
  0xF0, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x07, 0xF8, 0x3F,
  0x01, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x3F, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x0F, 0x83, 0xE7, 0xE1, 0xF0, 0x7C, 0xF8, 0x3E, 0x1F, 0x9F,
  0x0F, 0xC3, 0xE3, 0xE1, 0xF8, 0x7C, 0x7C, 0x3F, 0x0F, 0x8F, 0x87, 0xE1,
  0xF1, 0xF1, 0xDC, 0x7C, 0x3E, 0x3B, 0x8F, 0x87, 0xC7, 0x71, 0xF0, 0xF9,
  0xEE, 0x3E, 0x1F, 0x39, 0xCF, 0x83, 0xE7, 0x39, 0xF0, 0x7C, 0xE7, 0x3E,
  0x0F, 0x3C, 0xE7, 0xC3, 0xE7, 0x3D, 0xF0, 0x7C, 0xE7, 0xBE, 0x0F, 0x9C,
  0xF7, 0xC1, 0xF7, 0x9E, 0xF8, 0x3E, 0xE3, 0x9E, 0x07, 0xDC, 0x77, 0xC0,
  0xFB, 0x8E, 0xF8, 0x1F, 0xF1, 0xDF, 0x03, 0xFC, 0x3B, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0x70, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7F,
  0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F,
  0xBF, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07,
  0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7F, 0x03,
  0xFF, 0x7F, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFD, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFB, 0xF0, 0x1F, 0xFB, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xF8, 0x3F, 0xBF,
  0xF8, 0x7E, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F,
  0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0x9F, 0xF8, 0x3F, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xFB, 0xF8, 0x1F, 0xCF, 0xF0, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xFF, 0x7F,
  0x03, 0xFF, 0xBF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xBF, 0x00, 0xFF, 0xDF, 0x80, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE,
  0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x0F, 0xFD, 0xFC,
  0x3F, 0xFB, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0x03, 0xFC, 0xFC, 0x01, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x0F, 0xCF, 0xF8, 0x3F, 0xBF, 0xF8, 0x7E, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0x0F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0x7E, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0x9E, 0x1E, 0x0F, 0xDF, 0x9F, 0x87, 0xDF, 0xDF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xF9, 0xF9, 0xF8, 0xFC, 0x78, 0xFC, 0x7C, 0x3C, 0x7E, 0x3E, 0x3E, 0x3F,
  0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F, 0x8F, 0xC7, 0x87, 0xC7, 0xC3, 0xC3,
  0xE3, 0xE1, 0xE3, 0xF1, 0xF1, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C,
  0x7E, 0x7E, 0x3C, 0x3E, 0x3F, 0x1E, 0x1F, 0x1F, 0x0F, 0x1F, 0x8F, 0x87,
  0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1, 0xF1, 0xF8,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0xF0, 0x7F, 0x7F, 0xF0, 0xFD,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x8F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE,
  0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8,
  0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xF3, 0xF8, 0x1F,
  0xCF, 0xF0, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0xE7, 0xFC, 0x0F,
  0xEF, 0xFE, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0x7F, 0xE0, 0x7E, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xFF, 0x7F, 0x07,
  0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x8F, 0xF8, 0x7F, 0xFD, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF0, 0x1F,
  0xFB, 0xF0, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0x9F, 0xF8, 0x1F,
  0xBF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE8, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3,
  0xFC, 0x3F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80,
  0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF,
  0x0F, 0xC3, 0xEF, 0x87, 0xE1, 0xF7, 0xC3, 0xF0, 0xFB, 0xE1, 0xB8, 0xF9,
  0xF1, 0xDC, 0x7C, 0xF8, 0xEE, 0x3E, 0x7C, 0x77, 0x3E, 0x3E, 0x73, 0x9F,
  0x1F, 0x39, 0xCF, 0x8F, 0x9C, 0xE7, 0xC7, 0xDE, 0x77, 0xC3, 0xEE, 0x3B,
  0xE1, 0xF7, 0x1D, 0xF0, 0xFB, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x8F, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8,
  0xFF, 0x9F, 0xF1, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x83,
  0xFE, 0x7E, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x04, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0xFB, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3,
  0xFF, 0x9F, 0x8F, 0xFE, 0x1F, 0xFF, 0x7C, 0x3F, 0xFE, 0xF8, 0x3F, 0xF9,
  0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 12, 31, 26, 7, -31 },
  { 48, 18, 13, 26, 6, -31 },
  { 78, 27, 31, 26, 0, -31 },
  { 183, 25, 43, 26, 1, -37 },
  { 318, 33, 32, 26, -3, -32 },
  { 450, 25, 32, 26, 0, -32 },
  { 550, 8, 13, 26, 11, -31 },
  { 563, 19, 41, 26, 6, -36 },
  { 661, 19, 41, 26, 2, -36 },
  { 759, 23, 22, 26, 2, -26 },
  { 823, 22, 21, 26, 2, -25 },
  { 881, 13, 14, 26, 3, -7 },
  { 904, 16, 6, 26, 5, -17 },
  { 916, 9, 8, 26, 7, -8 },
  { 925, 27, 41, 26, 0, -36 },
  { 1064, 23, 32, 26, 2, -32 },
  { 1156, 21, 31, 26, 2, -31 },
  { 1238, 24, 32, 26, 1, -32 },
  { 1334, 24, 31, 26, 1, -31 },
  { 1427, 24, 31, 26, 1, -31 },
  { 1520, 24, 31, 26, 1, -31 },
  { 1613, 23, 31, 26, 1, -31 },
  { 1703, 24, 31, 26, 3, -31 },
  { 1796, 24, 32, 26, 1, -32 },
  { 1892, 23, 32, 26, 3, -32 },
  { 1984, 12, 24, 26, 7, -24 },
  { 2020, 16, 31, 26, 3, -24 },
  { 2082, 22, 24, 26, 3, -26 },
  { 2148, 22, 17, 26, 2, -23 },
  { 2195, 23, 24, 26, 1, -26 },
  { 2264, 19, 31, 26, 5, -31 },
  { 2338, 28, 40, 26, -1, -32 },
  { 2478, 24, 31, 26, -1, -31 },
  { 2571, 25, 31, 26, 1, -31 },
  { 2668, 24, 32, 26, 2, -32 },
  { 2764, 25, 31, 26, 1, -31 },
  { 2861, 24, 31, 26, 2, -31 },
  { 2954, 25, 31, 26, 1, -31 },
  { 3051, 24, 32, 26, 2, -32 },
  { 3147, 25, 31, 26, 1, -31 },
  { 3244, 23, 31, 26, 2, -31 },
  { 3334, 25, 31, 26, 0, -31 },
  { 3431, 27, 31, 26, 1, -31 },
  { 3536, 20, 31, 26, 2, -31 },
  { 3614, 27, 31, 26, 0, -31 },
  { 3719, 25, 31, 26, 1, -31 },
  { 3816, 23, 32, 26, 2, -32 },
  { 3908, 25, 31, 26, 1, -31 },
  { 4005, 23, 40, 26, 2, -32 },
  { 4120, 25, 31, 26, 1, -31 },
  { 4217, 25, 32, 26, 1, -32 },
  { 4317, 23, 31, 26, 4, -31 },
  { 4407, 25, 31, 26, 1, -31 },
  { 4504, 24, 31, 26, 4, -31 },
  { 4597, 27, 31, 26, 1, -31 },
  { 4702, 28, 31, 26, -1, -31 },
  { 4811, 24, 31, 26, 4, -31 },
  { 4904, 24, 31, 26, 1, -31 },
  { 4997, 19, 41, 26, 5, -36 },
  { 5095, 15, 41, 26, 6, -36 },
  { 5172, 19, 41, 26, 3, -36 },
  { 5270, 21, 16, 26, 3, -31 },
  { 5312, 21, 6, 26, 0, 1 },
  { 5328, 10, 6, 26, 10, -34 },
  { 5336, 24, 24, 26, 1, -24 },
  { 5408, 23, 31, 26, 1, -31 },
  { 5498, 22, 24, 26, 2, -24 },
  { 5564, 25, 31, 26, 1, -31 },
  { 5661, 22, 24, 26, 2, -24 },
  { 5727, 30, 39, 26, -3, -31 },
  { 5874, 23, 32, 26, 2, -24 },
  { 5966, 23, 31, 26, 1, -31 },
  { 6056, 22, 34, 26, 1, -34 },
  { 6150, 24, 42, 26, 0, -34 },
  { 6276, 26, 31, 26, 1, -31 },
  { 6377, 20, 31, 26, 3, -31 },
  { 6455, 25, 24, 26, 0, -24 },
  { 6530, 23, 24, 26, 1, -24 },
  { 6599, 22, 24, 26, 2, -24 },
  { 6665, 24, 32, 26, 0, -24 },
  { 6761, 24, 32, 26, 1, -24 },
  { 6857, 24, 24, 26, 2, -24 },
  { 6929, 24, 24, 26, 1, -24 },
  { 7001, 23, 30, 26, 2, -30 },
  { 7088, 23, 24, 26, 2, -24 },
  { 7157, 23, 24, 26, 3, -24 },
  { 7226, 25, 24, 26, 2, -24 },
  { 7301, 27, 24, 26, -1, -24 },
  { 7382, 23, 32, 26, 2, -24 },
  { 7474, 23, 24, 26, 1, -24 },
  { 7543, 23, 41, 26, 3, -36 },
  { 7661, 13, 41, 26, 7, -36 },
  { 7728, 23, 41, 26, 1, -36 },
  { 7846, 23, 11, 26, 2, -21 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC43PT7B_H_
