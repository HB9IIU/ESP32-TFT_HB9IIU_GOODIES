#ifndef _JETBRAINSMONO_EXTRABOLDITALIC22PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x00, 0x03, 0xCF,
  0x38, 0x73, 0xB9, 0xDC, 0xFE, 0x7E, 0x7F, 0x3B, 0x9C, 0x03, 0x18, 0x1C,
  0xE0, 0x63, 0x01, 0x8C, 0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x07, 0x38, 0x18,
  0xC0, 0x63, 0x0F, 0xFF, 0x3F, 0xFC, 0x31, 0x81, 0xCE, 0x06, 0x30, 0x18,
  0xC0, 0x00, 0x80, 0x04, 0x00, 0x60, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF5,
  0xE7, 0x20, 0x3D, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0x78,
  0x09, 0xCE, 0xDE, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x0F, 0x07, 0x1F, 0x8E, 0x39, 0x8C, 0x31, 0x98, 0x33, 0xB0, 0x3F,
  0x60, 0x1E, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0xF8, 0x06, 0xFC, 0x0D,
  0x8C, 0x19, 0x9C, 0x31, 0x98, 0x61, 0xF8, 0xC0, 0xF0, 0x07, 0xE0, 0x7F,
  0x87, 0xBC, 0x38, 0xE1, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x7F, 0x3B,
  0xBB, 0x9C, 0xF9, 0xE7, 0xCF, 0x1C, 0x7B, 0xE1, 0xFF, 0x87, 0xDE, 0xFF,
  0xEE, 0xEE, 0xC0, 0x00, 0x40, 0x60, 0x78, 0x3E, 0x1E, 0x0F, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0xE0, 0xF8, 0x1C, 0x01, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x7C,
  0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x07, 0x87, 0xC3, 0xE0, 0xE0, 0x20, 0x00, 0x07,
  0x00, 0x70, 0x47, 0x17, 0x6F, 0xFF, 0xF7, 0xFC, 0x0E, 0x01, 0xB0, 0x3B,
  0x87, 0x3C, 0x21, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0xE7, 0x9C, 0xF3,
  0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x87,
  0x70, 0x77, 0x0F, 0x76, 0xE7, 0xEE, 0x7E, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0xFE, 0x1D, 0xC3,
  0x38, 0x87, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0xFC, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0xE1, 0xCF,
  0xFC, 0xFF, 0x87, 0xF0, 0x01, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x8E, 0xF1, 0xEE, 0x1E, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0x80, 0x38, 0x07,
  0x90, 0x77, 0xC7, 0xFE, 0x71, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0xE1, 0xCF,
  0xFC, 0x7F, 0x83, 0xF0, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0xE3, 0xBE, 0x7F, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xFF, 0x9F,
  0xE1, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xEE, 0x0E, 0xE1, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0xF7, 0x8E, 0x3F,
  0xC1, 0xF8, 0x3F, 0xC7, 0x9C, 0xF1, 0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF,
  0x87, 0xF0, 0x1F, 0x87, 0xF9, 0xEF, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0xFE, 0xFF, 0xC7, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80,
  0x39, 0xE7, 0x8C, 0x00, 0x00, 0x00, 0x63, 0xCF, 0x38, 0x0E, 0x1E, 0x1E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0,
  0xE0, 0x00, 0x30, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x07, 0x00, 0x78, 0x0F,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xC0, 0x04, 0x3F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0xFF, 0xC0, 0x30, 0x0F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x01, 0xC0, 0xF8, 0xFE, 0x7F, 0x1F, 0x03, 0x80, 0x40,
  0x00, 0x7E, 0x1F, 0xC7, 0xFA, 0x0E, 0x03, 0x80, 0xE7, 0xF9, 0xFC, 0x7E,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x03, 0x80, 0x07, 0xF0, 0x3F,
  0xE1, 0xC3, 0x8E, 0x07, 0x30, 0x1D, 0xC7, 0x67, 0x3F, 0x9D, 0xCE, 0x67,
  0x39, 0x9C, 0xEE, 0x63, 0xB9, 0x8E, 0xE6, 0x73, 0x9E, 0xCE, 0x33, 0x38,
  0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x3F,
  0xE7, 0xFE, 0x70, 0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0x1F, 0xE0, 0xFF, 0x87,
  0xFE, 0x78, 0xF3, 0x87, 0x9C, 0x38, 0xFF, 0xC7, 0xF8, 0x3F, 0xE1, 0xC7,
  0x9E, 0x1C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0x0F, 0xC1,
  0xFE, 0x3F, 0xF7, 0x87, 0x70, 0x77, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x1E, 0xE1, 0xEF, 0xFC, 0x7F, 0x83, 0xF0, 0x1F, 0xE0,
  0xFF, 0x87, 0xFE, 0x78, 0xF3, 0xC3, 0x9C, 0x1C, 0xE1, 0xE7, 0x0F, 0x38,
  0x73, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0E, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x80, 0x38, 0x07, 0x80, 0x7F, 0xC7, 0xFC,
  0x7F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0xFE,
  0x7F, 0xE7, 0xFC, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0x70, 0x77, 0x00, 0x70, 0x07, 0x3E,
  0x73, 0xEF, 0x7E, 0xF0, 0xEE, 0x1E, 0xE1, 0xEF, 0xFC, 0x7F, 0x83, 0xF0,
  0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xC3, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC3,
  0x9E, 0x3C, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFC, 0xFF,
  0xCF, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x39, 0xE1, 0xCF, 0x1E, 0x7F,
  0xE1, 0xFF, 0x07, 0xE0, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x3C, 0x3C,
  0xE0, 0xE7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0x9C, 0x1C,
  0x70, 0x71, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x3C, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8D, 0xB6, 0x36,
  0xF8, 0xDB, 0xE7, 0x7B, 0x9D, 0xEE, 0x77, 0x39, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0x1E, 0x38, 0xF1, 0xCF,
  0x8E, 0x7C, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xC7, 0x6E, 0x33, 0x73, 0x9B,
  0x9C, 0xFC, 0xE7, 0xE7, 0x3E, 0x38, 0xF1, 0x87, 0x9C, 0x3C, 0x0F, 0xC1,
  0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xEF,
  0x0E, 0xF1, 0xEE, 0x1E, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x8F, 0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x87, 0x8F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70,
  0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1E, 0xE1, 0xCF, 0xFC, 0x7F,
  0x83, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x1F, 0xE0, 0xFF, 0x87,
  0xFE, 0x78, 0xF3, 0xC3, 0x9C, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xE3, 0xFC,
  0x1E, 0xF0, 0xE3, 0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x9E, 0x1C, 0x07, 0xE0,
  0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE7, 0x0F, 0x3F, 0xF1, 0xFF, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x73, 0x87, 0x78, 0x77, 0x87, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x0E,
  0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1E, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0,
  0xF0, 0x7F, 0x0F, 0xF0, 0xEF, 0x0E, 0x71, 0xC7, 0x1C, 0x73, 0xC7, 0x38,
  0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xC0,
  0x63, 0x1D, 0x9C, 0xE6, 0x73, 0x99, 0x4E, 0xE5, 0x33, 0xB4, 0xCE, 0xF7,
  0x3A, 0xDC, 0xEB, 0x63, 0xED, 0x8F, 0xBE, 0x34, 0xF8, 0xD3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x38, 0xF0, 0x1E, 0x1E, 0x1C, 0x78, 0x3C, 0xE0, 0x3B, 0xC0,
  0x77, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x80, 0xF7, 0x01, 0xCF, 0x07, 0x9E, 0x1E, 0x1C, 0x78, 0x3C, 0xE0, 0x7F,
  0x0F, 0x71, 0xE7, 0x1C, 0x73, 0xC3, 0xB8, 0x3F, 0x03, 0xF0, 0x3E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x3F, 0xF3,
  0xFF, 0x3F, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x0F, 0xC7,
  0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1F, 0xC7, 0xE3, 0xF8, 0xE0,
  0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0xC7, 0xF1, 0xFC, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x1F, 0xC7, 0xE3, 0xF8, 0x0F, 0x03, 0xC1, 0xF0,
  0xEE, 0x3B, 0x9C, 0xE7, 0x1F, 0x87, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF3, 0xCE, 0x1E, 0xF3, 0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x0E,
  0xF1, 0xEE, 0x1C, 0xE1, 0xCF, 0xFC, 0xFF, 0xC7, 0xDC, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3F, 0xE3, 0xBF, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87,
  0x78, 0xF7, 0x0F, 0x78, 0xE7, 0xFE, 0x7F, 0xCF, 0x78, 0x1F, 0xC3, 0xFE,
  0x7F, 0xE7, 0x0E, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE1, 0xEF, 0xFC,
  0x7F, 0x83, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x1E, 0xF3, 0xFE,
  0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCF, 0xFC,
  0xFF, 0xC7, 0xDC, 0x1F, 0xC7, 0xFD, 0xE7, 0xB8, 0x77, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x1E, 0x79, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xF0, 0x1E, 0x00, 0x38, 0x03, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0xF3,
  0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEF, 0x1C, 0xFF, 0xCF,
  0xFC, 0x7D, 0xC0, 0x1C, 0x03, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3F, 0xE3, 0xBF, 0x3F, 0xF3, 0x87, 0x38, 0x73,
  0x87, 0x78, 0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x7F, 0x8F, 0xF0, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x17, 0x8F, 0x3C, 0x71, 0xC7, 0x8E, 0x78, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xEF, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xFE, 0x3F, 0x8F, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xF3, 0xFC, 0x7F, 0x37, 0x71, 0xFF, 0xDC, 0xCE, 0xE6, 0x77, 0x33,
  0xB9, 0x99, 0xDD, 0xCE, 0xCE, 0x66, 0x77, 0x33, 0xB9, 0x9D, 0xCD, 0xC0,
  0x3F, 0xE3, 0xBF, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x78, 0xF7, 0x0F,
  0x70, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0x1F, 0xC7, 0xFD, 0xFF, 0xB8, 0x77,
  0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0x3F,
  0xE3, 0xBF, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x78, 0xF7, 0x0F, 0x78,
  0xE7, 0xFE, 0x7F, 0xC7, 0x78, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0xF3, 0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1C, 0xE1,
  0xCF, 0xFC, 0xFD, 0xC7, 0xDC, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x3B,
  0xE7, 0xFF, 0x7D, 0xF7, 0x8F, 0x70, 0xF7, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0x1C, 0x70, 0x03,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1E, 0x70, 0xF3, 0xCF, 0x1F, 0xF8, 0x7F,
  0x80, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xFF, 0xFF, 0xEF, 0xFE, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1E,
  0xF1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x1C,
  0xF3, 0x8F, 0x38, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xC0,
  0xE7, 0x3F, 0x39, 0xB9, 0xCD, 0xDE, 0xEE, 0xB7, 0x75, 0xB3, 0xEF, 0x9F,
  0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xC7, 0x00, 0x3C, 0x78, 0xE7, 0x87,
  0xB8, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3D, 0xC1, 0xCE,
  0x1E, 0x79, 0xE1, 0xE0, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xF0, 0xEF,
  0x1E, 0xE1, 0xEF, 0x1C, 0xFF, 0xCF, 0xDC, 0x79, 0xC0, 0x1C, 0x03, 0xC7,
  0xF8, 0x7F, 0x0F, 0xE0, 0x3F, 0xEF, 0xFD, 0xFF, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0xFB, 0xFF, 0x7F, 0xE0, 0x01, 0xE0, 0x7C,
  0x1F, 0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0x1F, 0xC3, 0xF0,
  0x7F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0xF0, 0x7E, 0x07,
  0x80, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xC7,
  0x3C, 0xF3, 0x8E, 0x38, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x07, 0xF0, 0xFF, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x18, 0x07,
  0xC7, 0xFE, 0x7E, 0xFF, 0xE7, 0xE0, 0x3C,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 16, 13, 4, -16 },
  { 13, 9, 7, 13, 3, -16 },
  { 21, 14, 16, 13, 0, -16 },
  { 49, 13, 22, 13, 0, -19 },
  { 85, 16, 16, 13, -1, -16 },
  { 117, 13, 16, 13, 0, -16 },
  { 143, 4, 7, 13, 6, -16 },
  { 147, 10, 22, 13, 3, -19 },
  { 175, 10, 22, 13, 1, -19 },
  { 203, 12, 11, 13, 1, -13 },
  { 220, 11, 11, 13, 1, -13 },
  { 236, 6, 7, 13, 2, -3 },
  { 242, 8, 3, 13, 3, -9 },
  { 245, 4, 4, 13, 4, -4 },
  { 247, 14, 20, 13, 0, -18 },
  { 282, 12, 16, 13, 1, -16 },
  { 306, 11, 16, 13, 1, -16 },
  { 328, 12, 16, 13, 1, -16 },
  { 352, 12, 16, 13, 1, -16 },
  { 376, 12, 16, 13, 1, -16 },
  { 400, 12, 16, 13, 1, -16 },
  { 424, 11, 16, 13, 1, -16 },
  { 446, 12, 16, 13, 2, -16 },
  { 470, 12, 16, 13, 1, -16 },
  { 494, 11, 16, 13, 2, -16 },
  { 516, 6, 12, 13, 4, -12 },
  { 525, 8, 16, 13, 2, -12 },
  { 541, 12, 12, 13, 1, -13 },
  { 559, 11, 9, 13, 1, -12 },
  { 572, 11, 12, 13, 1, -13 },
  { 589, 10, 16, 13, 3, -16 },
  { 609, 14, 20, 13, 0, -16 },
  { 644, 12, 16, 13, 0, -16 },
  { 668, 13, 16, 13, 0, -16 },
  { 694, 12, 16, 13, 1, -16 },
  { 718, 13, 16, 13, 0, -16 },
  { 744, 12, 16, 13, 1, -16 },
  { 768, 12, 16, 13, 1, -16 },
  { 792, 12, 16, 13, 1, -16 },
  { 816, 13, 16, 13, 0, -16 },
  { 842, 12, 16, 13, 1, -16 },
  { 866, 13, 16, 13, 0, -16 },
  { 892, 14, 16, 13, 0, -16 },
  { 920, 10, 16, 13, 1, -16 },
  { 940, 14, 16, 13, 0, -16 },
  { 968, 13, 16, 13, 0, -16 },
  { 994, 12, 16, 13, 1, -16 },
  { 1018, 14, 16, 13, 0, -16 },
  { 1046, 12, 20, 13, 1, -16 },
  { 1076, 13, 16, 13, 0, -16 },
  { 1102, 13, 16, 13, 0, -16 },
  { 1128, 12, 16, 13, 2, -16 },
  { 1152, 12, 16, 13, 1, -16 },
  { 1176, 12, 16, 13, 2, -16 },
  { 1200, 14, 16, 13, 1, -16 },
  { 1228, 15, 16, 13, -1, -16 },
  { 1258, 12, 16, 13, 2, -16 },
  { 1282, 12, 16, 13, 1, -16 },
  { 1306, 10, 20, 13, 2, -18 },
  { 1331, 8, 20, 13, 3, -18 },
  { 1351, 10, 20, 13, 1, -18 },
  { 1376, 10, 9, 13, 2, -16 },
  { 1388, 11, 3, 13, 0, 1 },
  { 1393, 5, 3, 13, 5, -17 },
  { 1395, 12, 12, 13, 1, -12 },
  { 1413, 12, 16, 13, 0, -16 },
  { 1437, 12, 12, 13, 1, -12 },
  { 1455, 12, 16, 13, 1, -16 },
  { 1479, 11, 12, 13, 1, -12 },
  { 1496, 15, 20, 13, -1, -16 },
  { 1534, 12, 16, 13, 1, -12 },
  { 1558, 12, 16, 13, 0, -16 },
  { 1582, 11, 17, 13, 1, -17 },
  { 1606, 12, 21, 13, 0, -17 },
  { 1638, 13, 16, 13, 1, -16 },
  { 1664, 10, 16, 13, 2, -16 },
  { 1684, 13, 12, 13, 0, -12 },
  { 1704, 12, 12, 13, 0, -12 },
  { 1722, 11, 12, 13, 1, -12 },
  { 1739, 12, 16, 13, 0, -12 },
  { 1763, 12, 16, 13, 1, -12 },
  { 1787, 12, 12, 13, 1, -12 },
  { 1805, 13, 12, 13, 0, -12 },
  { 1825, 12, 15, 13, 1, -15 },
  { 1848, 12, 12, 13, 1, -12 },
  { 1866, 12, 12, 13, 2, -12 },
  { 1884, 13, 12, 13, 1, -12 },
  { 1904, 13, 12, 13, 0, -12 },
  { 1924, 12, 16, 13, 1, -12 },
  { 1948, 11, 12, 13, 1, -12 },
  { 1965, 11, 20, 13, 2, -18 },
  { 1993, 6, 20, 13, 4, -18 },
  { 2008, 12, 20, 13, 0, -18 },
  { 2038, 12, 6, 13, 1, -11 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC22PT7B_H_
