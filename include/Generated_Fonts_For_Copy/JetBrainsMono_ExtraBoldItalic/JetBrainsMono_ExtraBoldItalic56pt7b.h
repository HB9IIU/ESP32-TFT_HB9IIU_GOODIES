#ifndef _JETBRAINSMONO_EXTRABOLDITALIC56PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0x7F, 0xDF,
  0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1,
  0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x73, 0xFF, 0x07,
  0xFC, 0xF1, 0xFF, 0x07, 0xF8, 0xF1, 0xFF, 0x07, 0xF8, 0xF1, 0xFF, 0x0F,
  0xF8, 0xF0, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x0F,
  0xFD, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x9F, 0xF8, 0x00,
  0x03, 0x8F, 0xFC, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x07, 0x87, 0xF8, 0x00,
  0x07, 0x87, 0xF8, 0x7F, 0x87, 0x87, 0xF8, 0x7F, 0x87, 0x0F, 0xF8, 0x7F,
  0xC7, 0x0F, 0xF8, 0x7F, 0xE7, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x07, 0xC7,
  0xE0, 0x00, 0x1F, 0x87, 0xE7, 0xE0, 0x00, 0x0F, 0xFF, 0xE7, 0xE0, 0x00,
  0x03, 0xFF, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xE0, 0x00, 0x00, 0x3F,
  0xE7, 0xE0, 0x00, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x03,
  0xF3, 0xFF, 0xC0, 0x00, 0x03, 0xF3, 0xFF, 0xE0, 0x00, 0x03, 0xF3, 0xFF,
  0xF8, 0x00, 0x01, 0xF3, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x0F, 0x80, 0x01, 0xF8,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x03, 0xFB, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xBF, 0xC3,
  0xFC, 0x7F, 0xDF, 0xF3, 0xFC, 0x3F, 0xC7, 0xF9, 0xFE, 0x1F, 0xE3, 0xFF,
  0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x1F,
  0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0x8F, 0xF0, 0x07,
  0xFF, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xF7, 0xFD,
  0xFE, 0x7F, 0x9F, 0xE7, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0E, 0x01, 0xF8, 0x0E, 0x1F, 0x03, 0xE0, 0xFC,
  0x7F, 0x87, 0xC3, 0xF8, 0xFF, 0x8F, 0x1F, 0xF3, 0xFF, 0x9E, 0xFF, 0xF7,
  0xFF, 0xBB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x5F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE1, 0x03, 0xFC, 0x3F, 0x8F, 0x87, 0xF8, 0xFF, 0x3F, 0x9F,
  0xE1, 0xFE, 0x7F, 0x3F, 0xC3, 0xFC, 0xFE, 0x7F, 0x87, 0xF9, 0xFC, 0xFF,
  0x0F, 0xF3, 0xF9, 0xFE, 0x1F, 0xE3, 0xE3, 0xFC, 0x7F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0x7C, 0x1F, 0xE0,
  0x0F, 0x01, 0xFE, 0x00, 0xE0, 0x1F, 0xE0, 0x08, 0x01, 0xFE, 0x01, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80,
  0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0x80, 0x07, 0xF9, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x7E, 0x00, 0x7F, 0xCF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE,
  0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xBF, 0xE0, 0x03, 0xF9, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x02, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE2, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x70, 0x7E, 0x0F, 0xE0, 0x3F,
  0xC7, 0xE0, 0xFE, 0x07, 0xFE, 0x7E, 0x0F, 0xE0, 0xFF, 0xF7, 0xE0, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x7F, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x07, 0xE0,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xBF, 0x07, 0xF0, 0x3F, 0xF3, 0xF0,
  0x7E, 0x03, 0xFE, 0x3F, 0x07, 0xE0, 0x0F, 0x84, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x7F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x87,
  0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0x7C, 0x1F, 0x7E, 0x07, 0xEF, 0x83,
  0xFF, 0xC0, 0xFD, 0xF0, 0xFF, 0xF8, 0x1F, 0xBE, 0x1F, 0x7F, 0x03, 0xF7,
  0xC3, 0xEF, 0xC0, 0xFE, 0xF8, 0xFB, 0xF8, 0x1F, 0xDF, 0x1F, 0x7F, 0x03,
  0xF9, 0xF7, 0xCF, 0xE0, 0x7F, 0x3E, 0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0x3F,
  0x81, 0xFC, 0xFF, 0xCF, 0xF0, 0x7F, 0x9F, 0xF9, 0xFC, 0x0F, 0xF3, 0xFE,
  0x3F, 0x81, 0xFE, 0x7F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF9, 0xFE, 0x07, 0xF1,
  0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0x81, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0x03, 0xF8, 0x1F,
  0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x03,
  0xF7, 0xE0, 0x7F, 0x81, 0xFB, 0xF0, 0x3F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC0,
  0xFE, 0xFC, 0x0F, 0xE0, 0x7F, 0x7E, 0x07, 0xF0, 0x3F, 0xBF, 0x83, 0xF8,
  0x1F, 0xCF, 0xC3, 0xFC, 0x0F, 0xE7, 0xE1, 0xFE, 0x07, 0xF3, 0xF0, 0xFF,
  0x07, 0xF9, 0xF8, 0x7F, 0x03, 0xFC, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x1F,
  0xC0, 0xFE, 0x1F, 0x8F, 0xE0, 0x7F, 0x0F, 0xC7, 0xF0, 0x3F, 0x87, 0xE7,
  0xF8, 0x3F, 0xC3, 0xF3, 0xF8, 0x1F, 0xE1, 0xFD, 0xFC, 0x0F, 0xF0, 0x7E,
  0xFE, 0x07, 0xF0, 0x3F, 0x7F, 0x03, 0xF8, 0x1F, 0xBF, 0x81, 0xFC, 0x0F,
  0xDF, 0xC0, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x80,
  0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFC, 0x0F, 0xE0,
  0x1F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F,
  0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x5F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x3F, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF,
  0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0x81, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xC1, 0xFC, 0x7F, 0x07, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFF, 0x07, 0xE1, 0xFC, 0x1D, 0xE1, 0xFC, 0x3F, 0x87,
  0xBC, 0x3F, 0x87, 0xF0, 0xF7, 0x87, 0xF0, 0xFC, 0x1F, 0xF0, 0xFC, 0x1F,
  0x87, 0xFC, 0x1F, 0x83, 0xF0, 0xF7, 0x87, 0xF0, 0x7E, 0x1E, 0xF0, 0xFE,
  0x0F, 0xC3, 0xDE, 0x1F, 0x81, 0xF8, 0xFB, 0xC3, 0xF0, 0x7F, 0x1E, 0x78,
  0xFE, 0x0F, 0xE3, 0xCF, 0x1F, 0xC1, 0xFC, 0x79, 0xE3, 0xF0, 0x3F, 0x9E,
  0x3C, 0x7E, 0x07, 0xF3, 0xC7, 0x9F, 0xC0, 0xFE, 0x78, 0xF3, 0xF8, 0x1F,
  0x9F, 0x1E, 0x7E, 0x03, 0xF3, 0xC3, 0xCF, 0xC0, 0x7E, 0x78, 0x79, 0xF8,
  0x0F, 0xCF, 0x0F, 0x7F, 0x01, 0xFB, 0xE1, 0xEF, 0xC0, 0x3F, 0x78, 0x7D,
  0xF8, 0x07, 0xEF, 0x0F, 0xBF, 0x00, 0xFD, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3D, 0xF8, 0x03, 0xFF, 0x07, 0xBF, 0x00, 0xFF, 0xE0, 0xF7, 0xE0, 0x1F,
  0xBC, 0x1E, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0x3F,
  0xC0, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x7F,
  0xBF, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFB,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0xFC, 0x0F,
  0xF7, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xC0, 0x7F, 0xCF, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xF3, 0xFC, 0x03,
  0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF,
  0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFF,
  0x8F, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F,
  0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00,
  0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xF3, 0xFC, 0x03,
  0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x3F,
  0xC7, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xE3, 0xF0, 0xFE, 0x03, 0xF3, 0xF8, 0xFF, 0x83, 0xFB,
  0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xDF, 0xF7, 0xFC, 0x3F, 0x87, 0xE1, 0xFE, 0x1F, 0xC3, 0xF0, 0xFF, 0x1F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x3E, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0x87, 0xF8,
  0xFF, 0x0F, 0xC3, 0xF8, 0x7F, 0x87, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xE3, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x0F, 0x83, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xE1,
  0xFE, 0x1F, 0xC3, 0xF0, 0xFF, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xF0, 0xFC,
  0x3F, 0x87, 0xF0, 0x7C, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0,
  0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xE7,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x03,
  0xFC, 0x7F, 0xF0, 0x03, 0xFD, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xC0, 0x3F,
  0xDF, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F,
  0xC0, 0x40, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0x8F, 0xF0, 0x1F,
  0xFF, 0x3F, 0xC0, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F,
  0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00,
  0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xEF, 0xF0,
  0x3F, 0xFF, 0x3F, 0xC0, 0x7F, 0xF9, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x30, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF3, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF,
  0xE0, 0x7F, 0xBF, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7,
  0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x07, 0xE0,
  0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7E, 0xFE, 0x0F, 0xE0,
  0x7E, 0xFC, 0x0F, 0xE0, 0xFE, 0xFC, 0x1F, 0xE0, 0xFE, 0xFC, 0x1F, 0xE0,
  0xFC, 0xFC, 0x1D, 0xE1, 0xFC, 0xFC, 0x3D, 0xE1, 0xFC, 0xFC, 0x3D, 0xE1,
  0xF8, 0xFC, 0x3D, 0xE1, 0xF8, 0xFC, 0x79, 0xE3, 0xF8, 0xFC, 0x79, 0xE3,
  0xF0, 0xFC, 0x79, 0xE3, 0xF0, 0xFC, 0xF1, 0xE7, 0xF0, 0xFC, 0xF1, 0xE7,
  0xE0, 0xFC, 0xF1, 0xE7, 0xE0, 0xFC, 0xF1, 0xEF, 0xE0, 0xFD, 0xE1, 0xEF,
  0xE0, 0xFD, 0xE1, 0xEF, 0xC0, 0xFD, 0xE1, 0xEF, 0xC0, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F,
  0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBF, 0xC0, 0xFF,
  0xFC, 0xFF, 0x01, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xF0,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x03, 0xF8, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFC, 0x0F,
  0xC7, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF, 0xF8, 0x7F, 0x3F, 0x8F, 0xF8, 0xFE,
  0x7E, 0x0F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xE7,
  0xF0, 0x1F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 41, 34, 10, -41 },
  { 78, 23, 17, 34, 8, -41 },
  { 127, 35, 41, 34, 0, -41 },
  { 307, 32, 57, 34, 1, -49 },
  { 535, 41, 41, 34, -3, -41 },
  { 746, 33, 42, 34, 0, -41 },
  { 920, 10, 17, 34, 15, -41 },
  { 942, 25, 54, 34, 7, -47 },
  { 1111, 24, 54, 34, 3, -47 },
  { 1273, 31, 29, 34, 2, -34 },
  { 1386, 29, 27, 34, 3, -32 },
  { 1484, 17, 17, 34, 4, -8 },
  { 1521, 21, 7, 34, 7, -22 },
  { 1540, 12, 12, 34, 9, -11 },
  { 1558, 37, 52, 34, -1, -46 },
  { 1799, 31, 42, 34, 2, -41 },
  { 1962, 28, 41, 34, 2, -41 },
  { 2106, 32, 41, 34, 1, -41 },
  { 2270, 31, 42, 34, 2, -41 },
  { 2433, 30, 41, 34, 2, -41 },
  { 2587, 31, 42, 34, 2, -41 },
  { 2750, 29, 42, 34, 2, -41 },
  { 2903, 31, 41, 34, 4, -41 },
  { 3062, 32, 42, 34, 1, -41 },
  { 3230, 30, 41, 34, 4, -41 },
  { 3384, 15, 32, 34, 9, -31 },
  { 3444, 20, 40, 34, 4, -31 },
  { 3544, 29, 31, 34, 4, -34 },
  { 3657, 28, 21, 34, 3, -29 },
  { 3731, 29, 31, 34, 2, -34 },
  { 3844, 26, 41, 34, 6, -41 },
  { 3978, 36, 51, 34, -1, -41 },
  { 4208, 31, 41, 34, -1, -41 },
  { 4367, 33, 41, 34, 1, -41 },
  { 4537, 31, 42, 34, 2, -41 },
  { 4700, 32, 41, 34, 1, -41 },
  { 4864, 32, 41, 34, 2, -41 },
  { 5028, 33, 41, 34, 1, -41 },
  { 5198, 31, 42, 34, 2, -41 },
  { 5361, 33, 41, 34, 1, -41 },
  { 5531, 31, 41, 34, 2, -41 },
  { 5690, 33, 42, 34, 0, -41 },
  { 5864, 35, 41, 34, 1, -41 },
  { 6044, 26, 41, 34, 3, -41 },
  { 6178, 35, 41, 34, 0, -41 },
  { 6358, 33, 41, 34, 1, -41 },
  { 6528, 31, 42, 34, 2, -41 },
  { 6691, 34, 41, 34, 1, -41 },
  { 6866, 31, 51, 34, 2, -41 },
  { 7064, 33, 41, 34, 1, -41 },
  { 7234, 32, 42, 34, 1, -41 },
  { 7402, 30, 41, 34, 5, -41 },
  { 7556, 32, 42, 34, 2, -41 },
  { 7724, 31, 41, 34, 5, -41 },
  { 7883, 35, 41, 34, 2, -41 },
  { 8063, 37, 41, 34, -1, -41 },
  { 8253, 32, 41, 34, 5, -41 },
  { 8417, 31, 41, 34, 2, -41 },
  { 8576, 25, 52, 34, 6, -46 },
  { 8739, 19, 52, 34, 8, -46 },
  { 8863, 25, 52, 34, 4, -46 },
  { 9026, 27, 22, 34, 4, -41 },
  { 9101, 29, 8, 34, -1, 1 },
  { 9130, 14, 8, 34, 13, -44 },
  { 9144, 30, 32, 34, 2, -31 },
  { 9264, 31, 42, 34, 1, -41 },
  { 9427, 30, 32, 34, 2, -31 },
  { 9547, 32, 42, 34, 2, -41 },
  { 9715, 29, 32, 34, 2, -31 },
  { 9831, 38, 51, 34, -3, -41 },
  { 10074, 30, 41, 34, 2, -31 },
  { 10228, 31, 41, 34, 1, -41 },
  { 10387, 29, 44, 34, 1, -44 },
  { 10547, 31, 54, 34, 0, -44 },
  { 10757, 34, 41, 34, 1, -41 },
  { 10932, 26, 41, 34, 4, -41 },
  { 11066, 33, 31, 34, 0, -31 },
  { 11194, 31, 31, 34, 1, -31 },
  { 11315, 29, 32, 34, 2, -31 },
  { 11431, 32, 41, 34, 0, -31 },
  { 11595, 30, 41, 34, 2, -31 },
  { 11749, 31, 31, 34, 2, -31 },
  { 11870, 31, 32, 34, 1, -31 },
  { 11994, 29, 39, 34, 3, -39 },
  { 12136, 30, 32, 34, 2, -31 },
  { 12256, 31, 31, 34, 4, -31 },
  { 12377, 32, 31, 34, 3, -31 },
  { 12501, 35, 31, 34, -1, -31 },
  { 12637, 30, 41, 34, 2, -31 },
  { 12791, 30, 31, 34, 1, -31 },
  { 12908, 30, 52, 34, 4, -46 },
  { 13103, 17, 52, 34, 9, -46 },
  { 13214, 30, 52, 34, 1, -46 },
  { 13409, 31, 14, 34, 2, -27 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC56PT7B_H_
