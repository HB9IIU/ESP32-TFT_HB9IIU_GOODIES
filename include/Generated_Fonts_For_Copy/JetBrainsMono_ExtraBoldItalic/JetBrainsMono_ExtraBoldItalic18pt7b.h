#ifndef _JETBRAINSMONO_EXTRABOLDITALIC18PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x19, 0xCE, 0x60, 0x01, 0xCE, 0x00, 0xEF, 0xDF,
  0xBE, 0x6C, 0xC0, 0x06, 0x61, 0x98, 0x33, 0x1F, 0xF7, 0xFE, 0x33, 0x06,
  0x61, 0x98, 0xFF, 0xDF, 0xF9, 0x98, 0x33, 0x0E, 0x60, 0x03, 0x00, 0x40,
  0x08, 0x07, 0xE1, 0xFC, 0x75, 0xCD, 0x81, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x02, 0xE6, 0x5C, 0xFF, 0x1F, 0xE1, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x1E, 0x19, 0x99, 0x8C, 0x98, 0x65, 0x83, 0xF8, 0x0E, 0x80, 0x0C, 0x00,
  0xFC, 0x0F, 0xE0, 0xD9, 0x0C, 0xD8, 0xC6, 0xCC, 0x3C, 0x00, 0x0F, 0x83,
  0xF8, 0x67, 0x1C, 0x01, 0x80, 0x78, 0x1F, 0x0B, 0x7E, 0x67, 0x9C, 0xF3,
  0x9C, 0x7F, 0xC7, 0xDC, 0xFF, 0xEC, 0x03, 0x07, 0x1F, 0x1C, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x70, 0x70, 0x7C, 0x3C, 0x0C, 0x10,
  0x3C, 0x3E, 0x0E, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x1C,
  0x3C, 0xF8, 0xF0, 0xC0, 0x0E, 0x03, 0x04, 0xCB, 0xAE, 0xFF, 0xC7, 0x03,
  0x61, 0xDC, 0xE6, 0x11, 0x00, 0x0E, 0x06, 0x07, 0x1F, 0xFF, 0xF8, 0xE0,
  0x70, 0x30, 0x1C, 0xE3, 0x9C, 0x63, 0x80, 0xFF, 0xFC, 0xFF, 0xE0, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x00, 0x1F,
  0x0F, 0xE7, 0x19, 0x86, 0x61, 0xBB, 0x6F, 0xFB, 0xAE, 0xE3, 0xB0, 0xCE,
  0x73, 0xFC, 0x7C, 0x00, 0x0F, 0x1F, 0x1D, 0x8D, 0xC4, 0xE0, 0x70, 0x38,
  0x1C, 0x0C, 0x06, 0x07, 0x1F, 0xFF, 0xF0, 0x0F, 0x83, 0xF8, 0xE7, 0x18,
  0x60, 0x1C, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x3F, 0xCF,
  0xF8, 0x3F, 0x9F, 0xD0, 0xE0, 0xC1, 0xC0, 0xF8, 0x7E, 0x07, 0x03, 0xE1,
  0xB9, 0xDF, 0xE7, 0xC0, 0x03, 0x83, 0x83, 0x83, 0x83, 0x83, 0x9F, 0xCF,
  0xC7, 0xFF, 0x7F, 0xBF, 0xC0, 0xE0, 0x70, 0x3F, 0xDF, 0xE7, 0x01, 0xC0,
  0x76, 0x1F, 0xC7, 0xF8, 0x0E, 0x03, 0x80, 0xCE, 0x73, 0xFC, 0x7C, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0F, 0xE7, 0xFD, 0xC7, 0x61, 0xD8,
  0x77, 0x39, 0xFE, 0x3E, 0x00, 0x7F, 0xDF, 0xF6, 0x1F, 0x8E, 0x03, 0x81,
  0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0x1C, 0x63, 0x9C, 0x3F, 0x07, 0xC1, 0xDC, 0x71, 0xCC, 0x39,
  0xCE, 0x3F, 0xC3, 0xF0, 0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0xE1, 0xFC, 0xE7,
  0xF8, 0xFC, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x3B, 0xDC, 0x00,
  0x00, 0x0C, 0xF7, 0x00, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x38,
  0x71, 0xC3, 0x0E, 0x00, 0x00, 0x81, 0xC3, 0xEF, 0xCF, 0x07, 0x83, 0xF0,
  0x3E, 0x07, 0x00, 0x80, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xFB, 0xFC,
  0x40, 0x38, 0x1F, 0x03, 0xE0, 0x78, 0x3C, 0x7D, 0xF8, 0xE0, 0x40, 0x00,
  0x7E, 0x7F, 0x07, 0x07, 0x07, 0x3E, 0x7C, 0x70, 0x60, 0x00, 0x00, 0xE0,
  0xE0, 0x0F, 0xC3, 0xFC, 0xC1, 0xB8, 0x36, 0x36, 0xCF, 0xDB, 0x3B, 0x67,
  0xEC, 0xD9, 0x9B, 0x3F, 0x67, 0x6C, 0x01, 0xC0, 0x1F, 0x01, 0xE0, 0x07,
  0x03, 0xE0, 0xF8, 0x7E, 0x1F, 0x86, 0x63, 0x98, 0xE6, 0x7F, 0x9F, 0xE6,
  0x1B, 0x86, 0xE1, 0xC0, 0x3F, 0x87, 0xF8, 0xE3, 0x9C, 0x63, 0x1C, 0x7F,
  0x1F, 0xE3, 0x8E, 0x71, 0xCE, 0x39, 0x8E, 0x3F, 0xCF, 0xE0, 0x1F, 0x8F,
  0xE7, 0x1D, 0x87, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE, 0x73,
  0xFC, 0x7C, 0x00, 0x3F, 0x87, 0xF8, 0xE7, 0x9C, 0x73, 0x0C, 0x61, 0x9C,
  0x73, 0x8E, 0x71, 0xCE, 0x39, 0xFE, 0x3F, 0x8F, 0xE0, 0x3F, 0xDF, 0xF7,
  0x01, 0xC0, 0x70, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0xE0, 0x1C, 0x03, 0x00, 0x7F, 0x8F, 0xE3,
  0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x1F, 0x8F, 0xE7, 0x1D,
  0x87, 0x60, 0x38, 0x0E, 0xFB, 0xBE, 0xE3, 0xB8, 0xEE, 0x73, 0xFC, 0x7C,
  0x00, 0x38, 0xE7, 0x1C, 0xE3, 0x1C, 0x63, 0x1C, 0x7F, 0x9F, 0xF3, 0x8E,
  0x71, 0xCE, 0x31, 0x86, 0x31, 0xCE, 0x38, 0x3F, 0xDF, 0xE0, 0xE0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x83, 0xFC, 0xFF, 0x00,
  0x07, 0xE0, 0xF8, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x9C, 0x73, 0x8E, 0x3F, 0x87, 0xE0, 0x38, 0xF3, 0x8E, 0x39, 0xC3, 0xB8,
  0x33, 0x83, 0xF0, 0x7F, 0x07, 0x70, 0x73, 0x07, 0x38, 0x63, 0x86, 0x38,
  0xE1, 0xC0, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xFF, 0xFF, 0xFF, 0x38, 0xE7, 0x1C, 0xE7, 0xBE, 0xB7, 0xFE, 0xDD, 0x9B,
  0xB3, 0x06, 0x60, 0xCC, 0x3B, 0x87, 0x70, 0xCE, 0x18, 0x3C, 0x67, 0x9C,
  0xF3, 0x9E, 0x63, 0xCC, 0xF9, 0x9D, 0xB3, 0xB6, 0x67, 0xCC, 0xF1, 0x9E,
  0x31, 0xCE, 0x38, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0x61, 0xB8, 0xEE, 0x3B,
  0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0xFC, 0x7C, 0x00, 0x3F, 0x87, 0xF8, 0xE3,
  0x9C, 0x73, 0x0E, 0x63, 0x9F, 0xF3, 0xFC, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0x61, 0xB8, 0xEE, 0x3B, 0x8E,
  0xE3, 0xB8, 0xCE, 0x73, 0xFC, 0x7C, 0x03, 0x00, 0xE0, 0x1C, 0x3F, 0x87,
  0xF8, 0xE7, 0x9C, 0x73, 0x0E, 0x63, 0x9F, 0xE3, 0xF8, 0x77, 0x0E, 0x61,
  0x8E, 0x31, 0xCE, 0x38, 0x0F, 0xC3, 0xF8, 0xE3, 0x98, 0x03, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xCC, 0x39, 0xCE, 0x3F, 0xC3, 0xE0, 0xFF, 0xFF,
  0xC7, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x00, 0x71, 0xDC, 0x77, 0x1D, 0x86, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3,
  0xB8, 0xCE, 0x73, 0xFC, 0x7C, 0x00, 0xE1, 0xF8, 0xEE, 0x3B, 0x8C, 0xE7,
  0x39, 0x8E, 0xE3, 0xB8, 0x6C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x00, 0xEE,
  0x7D, 0xDB, 0x3B, 0x67, 0x6D, 0xCD, 0xAB, 0x35, 0x66, 0xAC, 0xF5, 0x9C,
  0xE3, 0x9C, 0x73, 0x8E, 0x70, 0x38, 0xF3, 0x9C, 0x1D, 0xC1, 0xF8, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xF0, 0x1F, 0x03, 0xB0, 0x73, 0x87, 0x38, 0xE1,
  0xC0, 0xC1, 0xF8, 0xEE, 0x71, 0x9C, 0x6E, 0x1F, 0x07, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x00, 0x3F, 0xCF, 0xE4, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0xF3, 0xFC, 0xFF, 0x00, 0x1F,
  0x3F, 0x3F, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xFC, 0xFC, 0xFC, 0xE0, 0xC1, 0xC3, 0x87, 0x06, 0x0E, 0x1C, 0x38,
  0x70, 0x60, 0xE1, 0xC3, 0x83, 0x06, 0x0E, 0x1F, 0x1F, 0x3F, 0x07, 0x07,
  0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x7C, 0xFC, 0xFC,
  0x0E, 0x0F, 0x06, 0xC7, 0x63, 0x33, 0x9F, 0x8E, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE3, 0xC0, 0x3D, 0xBE, 0xDC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8D, 0xCE, 0xFF,
  0x3F, 0x80, 0x38, 0x0E, 0x03, 0x80, 0xFE, 0x37, 0xCE, 0x77, 0x1D, 0xC7,
  0x71, 0xDC, 0x67, 0x39, 0xFE, 0xEF, 0x00, 0x1F, 0x3F, 0xDC, 0xFC, 0x7E,
  0x07, 0x03, 0x8F, 0xCE, 0xFF, 0x3E, 0x00, 0x01, 0xC0, 0x70, 0x18, 0xF6,
  0x7D, 0x9C, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0xFC, 0x7F, 0x00,
  0x1F, 0x3F, 0xD8, 0xFC, 0x7F, 0xFF, 0xFF, 0x01, 0xCE, 0xFF, 0x3E, 0x00,
  0x01, 0xF0, 0x3F, 0x07, 0x00, 0x70, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xFC, 0x0F, 0x80,
  0x3D, 0xBE, 0xDC, 0xFC, 0x7E, 0x3F, 0x1F, 0x9D, 0xFE, 0x7F, 0x03, 0x81,
  0xCF, 0xCF, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xFE, 0x37, 0xCE, 0x77, 0x1D,
  0xC7, 0x71, 0xDC, 0x66, 0x19, 0x8E, 0xE3, 0x80, 0x03, 0x81, 0xE0, 0x20,
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x7F,
  0xFF, 0xE0, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x1F, 0x87, 0xE3, 0xF8, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0xF3, 0xF8, 0xFC, 0x00,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x73, 0x1C, 0x67, 0x1C, 0xE3, 0xF8, 0x7F,
  0x0E, 0xE1, 0xCE, 0x31, 0xCE, 0x3C, 0x7E, 0x7E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x03, 0xF1, 0xF0, 0x7F, 0xCD, 0xFD,
  0xDB, 0x33, 0x66, 0x4C, 0xD9, 0x9B, 0x37, 0x6E, 0xED, 0xD9, 0xB0, 0x3F,
  0x8D, 0xF3, 0x9D, 0xC7, 0x71, 0xDC, 0x77, 0x19, 0x86, 0x63, 0xB8, 0xE0,
  0x1F, 0x3F, 0xDC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8D, 0xCE, 0xFF, 0x3E, 0x00,
  0x3F, 0x8D, 0xF3, 0x9D, 0xC7, 0x71, 0xDC, 0x77, 0x19, 0xCE, 0x7F, 0xBB,
  0xCE, 0x03, 0x80, 0xE0, 0x00, 0x3D, 0xBE, 0xDC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8D, 0xCE, 0xFF, 0x3F, 0x81, 0xC0, 0xE0, 0x60, 0x77, 0x9F, 0xE7, 0x3D,
  0x86, 0x63, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x1F, 0x8F, 0xF3,
  0x1D, 0xC0, 0x3F, 0x07, 0xE0, 0x1D, 0x86, 0x7F, 0x8F, 0xC0, 0x1C, 0x0E,
  0x07, 0x1F, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE1,
  0xF0, 0x71, 0xB1, 0xD8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8D, 0xCE, 0xFE, 0x3E,
  0x00, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x77, 0x1D, 0x87, 0xE0, 0xF8, 0x3C,
  0x0F, 0x00, 0xCC, 0xF3, 0x3D, 0xCF, 0x56, 0xD5, 0xB5, 0x6F, 0x73, 0x9C,
  0xE7, 0x39, 0xC0, 0x79, 0xE7, 0x38, 0x6E, 0x0F, 0x80, 0xE0, 0x3C, 0x07,
  0xC1, 0xF8, 0x73, 0x9C, 0x78, 0x73, 0xB1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1B,
  0x9D, 0xFE, 0x7F, 0x03, 0x81, 0xDF, 0xCF, 0xC0, 0x3F, 0xCF, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0xBF, 0xE0, 0x01, 0xC1, 0xF0,
  0x7C, 0x18, 0x06, 0x01, 0x80, 0xE1, 0xF8, 0x78, 0x3F, 0x00, 0xE0, 0x30,
  0x1C, 0x07, 0x01, 0xF0, 0x7C, 0x0E, 0x00, 0x19, 0xCE, 0x73, 0x98, 0xCE,
  0x73, 0x9C, 0xE6, 0x73, 0x9C, 0xE0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0x07, 0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x07,
  0x83, 0xE0, 0xF0, 0x00, 0x30, 0x3E, 0x7D, 0xDB, 0x3E, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 7, 5, 11, 3, -13 },
  { 15, 11, 13, 11, 0, -13 },
  { 33, 11, 19, 11, 0, -16 },
  { 60, 13, 13, 11, -1, -13 },
  { 82, 11, 13, 11, 0, -13 },
  { 100, 3, 5, 11, 5, -13 },
  { 102, 8, 17, 11, 2, -15 },
  { 119, 8, 17, 11, 1, -15 },
  { 136, 10, 10, 11, 1, -11 },
  { 149, 9, 8, 11, 1, -10 },
  { 158, 6, 6, 11, 1, -3 },
  { 163, 7, 2, 11, 2, -7 },
  { 165, 4, 3, 11, 3, -3 },
  { 167, 11, 17, 11, 0, -15 },
  { 191, 10, 13, 11, 1, -13 },
  { 208, 9, 13, 11, 1, -13 },
  { 223, 11, 13, 11, 0, -13 },
  { 241, 9, 13, 11, 1, -13 },
  { 256, 9, 13, 11, 1, -13 },
  { 271, 10, 13, 11, 1, -13 },
  { 288, 10, 13, 11, 0, -13 },
  { 305, 10, 13, 11, 1, -13 },
  { 322, 11, 13, 11, 0, -13 },
  { 340, 10, 13, 11, 1, -13 },
  { 357, 5, 10, 11, 3, -10 },
  { 364, 7, 13, 11, 1, -10 },
  { 376, 9, 10, 11, 1, -11 },
  { 388, 9, 7, 11, 1, -9 },
  { 396, 9, 10, 11, 1, -11 },
  { 408, 8, 13, 11, 2, -13 },
  { 421, 11, 16, 11, 0, -13 },
  { 443, 10, 13, 11, 0, -13 },
  { 460, 11, 13, 11, 0, -13 },
  { 478, 10, 13, 11, 1, -13 },
  { 495, 11, 13, 11, 0, -13 },
  { 513, 10, 13, 11, 1, -13 },
  { 530, 11, 13, 11, 0, -13 },
  { 548, 10, 13, 11, 1, -13 },
  { 565, 11, 13, 11, 0, -13 },
  { 583, 10, 13, 11, 1, -13 },
  { 600, 11, 13, 11, 0, -13 },
  { 618, 12, 13, 11, 0, -13 },
  { 638, 8, 13, 11, 1, -13 },
  { 651, 11, 13, 11, 0, -13 },
  { 669, 11, 13, 11, 0, -13 },
  { 687, 10, 13, 11, 1, -13 },
  { 704, 11, 13, 11, 0, -13 },
  { 722, 10, 16, 11, 1, -13 },
  { 742, 11, 13, 11, 0, -13 },
  { 760, 11, 13, 11, 0, -13 },
  { 778, 9, 13, 11, 2, -13 },
  { 793, 10, 13, 11, 1, -13 },
  { 810, 10, 13, 11, 2, -13 },
  { 827, 11, 13, 11, 1, -13 },
  { 845, 12, 13, 11, 0, -13 },
  { 865, 10, 13, 11, 2, -13 },
  { 882, 10, 13, 11, 1, -13 },
  { 899, 8, 17, 11, 2, -15 },
  { 916, 7, 17, 11, 2, -15 },
  { 931, 8, 17, 11, 1, -15 },
  { 948, 9, 7, 11, 1, -13 },
  { 956, 9, 3, 11, 0, 0 },
  { 960, 5, 2, 11, 4, -14 },
  { 962, 9, 10, 11, 1, -10 },
  { 974, 10, 13, 11, 0, -13 },
  { 991, 9, 10, 11, 1, -10 },
  { 1003, 10, 13, 11, 1, -13 },
  { 1020, 9, 10, 11, 1, -10 },
  { 1032, 12, 16, 11, -1, -13 },
  { 1056, 9, 13, 11, 1, -10 },
  { 1071, 10, 13, 11, 0, -13 },
  { 1088, 10, 14, 11, 0, -14 },
  { 1106, 10, 17, 11, 0, -14 },
  { 1128, 11, 13, 11, 0, -13 },
  { 1146, 9, 13, 11, 1, -13 },
  { 1161, 11, 10, 11, 0, -10 },
  { 1175, 10, 10, 11, 0, -10 },
  { 1188, 9, 10, 11, 1, -10 },
  { 1200, 10, 13, 11, 0, -10 },
  { 1217, 9, 13, 11, 1, -10 },
  { 1232, 10, 10, 11, 1, -10 },
  { 1245, 10, 10, 11, 0, -10 },
  { 1258, 9, 13, 11, 1, -13 },
  { 1273, 9, 10, 11, 1, -10 },
  { 1285, 10, 10, 11, 1, -10 },
  { 1298, 10, 10, 11, 1, -10 },
  { 1311, 11, 10, 11, 0, -10 },
  { 1325, 9, 13, 11, 1, -10 },
  { 1340, 10, 10, 11, 0, -10 },
  { 1353, 10, 17, 11, 1, -15 },
  { 1375, 5, 17, 11, 3, -15 },
  { 1386, 10, 17, 11, 0, -15 },
  { 1408, 10, 5, 11, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC18PT7B_H_
