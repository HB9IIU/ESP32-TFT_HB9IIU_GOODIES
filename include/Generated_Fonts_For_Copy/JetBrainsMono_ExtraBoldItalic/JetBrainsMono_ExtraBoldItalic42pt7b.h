#ifndef _JETBRAINSMONO_EXTRABOLDITALIC42PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x00,
  0x3F, 0x1F, 0xDF, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x01, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xCE, 0x7F, 0x1F, 0xCE, 0x7F, 0x1F, 0x8E, 0x7E, 0x1F, 0x8C, 0x00, 0x1F,
  0xDC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3B, 0xFC, 0x00, 0x39, 0xFC, 0x00, 0x31, 0xFC, 0x00,
  0x31, 0xFC, 0xFE, 0x71, 0xFC, 0xFE, 0x71, 0xF8, 0xFF, 0x77, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0xF8, 0x0F, 0xFE, 0x01, 0xE0, 0x3F, 0xFC, 0x07, 0x80,
  0x78, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x78, 0x03, 0xE1, 0xE1, 0xE0, 0x07,
  0x83, 0xC7, 0xC0, 0x0F, 0x07, 0x9F, 0x00, 0x1E, 0x1F, 0x7C, 0x00, 0x3E,
  0x7C, 0xF0, 0x00, 0x7F, 0xF3, 0xC0, 0x00, 0x7F, 0xEF, 0x00, 0x00, 0x7F,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xFE, 0x00, 0x01, 0xEF,
  0xFE, 0x00, 0x07, 0xBF, 0xFC, 0x00, 0x1E, 0x78, 0x78, 0x00, 0x78, 0xF0,
  0xF0, 0x01, 0xF1, 0xE1, 0xE0, 0x07, 0xC7, 0xC3, 0xC0, 0x1F, 0x0F, 0x07,
  0x80, 0x7C, 0x1E, 0x1F, 0x00, 0xF0, 0x3E, 0x7C, 0x03, 0xC0, 0x3F, 0xF8,
  0x0F, 0x00, 0x7F, 0xE0, 0x3C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0x3F,
  0xFE, 0x3F, 0x1F, 0xBF, 0x1F, 0x8F, 0xCF, 0xDF, 0x8F, 0xC7, 0xFF, 0x87,
  0xE1, 0xFF, 0xC3, 0xF0, 0xFF, 0xC1, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xE7, 0xE0, 0x3F, 0xE3, 0xF8, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x04,
  0x07, 0x80, 0x8E, 0x0F, 0x07, 0x3F, 0x1E, 0x3E, 0x7F, 0x39, 0xFD, 0xFF,
  0x77, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F,
  0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xE0, 0x78, 0x01, 0x80, 0xC0,
  0x01, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1E, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xCF,
  0x1F, 0x9F, 0xBF, 0x3E, 0x3F, 0x7E, 0xFC, 0x7E, 0xFD, 0xF8, 0xFC, 0xF3,
  0xF1, 0xF8, 0x47, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF3, 0xF0,
  0x1F, 0x1F, 0x80, 0xE0, 0xFC, 0x06, 0x0F, 0xE0, 0x40, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x0F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC3,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0x80, 0x3F, 0x7F, 0xC1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7E, 0x7E, 0x03, 0xF9, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF9, 0xFC,
  0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x0F, 0xF3, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB,
  0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFC, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC1, 0xFC, 0x7F, 0xCF, 0xF9, 0xFE, 0x3F, 0xC3, 0xF0, 0x00,
  0x10, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x08, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xE0, 0x1F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x03, 0x8F, 0x8F, 0x83, 0xF9, 0xF1, 0xF0, 0xFF, 0xBC, 0x3E,
  0x1F, 0xFF, 0x87, 0xC7, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x07,
  0xC7, 0xC3, 0xE0, 0xF8, 0xF8, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC3, 0xE3,
  0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xFC,
  0x7C, 0x3E, 0x1F, 0x8F, 0x87, 0xFF, 0xE1, 0xF0, 0xFF, 0xBC, 0x3E, 0x0F,
  0xEF, 0x87, 0xC0, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xC3, 0xFF, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8,
  0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xC7,
  0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE,
  0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8,
  0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xC7, 0xF0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xFF, 0x3F,
  0x0F, 0xFE, 0x7E, 0x1F, 0xF8, 0xFC, 0x7F, 0xF1, 0xF8, 0xFF, 0xE7, 0xF1,
  0xFF, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x01,
  0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x07,
  0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x1F,
  0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x8F, 0x78,
  0x3F, 0xE3, 0xFE, 0x1F, 0x78, 0xEF, 0x87, 0xDE, 0x7B, 0xE1, 0xF7, 0x9E,
  0xF8, 0x7D, 0xEF, 0x7E, 0x1F, 0x3B, 0xDF, 0x87, 0xCE, 0xE7, 0xC1, 0xF3,
  0xF9, 0xF0, 0xFC, 0xFE, 0xFC, 0x3F, 0x3F, 0x3F, 0x0F, 0xCF, 0xCF, 0xC3,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x87, 0xF8, 0x0F,
  0xC3, 0xFC, 0x07, 0xC1, 0xFE, 0x03, 0xE0, 0xFF, 0x83, 0xF0, 0x7F, 0xC1,
  0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0xF0, 0x7E, 0x1F, 0x78, 0x3E, 0x0F, 0xBC,
  0x1F, 0x07, 0xDF, 0x0F, 0x83, 0xEF, 0x8F, 0xC1, 0xF7, 0xC7, 0xE1, 0xFB,
  0xE3, 0xF0, 0xFC, 0xF1, 0xF0, 0x7E, 0x7C, 0xF8, 0x3F, 0x3E, 0x7C, 0x1F,
  0x1F, 0x3E, 0x0F, 0x8F, 0xBF, 0x0F, 0xC3, 0xDF, 0x87, 0xE1, 0xEF, 0xC3,
  0xF0, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8,
  0x3E, 0x07, 0xFC, 0x3F, 0x03, 0xFE, 0x1F, 0x81, 0xFE, 0x0F, 0xC0, 0xFF,
  0x07, 0xC0, 0x7F, 0x83, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F,
  0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x03, 0xFC, 0x1F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFE,
  0x07, 0xF1, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xC0, 0xFF, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x81,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x0F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xC0,
  0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3E, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0xFC, 0xF8, 0x3E, 0x1F,
  0x1F, 0x0F, 0xC3, 0xE3, 0xE1, 0xF8, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x8E,
  0xE3, 0xE1, 0xF1, 0xDC, 0x7C, 0x3E, 0x3B, 0x8F, 0x87, 0xC7, 0xF3, 0xE0,
  0xF9, 0xFE, 0x7C, 0x1F, 0x3B, 0x8F, 0x83, 0xC7, 0x71, 0xF0, 0x78, 0xEE,
  0x3C, 0x1F, 0x39, 0xCF, 0x83, 0xE7, 0x39, 0xF0, 0x7C, 0xE7, 0x3E, 0x0F,
  0xBC, 0xE7, 0x81, 0xF7, 0x1D, 0xF0, 0x3E, 0xE3, 0xBE, 0x07, 0xDC, 0x77,
  0xC0, 0xFF, 0x8E, 0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xFC, 0x3F, 0xC0, 0x7B,
  0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8,
  0x07, 0xF0, 0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x81,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x80, 0x7E, 0xFC, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFE, 0x1F,
  0x87, 0xF0, 0x00, 0x10, 0x00, 0x03, 0xFC, 0xFC, 0x0F, 0xFD, 0xF8, 0x3F,
  0xFB, 0xF0, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x0F, 0xFC, 0xFC, 0x07, 0xF3, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xC0, 0x1F, 0xCF,
  0xF0, 0x3F, 0xBF, 0xF0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xDF, 0xFE, 0x1F, 0x9F,
  0xF8, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xF8, 0x3F,
  0x8F, 0xC0, 0x7F, 0x7F, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7E, 0x01,
  0xFE, 0x7E, 0x03, 0xFF, 0x7E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0x7E, 0x1F,
  0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFB, 0xF0, 0x3F, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x00, 0x08, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x1F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x4F, 0xE0, 0x7E,
  0x3F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xBF, 0x1F,
  0xFE, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFE, 0xFE, 0x03, 0xF3,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF7, 0xE0, 0xFF, 0x9F,
  0x80, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xC0, 0x1F, 0xCF, 0xF0, 0x3F, 0xBF, 0xF0, 0x7E, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7F,
  0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x7E,
  0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x08, 0x08, 0x0F, 0xDF, 0x1F, 0x07, 0xDF, 0xDF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFC, 0xF8, 0xFC, 0x7C, 0x7C,
  0x7C, 0x3E, 0x3E, 0x3E, 0x3F, 0x1E, 0x1F, 0x1F, 0x8F, 0x1F, 0x8F, 0x87,
  0x8F, 0xC7, 0xC3, 0xC7, 0xE3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF1, 0xF8,
  0xF0, 0xF8, 0xFC, 0x78, 0x7C, 0x7E, 0x3C, 0x7E, 0x3E, 0x1E, 0x3F, 0x1F,
  0x1F, 0x1F, 0x8F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7, 0xE3, 0xC3, 0xE3,
  0xF1, 0xE3, 0xF1, 0xF0, 0xF1, 0xF8, 0x00, 0x01, 0x80, 0x3F, 0x9F, 0xE0,
  0x7E, 0x7F, 0xE0, 0xFD, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC,
  0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0,
  0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xE7, 0xF8, 0x0F, 0xCF, 0xFC, 0x0F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7E, 0x7F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFC, 0xFC, 0x0F, 0xFD, 0xF8, 0x3F, 0xFB, 0xF0, 0xFF, 0xF7, 0xE3,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x8F, 0xE0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0x7E,
  0x0F, 0xFC, 0xFC, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x3F, 0x1F, 0xE0, 0x7E,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xF1, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0xFE, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE7,
  0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0,
  0x3F, 0x9F, 0x80, 0xFE, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xFC, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x1F, 0xFC, 0x1F, 0x0F,
  0xBE, 0x1F, 0x87, 0xDF, 0x0F, 0xC3, 0xEF, 0x87, 0xE3, 0xE7, 0xC7, 0x71,
  0xF3, 0xE3, 0xB8, 0xF9, 0xF1, 0xDC, 0xF8, 0xF8, 0xCE, 0x7C, 0x7C, 0xEF,
  0x3E, 0x3E, 0x77, 0x9E, 0x1F, 0x3B, 0xDF, 0x0F, 0xB9, 0xEF, 0x87, 0xDC,
  0xE7, 0x83, 0xEE, 0x77, 0xC1, 0xFE, 0x3B, 0xE0, 0xFF, 0x1D, 0xF0, 0x7F,
  0x8E, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF3,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xFC,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF9, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0xC7, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0x7E, 0x0F, 0xF9, 0xF8, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x7D, 0xFF, 0xE1, 0xF3,
  0xFF, 0xC3, 0xEF, 0xFF, 0xC7, 0xDF, 0x1F, 0xDF, 0xBE, 0x1F, 0xFF, 0x7C,
  0x3F, 0xFC, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 31, 25, 7, -31 },
  { 48, 18, 13, 25, 6, -31 },
  { 78, 26, 31, 25, 0, -31 },
  { 179, 24, 43, 25, 1, -37 },
  { 308, 31, 31, 25, -2, -31 },
  { 429, 25, 31, 25, 0, -31 },
  { 526, 8, 13, 25, 11, -31 },
  { 539, 19, 40, 25, 5, -35 },
  { 634, 19, 40, 25, 2, -35 },
  { 729, 23, 23, 25, 2, -26 },
  { 796, 22, 20, 25, 2, -24 },
  { 851, 13, 13, 25, 3, -6 },
  { 873, 16, 6, 25, 5, -17 },
  { 885, 9, 8, 25, 7, -8 },
  { 894, 27, 40, 25, 0, -35 },
  { 1029, 23, 31, 25, 2, -31 },
  { 1119, 21, 31, 25, 2, -31 },
  { 1201, 24, 31, 25, 1, -31 },
  { 1294, 23, 31, 25, 1, -31 },
  { 1384, 23, 31, 25, 1, -31 },
  { 1474, 24, 31, 25, 1, -31 },
  { 1567, 22, 31, 25, 1, -31 },
  { 1653, 23, 31, 25, 3, -31 },
  { 1743, 24, 31, 25, 1, -31 },
  { 1836, 22, 31, 25, 3, -31 },
  { 1922, 11, 24, 25, 7, -24 },
  { 1955, 15, 31, 25, 3, -24 },
  { 2014, 21, 24, 25, 3, -26 },
  { 2077, 21, 16, 25, 2, -22 },
  { 2119, 22, 24, 25, 1, -26 },
  { 2185, 19, 31, 25, 5, -31 },
  { 2259, 27, 39, 25, -1, -31 },
  { 2391, 23, 31, 25, -1, -31 },
  { 2481, 24, 31, 25, 1, -31 },
  { 2574, 23, 31, 25, 2, -31 },
  { 2664, 24, 31, 25, 1, -31 },
  { 2757, 23, 31, 25, 2, -31 },
  { 2847, 25, 31, 25, 1, -31 },
  { 2944, 23, 31, 25, 2, -31 },
  { 3034, 24, 31, 25, 1, -31 },
  { 3127, 23, 31, 25, 2, -31 },
  { 3217, 25, 31, 25, 0, -31 },
  { 3314, 26, 31, 25, 1, -31 },
  { 3415, 20, 31, 25, 2, -31 },
  { 3493, 26, 31, 25, 0, -31 },
  { 3594, 25, 31, 25, 1, -31 },
  { 3691, 23, 31, 25, 2, -31 },
  { 3781, 25, 31, 25, 1, -31 },
  { 3878, 23, 39, 25, 2, -31 },
  { 3991, 24, 31, 25, 1, -31 },
  { 4084, 24, 31, 25, 1, -31 },
  { 4177, 23, 31, 25, 4, -31 },
  { 4267, 25, 31, 25, 1, -31 },
  { 4364, 23, 31, 25, 4, -31 },
  { 4454, 27, 31, 25, 1, -31 },
  { 4559, 28, 31, 25, -1, -31 },
  { 4668, 24, 31, 25, 4, -31 },
  { 4761, 24, 31, 25, 1, -31 },
  { 4854, 19, 40, 25, 5, -35 },
  { 4949, 15, 40, 25, 6, -35 },
  { 5024, 19, 40, 25, 3, -35 },
  { 5119, 20, 17, 25, 3, -31 },
  { 5162, 21, 6, 25, 0, 1 },
  { 5178, 10, 6, 25, 10, -33 },
  { 5186, 23, 24, 25, 1, -24 },
  { 5255, 23, 31, 25, 1, -31 },
  { 5345, 22, 24, 25, 2, -24 },
  { 5411, 24, 31, 25, 1, -31 },
  { 5504, 22, 24, 25, 2, -24 },
  { 5570, 29, 39, 25, -3, -31 },
  { 5712, 22, 32, 25, 2, -24 },
  { 5800, 23, 31, 25, 1, -31 },
  { 5890, 22, 33, 25, 1, -33 },
  { 5981, 24, 41, 25, 0, -33 },
  { 6104, 25, 31, 25, 1, -31 },
  { 6201, 20, 31, 25, 3, -31 },
  { 6279, 25, 24, 25, 0, -24 },
  { 6354, 23, 24, 25, 1, -24 },
  { 6423, 22, 24, 25, 2, -24 },
  { 6489, 24, 32, 25, 0, -24 },
  { 6585, 23, 32, 25, 1, -24 },
  { 6677, 23, 24, 25, 2, -24 },
  { 6746, 23, 24, 25, 1, -24 },
  { 6815, 22, 29, 25, 2, -29 },
  { 6895, 22, 23, 25, 2, -23 },
  { 6959, 23, 23, 25, 3, -23 },
  { 7026, 25, 23, 25, 2, -23 },
  { 7098, 26, 23, 25, -1, -23 },
  { 7173, 22, 31, 25, 2, -23 },
  { 7259, 23, 23, 25, 1, -23 },
  { 7326, 23, 40, 25, 3, -35 },
  { 7441, 12, 40, 25, 7, -35 },
  { 7501, 22, 40, 25, 1, -35 },
  { 7611, 23, 11, 25, 2, -20 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC42PT7B_H_
