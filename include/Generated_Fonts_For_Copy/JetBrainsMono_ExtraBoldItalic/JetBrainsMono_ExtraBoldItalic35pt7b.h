#ifndef _JETBRAINSMONO_EXTRABOLDITALIC35PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x7E, 0x7E,
  0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0x81,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x3C,
  0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x70,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x0E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFB, 0x3E, 0x1F, 0x33, 0xE3, 0xF3,
  0x00, 0x3F, 0x70, 0x03, 0xF7, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xEF, 0xC0,
  0x0C, 0xFC, 0x00, 0xC7, 0xCF, 0x8C, 0x7C, 0xFC, 0xCF, 0xCF, 0xFD, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F, 0xC0, 0x70, 0x1E, 0x78, 0x38,
  0x0F, 0x1E, 0x1E, 0x03, 0xC7, 0x8F, 0x00, 0xE1, 0xC7, 0x80, 0x38, 0x73,
  0xC0, 0x0E, 0x3D, 0xE0, 0x03, 0xFE, 0xF0, 0x00, 0x7F, 0x38, 0x00, 0x0F,
  0x9C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC4, 0x00,
  0x01, 0xEF, 0xE0, 0x00, 0xF7, 0xFC, 0x00, 0x7B, 0xEF, 0x00, 0x1C, 0xE1,
  0xC0, 0x0E, 0x38, 0x70, 0x07, 0x1E, 0x1C, 0x03, 0xC7, 0x8F, 0x01, 0xE1,
  0xE3, 0xC0, 0xF0, 0x7F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7E,
  0x7E, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x7C, 0xFF, 0xE7, 0xCF, 0x9F, 0x7C, 0x7C, 0x7F, 0xE3, 0xE3, 0xFE, 0x1F,
  0x0F, 0xE0, 0xF8, 0x7F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xF7, 0xC0, 0xFF, 0x3F, 0x00, 0x7E, 0xF9, 0xF3,
  0xE7, 0xCF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x04,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x30, 0x70, 0x63, 0xC7, 0x1E, 0x7E, 0x77, 0xE7, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x3B, 0x80, 0x0F, 0xBC, 0x01,
  0xF3, 0xE0, 0x3F, 0x3F, 0x03, 0xE1, 0xF0, 0x1C, 0x1E, 0x00, 0x80, 0x80,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xEF, 0x3E,
  0x3E, 0xF3, 0xE3, 0xDF, 0x7C, 0x7C, 0xF7, 0xC7, 0xC6, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE3,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x18, 0x7E, 0x04, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x0F,
  0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x07, 0xCF,
  0xC0, 0xF9, 0xFC, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x9F,
  0x83, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE7, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x30, 0x0F, 0xBF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x9F, 0xE7, 0xF3, 0xF0, 0x7E, 0x7C, 0x07, 0xDF, 0x80,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xF8, 0xFC, 0x3F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBE, 0x03,
  0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F,
  0x8F, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xF1, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0x8F, 0xE1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE3, 0xFD, 0xFC, 0x7C, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x7D, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x06, 0x0F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0xFE,
  0x7F, 0x3F, 0x0F, 0x80, 0x00, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x20, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x01,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xC1, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x1F, 0x78,
  0x78, 0x7F, 0xF0, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x0F, 0x8F,
  0x1E, 0x1F, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF3,
  0xE1, 0xE3, 0xE7, 0x87, 0xC7, 0x8F, 0x8F, 0x8F, 0x1F, 0xFE, 0x1E, 0x1F,
  0xDC, 0x3C, 0x1E, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0,
  0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03,
  0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0x0F, 0xF0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0, 0x3F, 0x1F,
  0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xE0, 0xFC,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F,
  0xCF, 0xC3, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0, 0xFE, 0x1F, 0x03, 0xF1,
  0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x1F, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3F,
  0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x3F, 0xE3, 0xE3, 0xFE, 0x7E, 0x7F, 0xC7, 0xC7,
  0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F,
  0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE3, 0xF0, 0x3E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F,
  0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F,
  0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x03, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xEE, 0x77, 0x87, 0xB9, 0xDE, 0x1E, 0xEF, 0xF8, 0x7B,
  0xBB, 0xE3, 0xEE, 0xEF, 0x0F, 0xBF, 0x3C, 0x3E, 0xFC, 0xF0, 0xFB, 0xF7,
  0xC3, 0xCF, 0x9F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0xF1, 0xFC, 0x0F, 0x1F, 0xC1, 0xF1, 0xFC, 0x1F, 0x1F, 0xC1, 0xF1, 0xFE,
  0x1F, 0x1F, 0xE1, 0xE3, 0xFE, 0x1E, 0x3F, 0xE1, 0xE3, 0xFE, 0x3E, 0x3C,
  0xE3, 0xE3, 0xCF, 0x3E, 0x3C, 0xF3, 0xE3, 0xCF, 0x3C, 0x7C, 0xF3, 0xC7,
  0xCF, 0x3C, 0x7C, 0x7F, 0xC7, 0xC7, 0xFC, 0x78, 0x7F, 0xC7, 0x87, 0xF8,
  0xF8, 0x7F, 0x8F, 0x83, 0xF8, 0xF8, 0x3F, 0x8F, 0x83, 0xF8, 0xF0, 0x3F,
  0x8F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3,
  0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x83, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0,
  0xFC, 0x7C, 0x0F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E,
  0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE3, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xF0, 0x7F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3,
  0xF0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x0F, 0xCF, 0xE1,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C,
  0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F,
  0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C,
  0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3C,
  0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC7, 0xC7, 0xCF, 0x1F, 0x1E, 0x3C, 0x7C,
  0x78, 0xF1, 0xF1, 0xE7, 0xCF, 0xCF, 0x9E, 0x3F, 0x3C, 0x78, 0xDC, 0xF1,
  0xE7, 0x73, 0xC7, 0x9D, 0xDF, 0x1E, 0x76, 0x78, 0x79, 0x99, 0xE1, 0xEE,
  0x67, 0x87, 0xB9, 0x9E, 0x1E, 0xE6, 0xF0, 0x7B, 0x1B, 0xC1, 0xFC, 0x6F,
  0x07, 0xF1, 0xBC, 0x1D, 0x8F, 0xE0, 0x76, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3F,
  0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xFC, 0x03,
  0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xE1, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C,
  0x7C, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E,
  0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D,
  0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F, 0x9F, 0x0F, 0x8F, 0x87,
  0x83, 0xC7, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xF0,
  0x00, 0xC0, 0x00, 0xFE, 0x7C, 0x3F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0xFE,
  0x7E, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x07, 0xE3,
  0xF1, 0xFC, 0x7F, 0xEF, 0x8F, 0xFF, 0xF0, 0xFF, 0x7C, 0x0F, 0xCF, 0x80,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC3, 0x00, 0xFB, 0xFC, 0x1F, 0xFF, 0x87, 0xDF, 0xF8,
  0xFF, 0xFF, 0x1F, 0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3,
  0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7,
  0xC0, 0xF9, 0xFC, 0x7F, 0x3E, 0xFF, 0xC7, 0xDF, 0xF8, 0xFB, 0xFE, 0x1F,
  0x3F, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7E, 0x1F, 0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x9F,
  0x03, 0xE3, 0xF1, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xC3, 0xE0, 0x7F, 0x3E, 0x0F, 0xFB,
  0xE1, 0xFF, 0xBE, 0x1F, 0xFF, 0xE3, 0xF0, 0xFC, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xEF, 0x87,
  0xFF, 0xF8, 0x3F, 0xDF, 0x01, 0xF9, 0xF0, 0x00, 0x30, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x7E, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x7C,
  0x3F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xFC, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xEF, 0x87,
  0xFB, 0xF0, 0x3E, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC1, 0x00, 0xF9, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0x87, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E,
  0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF8,
  0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x23, 0xE0, 0x7E,
  0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x3F, 0x03, 0xE1,
  0xF8, 0x1F, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x20, 0x40, 0xF7, 0xCF, 0x87, 0xFE, 0xFC,
  0x3F, 0xFF, 0xE3, 0xE7, 0xCF, 0x1F, 0x3C, 0x78, 0xF9, 0xE3, 0xC7, 0x8F,
  0x3E, 0x3C, 0x79, 0xF1, 0xE3, 0x8F, 0x9F, 0x1C, 0x7C, 0xF8, 0xE3, 0xC7,
  0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0x1E, 0x7C, 0xF8, 0xE3,
  0xE7, 0xC7, 0x1E, 0x3E, 0x78, 0xF1, 0xF3, 0xC7, 0x80, 0x00, 0x04, 0x03,
  0xE7, 0xF0, 0x7F, 0xFE, 0x1F, 0x7F, 0xE3, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3E,
  0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC,
  0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xF1, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0xFB, 0xFC, 0x0F, 0xFF, 0xC1, 0xF7, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E,
  0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x03,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xF1,
  0xFC, 0x7D, 0xFF, 0x87, 0xDF, 0xF8, 0x7D, 0xFF, 0x07, 0xCF, 0xC0, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x7C, 0x3F, 0xEF, 0x8F, 0xFD, 0xF1,
  0xFF, 0xFE, 0x7E, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x07, 0xE3, 0xF1, 0xFC, 0x7F, 0xEF, 0x8F, 0xFF, 0xF0, 0xFF, 0x7C, 0x0F,
  0xCF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x04, 0x01, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x40, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7C, 0x0F, 0xCF, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x03,
  0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07,
  0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F,
  0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1,
  0xF1, 0xEF, 0x3F, 0x3C, 0xF3, 0x73, 0xCF, 0x37, 0x3C, 0xF7, 0x77, 0x8F,
  0x77, 0x78, 0xF6, 0x77, 0x8F, 0x67, 0x78, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C,
  0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7E, 0x3F, 0x00, 0xF9, 0xF8,
  0x03, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xC0,
  0xFC, 0x1F, 0x8F, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0xF8,
  0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xF0,
  0x7E, 0x7C, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE1,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFB, 0xE1, 0xFF, 0xFC, 0x3F, 0xDF, 0x00, 0x83,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFC,
  0x1F, 0x3F, 0xE1, 0xE7, 0xFF, 0x1E, 0x79, 0xF1, 0xE7, 0x8F, 0xFE, 0x78,
  0xFF, 0xCF, 0x87, 0xF8, 0x00, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 10, 26, 21, 6, -26 },
  { 34, 15, 11, 21, 5, -26 },
  { 55, 22, 26, 21, 0, -26 },
  { 127, 20, 35, 21, 1, -30 },
  { 215, 26, 26, 21, -2, -26 },
  { 300, 21, 26, 21, 0, -26 },
  { 369, 7, 11, 21, 9, -26 },
  { 379, 15, 34, 21, 5, -30 },
  { 443, 15, 34, 21, 2, -30 },
  { 507, 20, 18, 21, 1, -21 },
  { 552, 18, 17, 21, 2, -20 },
  { 591, 11, 11, 21, 2, -5 },
  { 607, 13, 5, 21, 4, -14 },
  { 616, 7, 7, 21, 6, -7 },
  { 623, 22, 33, 21, 0, -29 },
  { 714, 20, 26, 21, 1, -26 },
  { 779, 18, 26, 21, 1, -26 },
  { 838, 19, 26, 21, 1, -26 },
  { 900, 19, 26, 21, 1, -26 },
  { 962, 19, 26, 21, 1, -26 },
  { 1024, 19, 26, 21, 1, -26 },
  { 1086, 19, 26, 21, 1, -26 },
  { 1148, 19, 26, 21, 3, -26 },
  { 1210, 20, 26, 21, 1, -26 },
  { 1275, 19, 26, 21, 2, -26 },
  { 1337, 9, 20, 21, 6, -20 },
  { 1360, 12, 26, 21, 3, -20 },
  { 1399, 18, 19, 21, 2, -21 },
  { 1442, 18, 13, 21, 2, -18 },
  { 1472, 18, 19, 21, 1, -21 },
  { 1515, 16, 26, 21, 4, -26 },
  { 1567, 23, 32, 21, -1, -26 },
  { 1659, 20, 26, 21, -1, -26 },
  { 1724, 20, 26, 21, 1, -26 },
  { 1789, 20, 26, 21, 1, -26 },
  { 1854, 20, 26, 21, 1, -26 },
  { 1919, 20, 26, 21, 1, -26 },
  { 1984, 20, 26, 21, 1, -26 },
  { 2049, 20, 26, 21, 1, -26 },
  { 2114, 20, 26, 21, 1, -26 },
  { 2179, 20, 26, 21, 1, -26 },
  { 2244, 21, 26, 21, 0, -26 },
  { 2313, 21, 26, 21, 1, -26 },
  { 2382, 16, 26, 21, 2, -26 },
  { 2434, 22, 26, 21, 0, -26 },
  { 2506, 20, 26, 21, 1, -26 },
  { 2571, 20, 26, 21, 1, -26 },
  { 2636, 21, 26, 21, 1, -26 },
  { 2705, 20, 32, 21, 1, -26 },
  { 2785, 20, 26, 21, 1, -26 },
  { 2850, 20, 26, 21, 1, -26 },
  { 2915, 19, 26, 21, 3, -26 },
  { 2977, 20, 26, 21, 1, -26 },
  { 3042, 20, 26, 21, 3, -26 },
  { 3107, 22, 26, 21, 1, -26 },
  { 3179, 23, 26, 21, -1, -26 },
  { 3254, 20, 26, 21, 3, -26 },
  { 3319, 20, 26, 21, 1, -26 },
  { 3384, 16, 33, 21, 4, -29 },
  { 3450, 12, 33, 21, 5, -29 },
  { 3500, 16, 33, 21, 2, -29 },
  { 3566, 17, 14, 21, 2, -26 },
  { 3596, 17, 5, 21, 0, 1 },
  { 3607, 9, 4, 21, 8, -27 },
  { 3612, 19, 20, 21, 1, -20 },
  { 3660, 19, 26, 21, 1, -26 },
  { 3722, 19, 20, 21, 1, -20 },
  { 3770, 20, 26, 21, 1, -26 },
  { 3835, 19, 20, 21, 1, -20 },
  { 3883, 24, 32, 21, -2, -26 },
  { 3979, 19, 26, 21, 1, -20 },
  { 4041, 19, 26, 21, 1, -26 },
  { 4103, 18, 28, 21, 1, -28 },
  { 4166, 20, 34, 21, 0, -28 },
  { 4251, 21, 26, 21, 1, -26 },
  { 4320, 16, 26, 21, 3, -26 },
  { 4372, 21, 20, 21, 0, -20 },
  { 4425, 19, 20, 21, 1, -20 },
  { 4473, 19, 20, 21, 1, -20 },
  { 4521, 20, 26, 21, 0, -20 },
  { 4586, 19, 26, 21, 1, -20 },
  { 4648, 20, 20, 21, 1, -20 },
  { 4698, 19, 20, 21, 1, -20 },
  { 4746, 18, 25, 21, 2, -25 },
  { 4803, 19, 19, 21, 1, -19 },
  { 4849, 20, 19, 21, 2, -19 },
  { 4897, 20, 19, 21, 2, -19 },
  { 4945, 22, 19, 21, -1, -19 },
  { 4998, 19, 25, 21, 1, -19 },
  { 5058, 19, 19, 21, 1, -19 },
  { 5104, 18, 33, 21, 3, -29 },
  { 5179, 10, 33, 21, 6, -29 },
  { 5221, 19, 33, 21, 0, -29 },
  { 5300, 20, 9, 21, 1, -17 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC35PT7B_H_
