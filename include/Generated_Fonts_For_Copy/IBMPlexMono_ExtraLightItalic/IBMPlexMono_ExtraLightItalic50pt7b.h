#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC50PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x10, 0x33, 0x06, 0x30, 0x63, 0x06, 0x30,
  0x63, 0x06, 0x20, 0x46, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0xC0,
  0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x07, 0xFE, 0x03, 0xFF, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x01, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0x8C, 0x78, 0x03, 0x81, 0x83, 0x80, 0xE0, 0x30, 0x18, 0x18,
  0x04, 0x03, 0x86, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x38, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x03, 0xEC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x05,
  0xF8, 0x00, 0x01, 0x87, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x10, 0x0E, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x60,
  0x08, 0x03, 0x0C, 0x01, 0x00, 0xC0, 0xC0, 0x60, 0x38, 0x0E, 0x0C, 0x0E,
  0x00, 0xF1, 0x8F, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xC0, 0x70, 0x70, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x00,
  0x60, 0x10, 0x01, 0x00, 0x60, 0x18, 0x00, 0x80, 0x20, 0x0C, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x60, 0x30, 0x02, 0x00, 0x30, 0x30, 0x01, 0x00, 0x18,
  0x10, 0x00, 0x80, 0x08, 0x18, 0x00, 0x60, 0x0C, 0x18, 0x00, 0x30, 0x0C,
  0x18, 0x00, 0x0E, 0x1C, 0x08, 0x00, 0x03, 0xFC, 0x0C, 0x00, 0x00, 0xFC,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC1, 0xFF, 0x00, 0x00,
  0xC1, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x60, 0x00, 0x40, 0xC0, 0x18, 0x00,
  0x60, 0xC0, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x20, 0x03, 0x00,
  0x20, 0x10, 0x01, 0x80, 0x30, 0x18, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x40,
  0x30, 0x06, 0x00, 0x60, 0x10, 0x01, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x30,
  0x18, 0x00, 0x70, 0x70, 0x08, 0x00, 0x1F, 0xF0, 0x08, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x1F, 0xC7, 0x00, 0x01, 0xE7, 0xF0, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xA0, 0x00,
  0x58, 0x0D, 0x80, 0x02, 0xC0, 0xCC, 0x00, 0x13, 0x06, 0x60, 0x01, 0x0C,
  0x61, 0x80, 0x18, 0x63, 0x07, 0x03, 0x81, 0xB0, 0x1F, 0xF8, 0x0F, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0x33, 0x32, 0x66, 0x66, 0x64, 0xCC, 0xC0, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x78, 0x06, 0x01, 0xCF, 0x83, 0x07, 0xC0, 0xF9, 0x3F,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x00, 0x60,
  0x00, 0xC0, 0x20, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0C,
  0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x38, 0x02, 0xC0, 0x3C, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0x30, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0x00, 0x00, 0xF6, 0x00,
  0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x78, 0x30, 0x01, 0xE0, 0x60, 0x07,
  0x00, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3C, 0x07, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x08, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x61, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x18, 0x00, 0x38, 0x07, 0x80, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x08, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06,
  0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x20, 0x04,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0xFE, 0x00, 0x13,
  0xFF, 0xC0, 0x0B, 0x80, 0xF0, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x87, 0xF0, 0x0C, 0x7F,
  0xF0, 0x37, 0x80, 0xE1, 0xB0, 0x01, 0xC7, 0x80, 0x03, 0x9C, 0x00, 0x06,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x18, 0x70, 0x01, 0xC0,
  0xF0, 0x1E, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x64, 0x00, 0x00, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x07, 0x80, 0x70,
  0x00, 0xE0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x0E, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x38, 0x60, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0F,
  0x00, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x0C, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x39, 0x80, 0x01, 0x63, 0x00,
  0x0D, 0x0F, 0x01, 0xEC, 0x0F, 0xFE, 0x30, 0x0F, 0xE1, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0,
  0xF0, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0x01, 0xC1, 0xC0, 0x0E, 0x38, 0x00, 0x73, 0x00, 0x03, 0x60, 0x00, 0x3C,
  0x00, 0x03, 0x40, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x3E, 0x33, 0x01,
  0xFE, 0x66, 0x07, 0x06, 0xCC, 0x0C, 0x03, 0x10, 0x30, 0x06, 0x60, 0x40,
  0x0C, 0xC1, 0x80, 0x19, 0x83, 0x00, 0x33, 0x04, 0x00, 0x64, 0x08, 0x00,
  0x88, 0x30, 0x01, 0x30, 0x60, 0x02, 0x60, 0xC0, 0x0C, 0xC1, 0x80, 0x19,
  0x83, 0x00, 0x33, 0x06, 0x00, 0xC4, 0x0C, 0x02, 0x88, 0x0C, 0x0F, 0x10,
  0x1E, 0x76, 0x20, 0x1F, 0xCC, 0x40, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x10, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0C, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x10, 0x00,
  0x38, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0,
  0x0C, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x70, 0x00,
  0x70, 0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x07, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x80,
  0x1E, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0x80, 0x01, 0xC0, 0x40, 0x07, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x0C, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x0F, 0xFC, 0xC0, 0x0F, 0xFC, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x50, 0x30,
  0x00, 0xF0, 0x38, 0x01, 0xB0, 0x1E, 0x07, 0x30, 0x0F, 0xFE, 0x30, 0x03,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x02, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x04, 0x08, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x3C, 0x0F,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x70, 0x20,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x18, 0x78, 0x00, 0x01, 0x8C, 0xC0, 0x00, 0x1B, 0x8C,
  0x00, 0x01, 0x70, 0x60, 0x00, 0x3E, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00,
  0x38, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x06, 0x80, 0x03, 0x60, 0x4C, 0x00, 0x36, 0x04,
  0xC0, 0x06, 0x60, 0xCC, 0x00, 0x64, 0x0C, 0x40, 0x0C, 0x40, 0xC6, 0x01,
  0x8C, 0x0C, 0x60, 0x18, 0xC0, 0xC2, 0x03, 0x0C, 0x08, 0x20, 0x20, 0xC1,
  0x83, 0x06, 0x08, 0x18, 0x30, 0xC1, 0x81, 0x81, 0x0C, 0x18, 0x18, 0x19,
  0x81, 0x81, 0x81, 0x90, 0x18, 0x10, 0x0B, 0x01, 0x83, 0x00, 0xE0, 0x10,
  0x30, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x08, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x30,
  0x78, 0x00, 0x0C, 0x16, 0x00, 0x02, 0x04, 0x80, 0x01, 0x83, 0x30, 0x00,
  0x60, 0xCC, 0x00, 0x18, 0x31, 0x00, 0x06, 0x0C, 0x60, 0x01, 0x82, 0x18,
  0x00, 0x40, 0x82, 0x00, 0x30, 0x60, 0xC0, 0x0C, 0x18, 0x30, 0x03, 0x06,
  0x04, 0x00, 0xC1, 0x81, 0x80, 0x30, 0x40, 0x60, 0x08, 0x10, 0x08, 0x02,
  0x0C, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x60, 0xC0, 0x30, 0x18, 0x30, 0x06,
  0x06, 0x0C, 0x01, 0x81, 0x02, 0x00, 0x60, 0x41, 0x80, 0x0C, 0x30, 0x60,
  0x03, 0x0C, 0x18, 0x00, 0xC3, 0x06, 0x00, 0x18, 0xC1, 0x80, 0x06, 0x20,
  0x40, 0x01, 0x88, 0x30, 0x00, 0x36, 0x0C, 0x00, 0x0D, 0x83, 0x00, 0x03,
  0x60, 0xC0, 0x00, 0x58, 0x30, 0x00, 0x1C, 0x08, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0x30, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0xF0,
  0x18, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0C, 0x0E,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30,
  0x03, 0x80, 0x3C, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0xF0, 0x18, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x10,
  0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x70, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x18, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x30,
  0x04, 0x30, 0x0E, 0x01, 0x86, 0x01, 0xC0, 0x30, 0xC0, 0x68, 0x06, 0x18,
  0x0D, 0x00, 0x83, 0x01, 0x30, 0x30, 0x60, 0x66, 0x06, 0x0C, 0x08, 0xC0,
  0x81, 0x83, 0x18, 0x10, 0x20, 0x43, 0x06, 0x04, 0x18, 0x20, 0xC0, 0x83,
  0x04, 0x10, 0x10, 0xC0, 0x82, 0x02, 0x18, 0x10, 0xC0, 0xC2, 0x03, 0x18,
  0x18, 0xC0, 0x62, 0x03, 0x10, 0x0C, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0x80,
  0x33, 0x01, 0xB0, 0x02, 0x40, 0x36, 0x00, 0x58, 0x07, 0x80, 0x0B, 0x00,
  0xF0, 0x01, 0x60, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x19, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x20, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x08, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x46,
  0x18, 0xC3, 0x18, 0x63, 0x08, 0x00, 0x7F, 0x06, 0x03, 0xFF, 0x8C, 0x0F,
  0x03, 0x98, 0x38, 0x01, 0xB0, 0xC0, 0x01, 0x43, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x23, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC2,
  0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x16, 0x1C, 0x00, 0x68, 0x1C,
  0x01, 0x90, 0x1C, 0x0E, 0x7E, 0x1F, 0xF8, 0x7C, 0x0F, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0xFC, 0x00, 0xC7, 0xFE,
  0x01, 0x1C, 0x0E, 0x06, 0x60, 0x0E, 0x0D, 0x80, 0x0E, 0x1A, 0x00, 0x0C,
  0x38, 0x00, 0x18, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x04, 0x40,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xA0, 0x00,
  0xC3, 0x60, 0x07, 0x06, 0x70, 0x3C, 0x0C, 0x7F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x38, 0x1C, 0x00, 0xE1,
  0xC0, 0x03, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x05, 0x80, 0x00, 0x64, 0x00, 0x06, 0x30, 0x00, 0x71, 0xC0,
  0x07, 0x07, 0x00, 0x70, 0x1C, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x0F,
  0xE0, 0x40, 0x1F, 0xFC, 0x60, 0x1E, 0x07, 0x30, 0x1C, 0x00, 0xD8, 0x18,
  0x00, 0x2C, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x10, 0x40, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xB0, 0x38, 0x00, 0xD8, 0x0E, 0x00,
  0xC8, 0x03, 0x81, 0xC4, 0x00, 0xFF, 0xC6, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x07, 0x01, 0xC0, 0x0E, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x23, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x19,
  0x80, 0x00, 0xE4, 0x00, 0x07, 0x30, 0x00, 0x78, 0xC0, 0x7F, 0x83, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00, 0x31, 0x80, 0x01, 0x87,
  0x00, 0x0E, 0x0E, 0x00, 0x70, 0x1E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xF0, 0x04, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0x00, 0xFF, 0xE3, 0x01, 0xE0, 0x73, 0x03,
  0x80, 0x1B, 0x06, 0x00, 0x0B, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x38, 0x30, 0x00, 0x78, 0x38, 0x00, 0xD8, 0x1C, 0x01, 0x98, 0x0E,
  0x07, 0x10, 0x07, 0xFE, 0x30, 0x01, 0xF8, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x40, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x3F,
  0x00, 0xC7, 0xFE, 0x06, 0x70, 0x38, 0x36, 0x00, 0xC1, 0xA0, 0x03, 0x1A,
  0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01,
  0x88, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x02,
  0x00, 0x80, 0x1C, 0x06, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x60, 0x70, 0x01,
  0x07, 0x00, 0x04, 0x38, 0x00, 0x33, 0x80, 0x00, 0xDC, 0x00, 0x03, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x06, 0x03, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x38, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x82, 0x00, 0x0E, 0x30, 0x00,
  0x39, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x83, 0xF8, 0x00,
  0xC7, 0xFF, 0x00, 0x47, 0x03, 0x80, 0x66, 0x00, 0x60, 0x36, 0x00, 0x30,
  0x1A, 0x00, 0x18, 0x0E, 0x00, 0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x07,
  0x80, 0x30, 0x0F, 0x00, 0x10, 0x7C, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x13, 0x03, 0x00, 0x09, 0x80, 0xC0, 0x1E, 0x80,
  0x20, 0x1C, 0xC0, 0x18, 0x1C, 0x60, 0x06, 0x1C, 0x30, 0x03, 0x1C, 0x18,
  0x00, 0xDC, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x10, 0x60, 0x0E, 0x08, 0x03, 0x81, 0x01, 0xE0, 0x60,
  0x70, 0x0C, 0x1C, 0x01, 0x8E, 0x00, 0x23, 0x80, 0x05, 0xE0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x78, 0x1F, 0x03, 0x3F, 0x8F, 0xE0, 0x98,
  0x66, 0x1C, 0x68, 0x0B, 0x03, 0x1C, 0x02, 0x80, 0x47, 0x00, 0xC0, 0x11,
  0x80, 0x30, 0x04, 0x60, 0x08, 0x03, 0x10, 0x02, 0x00, 0xCC, 0x01, 0x80,
  0x33, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x02, 0x30, 0x06, 0x00, 0x8C, 0x01,
  0x00, 0x62, 0x00, 0xC0, 0x19, 0x80, 0x30, 0x06, 0x60, 0x0C, 0x01, 0x98,
  0x03, 0x00, 0x46, 0x00, 0x80, 0x11, 0x80, 0x20, 0x0C, 0x40, 0x18, 0x03,
  0x30, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x33, 0x00, 0x60, 0x08, 0xC0, 0x10,
  0x02, 0x30, 0x0C, 0x01, 0x80, 0x0C, 0x1F, 0x80, 0x63, 0xFF, 0x03, 0x38,
  0x1C, 0x1B, 0x00, 0x60, 0x90, 0x01, 0x8D, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x78, 0x0E, 0x03, 0x80,
  0x0C, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x80, 0x01, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x1C, 0x07, 0x80, 0x3F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x07, 0xE0, 0x01, 0x0F, 0xFC, 0x00,
  0x8E, 0x07, 0x00, 0xCC, 0x01, 0xC0, 0x6C, 0x00, 0x70, 0x34, 0x00, 0x18,
  0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x08, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0xD0, 0x00, 0x60, 0x6C, 0x00, 0xE0, 0x33, 0x81, 0xE0, 0x18,
  0xFF, 0xE0, 0x08, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x02, 0x03, 0xFF, 0x8C, 0x0F, 0x03, 0x98, 0x38, 0x01, 0xB0, 0xC0, 0x01,
  0x63, 0x80, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x23, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00,
  0x16, 0x1C, 0x00, 0x6C, 0x1C, 0x01, 0x90, 0x1C, 0x0E, 0x20, 0x1F, 0xF8,
  0xC0, 0x0F, 0xC1, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF,
  0x00, 0xCE, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x30, 0x00, 0x70,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0x38, 0x00, 0x06, 0x38, 0x00, 0x18, 0x3E, 0x01, 0xE0,
  0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x18, 0x03, 0x00, 0x3C, 0x03, 0x00, 0xF0, 0x03, 0x01, 0xC0,
  0x03, 0x07, 0x00, 0x02, 0x1E, 0x00, 0x02, 0x38, 0x00, 0x06, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x18, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00,
  0xC4, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00,
  0x1C, 0x60, 0x01, 0x43, 0x00, 0x16, 0x0C, 0x01, 0xB0, 0x70, 0x39, 0x81,
  0xFF, 0x8C, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0D, 0xFE, 0x00, 0x18, 0x0C,
  0x00, 0x10, 0x18, 0x00, 0x20, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00,
  0x30, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x80,
  0x40, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x07, 0x80, 0x0C,
  0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x08, 0x03, 0x03, 0x0C,
  0x01, 0x00, 0x86, 0x00, 0x80, 0x63, 0x00, 0x40, 0x31, 0x80, 0x60, 0x18,
  0x80, 0x30, 0x04, 0x40, 0x18, 0x02, 0x60, 0x0C, 0x01, 0x30, 0x04, 0x00,
  0x98, 0x02, 0x00, 0x4C, 0x03, 0x00, 0x24, 0x01, 0x80, 0x12, 0x00, 0xC0,
  0x1B, 0x00, 0x60, 0x0D, 0x80, 0x20, 0x06, 0xC0, 0x10, 0x03, 0x60, 0x18,
  0x01, 0xA0, 0x0C, 0x00, 0x90, 0x06, 0x00, 0xD8, 0x03, 0x00, 0x6C, 0x03,
  0x80, 0x66, 0x01, 0xC0, 0x33, 0x01, 0x60, 0x31, 0x81, 0xB0, 0x38, 0x61,
  0x8C, 0x38, 0x3F, 0x87, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x70, 0x07,
  0xC0, 0x0F, 0x81, 0xFE, 0x03, 0xDC, 0x38, 0x60, 0xF0, 0xC3, 0x03, 0x3C,
  0x04, 0x60, 0x36, 0x00, 0x6C, 0x03, 0x00, 0x06, 0x80, 0x10, 0x00, 0x68,
  0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0xC0, 0x12, 0x00, 0x4C, 0x03,
  0x20, 0x0E, 0xC0, 0x23, 0x03, 0x8C, 0x06, 0x30, 0xE0, 0x61, 0xC1, 0x9C,
  0x07, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x04, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x08,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x58, 0x18,
  0x00, 0x90, 0x1C, 0x01, 0xB0, 0x0F, 0x07, 0x30, 0x07, 0xFE, 0x30, 0x01,
  0xF8, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x40, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x03, 0x07, 0xFF, 0xC3, 0x0E, 0x07, 0xF3, 0x18, 0x00, 0xFF, 0x18,
  0x00, 0x1F, 0x10, 0x00, 0x0E, 0x10, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x10, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x60, 0x00, 0x08, 0xFF, 0x00, 0x08, 0xC7, 0xF8, 0x0C, 0xC0,
  0x7F, 0x8C, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x87, 0xF0,
  0x00, 0xC7, 0x1C, 0x00, 0x46, 0x06, 0x00, 0x63, 0x01, 0x80, 0x33, 0x00,
  0x60, 0x31, 0x00, 0x38, 0x39, 0x80, 0x0E, 0x38, 0xC0, 0x03, 0xF8, 0x40,
  0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 9, 35, 30, 11, -35 },
  { 41, 12, 13, 30, 12, -37 },
  { 61, 30, 35, 30, 1, -35 },
  { 193, 27, 47, 30, 2, -41 },
  { 352, 33, 37, 30, -1, -36 },
  { 505, 29, 37, 30, 0, -36 },
  { 640, 4, 13, 30, 16, -37 },
  { 647, 17, 45, 30, 11, -38 },
  { 743, 17, 45, 30, 3, -38 },
  { 839, 25, 25, 30, 3, -27 },
  { 918, 24, 24, 30, 3, -27 },
  { 990, 8, 13, 30, 8, -5 },
  { 1003, 14, 2, 30, 8, -16 },
  { 1007, 4, 4, 30, 11, -4 },
  { 1009, 27, 45, 30, 2, -38 },
  { 1161, 24, 37, 30, 4, -36 },
  { 1272, 23, 35, 30, 2, -35 },
  { 1373, 25, 36, 30, 2, -36 },
  { 1486, 25, 37, 30, 2, -36 },
  { 1602, 26, 35, 30, 1, -35 },
  { 1716, 25, 36, 30, 3, -35 },
  { 1829, 22, 36, 30, 4, -35 },
  { 1928, 23, 35, 30, 6, -35 },
  { 2029, 25, 37, 30, 3, -36 },
  { 2145, 22, 36, 30, 5, -36 },
  { 2244, 8, 26, 30, 11, -26 },
  { 2270, 11, 34, 30, 8, -26 },
  { 2317, 24, 27, 30, 4, -29 },
  { 2398, 25, 11, 30, 3, -21 },
  { 2433, 24, 27, 30, 2, -29 },
  { 2514, 20, 36, 30, 7, -36 },
  { 2604, 23, 41, 30, 4, -36 },
  { 2722, 26, 35, 30, 0, -35 },
  { 2836, 24, 35, 30, 3, -35 },
  { 2941, 24, 37, 30, 4, -36 },
  { 3052, 25, 35, 30, 3, -35 },
  { 3162, 26, 35, 30, 3, -35 },
  { 3276, 27, 35, 30, 3, -35 },
  { 3395, 24, 37, 30, 4, -36 },
  { 3506, 26, 35, 30, 3, -35 },
  { 3620, 27, 35, 30, 2, -35 },
  { 3739, 24, 36, 30, 3, -35 },
  { 3847, 28, 35, 30, 3, -35 },
  { 3970, 20, 35, 30, 5, -35 },
  { 4058, 28, 35, 30, 2, -35 },
  { 4181, 26, 35, 30, 3, -35 },
  { 4295, 24, 37, 30, 4, -36 },
  { 4406, 26, 35, 30, 3, -35 },
  { 4520, 24, 45, 30, 4, -36 },
  { 4655, 26, 35, 30, 3, -35 },
  { 4769, 26, 37, 30, 2, -36 },
  { 4890, 27, 35, 30, 5, -35 },
  { 5009, 25, 36, 30, 4, -35 },
  { 5122, 25, 35, 30, 6, -35 },
  { 5232, 27, 35, 30, 4, -35 },
  { 5351, 31, 35, 30, 0, -35 },
  { 5487, 27, 35, 30, 5, -35 },
  { 5606, 30, 35, 30, 0, -35 },
  { 5738, 20, 45, 30, 9, -38 },
  { 5851, 12, 45, 30, 10, -38 },
  { 5919, 20, 45, 30, 1, -38 },
  { 6032, 24, 19, 30, 4, -35 },
  { 6089, 24, 2, 30, 0, 6 },
  { 6095, 5, 9, 30, 12, -39 },
  { 6101, 23, 27, 30, 3, -26 },
  { 6179, 23, 38, 30, 4, -37 },
  { 6289, 21, 27, 30, 4, -26 },
  { 6360, 25, 38, 30, 3, -37 },
  { 6479, 22, 27, 30, 4, -26 },
  { 6554, 32, 48, 30, -1, -37 },
  { 6746, 24, 37, 30, 2, -26 },
  { 6857, 21, 37, 30, 4, -37 },
  { 6955, 22, 38, 30, 4, -37 },
  { 7060, 21, 48, 30, 5, -37 },
  { 7186, 25, 38, 30, 4, -37 },
  { 7305, 19, 38, 30, 6, -37 },
  { 7396, 26, 26, 30, 2, -26 },
  { 7481, 21, 26, 30, 4, -26 },
  { 7550, 22, 27, 30, 4, -26 },
  { 7625, 25, 36, 30, 2, -26 },
  { 7738, 23, 36, 30, 3, -26 },
  { 7842, 24, 26, 30, 6, -26 },
  { 7920, 23, 27, 30, 3, -26 },
  { 7998, 24, 36, 30, 4, -35 },
  { 8106, 21, 27, 30, 5, -26 },
  { 8177, 23, 26, 30, 4, -26 },
  { 8252, 25, 27, 30, 3, -26 },
  { 8337, 28, 27, 30, 1, -26 },
  { 8432, 24, 37, 30, 2, -26 },
  { 8543, 24, 27, 30, 3, -26 },
  { 8624, 23, 45, 30, 6, -38 },
  { 8754, 9, 45, 30, 11, -38 },
  { 8805, 23, 45, 30, 2, -38 },
  { 8935, 25, 10, 30, 3, -20 },
};

const GFXfont IBMPlexMono_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC50PT7B_H_
