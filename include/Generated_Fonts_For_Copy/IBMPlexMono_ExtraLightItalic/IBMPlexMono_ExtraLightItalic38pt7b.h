#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC38PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x00, 0x00, 0x00, 0x00, 0x61, 0xE3,
  0x80, 0x31, 0x90, 0xC8, 0x44, 0x26, 0x13, 0x09, 0x0C, 0x86, 0x42, 0x61,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x40, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x10,
  0x00, 0x20, 0x40, 0x00, 0x83, 0x00, 0x06, 0x08, 0x00, 0x10, 0x20, 0x00,
  0x41, 0x80, 0xFF, 0x07, 0xF0, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x82,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x03,
  0xF8, 0x3F, 0xC0, 0x60, 0x80, 0x01, 0x02, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xF8, 0x01, 0xC4, 0x70, 0x18, 0x20, 0xC1, 0x81,
  0x03, 0x08, 0x08, 0x00, 0x40, 0x40, 0x06, 0x06, 0x00, 0x30, 0x20, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x30, 0x40, 0x00, 0xC2, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x08, 0xC0, 0x00, 0x41, 0x00, 0x02, 0x0C, 0x00,
  0x10, 0x20, 0x01, 0x81, 0x00, 0x08, 0x0C, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x10, 0x10, 0x31, 0x80, 0x81, 0x03, 0x0C, 0x10, 0x0E, 0x43, 0x00, 0x1F,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0xC0, 0xC3, 0x00, 0x60, 0x60, 0x40, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x02, 0x04, 0x02, 0x00, 0x83, 0x00, 0x80, 0x61, 0x80, 0x20,
  0x10, 0x40, 0x08, 0x04, 0x20, 0x02, 0x01, 0x18, 0x00, 0xC0, 0x8C, 0x00,
  0x18, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x08, 0x60, 0x00, 0xC4, 0x0C, 0x00, 0x62, 0x01, 0x00, 0x10,
  0x80, 0x40, 0x08, 0x60, 0x10, 0x06, 0x18, 0x04, 0x03, 0x04, 0x01, 0x00,
  0x81, 0x00, 0xC0, 0x40, 0x40, 0x20, 0x30, 0x08, 0x18, 0x18, 0x03, 0x0C,
  0x0C, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x0C, 0x00, 0x10, 0x08,
  0x00, 0xC0, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00,
  0x80, 0x30, 0x02, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x10, 0x18, 0x00, 0x60,
  0x40, 0x01, 0x86, 0x00, 0x39, 0x60, 0x03, 0x06, 0x00, 0x08, 0x08, 0x00,
  0x40, 0x30, 0x01, 0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x03, 0x00, 0xC0,
  0x04, 0x03, 0x00, 0x28, 0x14, 0x00, 0xB0, 0x90, 0x02, 0x42, 0x60, 0x11,
  0x90, 0xC1, 0x82, 0xC0, 0xF8, 0x06, 0x00, 0x25, 0xB4, 0x92, 0xD8, 0x00,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x2F, 0x06, 0x0F, 0x1E, 0x47, 0x80, 0x3F, 0xC0, 0x00,
  0xE0, 0x00, 0x1A, 0x00, 0x01, 0x30, 0x00, 0x21, 0x00, 0x04, 0x18, 0x00,
  0x80, 0x80, 0x18, 0x04, 0x03, 0x00, 0x60, 0x20, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x1C, 0x61, 0x8C, 0x31, 0x86, 0x10, 0xC2,
  0x00, 0xFF, 0xE0, 0x6F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x18, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00,
  0x32, 0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0xC0, 0xF0, 0x30, 0x38, 0x0C, 0x0E, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00,
  0x8C, 0x00, 0x61, 0x00, 0x10, 0x60, 0x18, 0x0C, 0x0C, 0x00, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x16, 0x00, 0x32, 0x00, 0x31, 0x00, 0x30, 0x80, 0x60,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0xC0, 0xC0, 0x60, 0x08, 0x30, 0x03, 0x08, 0x00, 0x44, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x20, 0x03, 0x18, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x08, 0x40, 0x04, 0x0C, 0x06, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x04,
  0xC0, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x04,
  0x08, 0x00, 0x81, 0x80, 0x18, 0x18, 0x03, 0x01, 0x00, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x10, 0x18, 0x03, 0x03, 0x00, 0x30, 0x60, 0x02, 0x0C,
  0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0xFC,
  0x01, 0x60, 0x60, 0x30, 0x06, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x20, 0x00, 0x46, 0x00, 0x10, 0x60, 0x06, 0x07, 0x03, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x7F, 0x06, 0xC0, 0xC2, 0x80, 0x11, 0x80, 0x0D, 0xC0, 0x02, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B,
  0x00, 0x08, 0x80, 0x0C, 0x60, 0x0C, 0x18, 0x18, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xD8, 0x00, 0x34, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x10, 0x00,
  0xCC, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x70, 0x30, 0x18, 0x01, 0x06, 0x00, 0x30, 0x80, 0x02,
  0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x00, 0x18,
  0x30, 0x06, 0x03, 0x01, 0x80, 0x1F, 0xC0, 0x1C, 0x0C, 0x06, 0x00, 0x41,
  0x00, 0x04, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x62, 0x00, 0x08, 0x60, 0x06, 0x07,
  0x03, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x06, 0x06, 0x04, 0x00, 0x84,
  0x00, 0x26, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xA0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x73, 0x00, 0x50, 0xC0,
  0xC8, 0x1F, 0x8C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x8F, 0x38, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x20, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x10, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x31, 0x80, 0x32, 0x00,
  0x2C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xC0,
  0xC0, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0x86, 0x00, 0x31, 0x00, 0x0C,
  0xC0, 0x03, 0x20, 0x3C, 0x88, 0x30, 0xA2, 0x18, 0x19, 0x84, 0x06, 0x43,
  0x00, 0x90, 0x80, 0x64, 0x20, 0x19, 0x08, 0x04, 0xC2, 0x01, 0x31, 0x80,
  0x48, 0x60, 0x32, 0x08, 0x0C, 0x82, 0x07, 0x20, 0x82, 0x88, 0x19, 0xA2,
  0x03, 0x80, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x2C, 0x00, 0x05, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x61, 0x00, 0x08, 0x30, 0x03, 0x06, 0x00, 0x40, 0x40, 0x18,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x06, 0x06, 0x00, 0xC0, 0xFF,
  0xF8, 0x30, 0x01, 0x04, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0xCC, 0x00,
  0x19, 0x00, 0x03, 0x60, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x80, 0x0F,
  0xFE, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x11, 0x80, 0x04, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08,
  0x40, 0x06, 0x30, 0x03, 0x0F, 0xFF, 0x03, 0x00, 0x30, 0x80, 0x06, 0x20,
  0x00, 0x88, 0x00, 0x26, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x30, 0x03, 0x8F, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x60, 0xC0, 0x60, 0x18, 0x10, 0x03, 0x08, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x44, 0x00, 0x21, 0x80, 0x18, 0x30, 0x0C, 0x06, 0x0E, 0x00, 0x7E,
  0x00, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x80,
  0x04, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x23, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00,
  0x46, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x04,
  0x08, 0x03, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x08, 0x00,
  0x44, 0x00, 0x13, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x01,
  0xFE, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01,
  0x30, 0x00, 0xC4, 0x00, 0x31, 0x80, 0x1C, 0x20, 0x0A, 0x06, 0x0C, 0x80,
  0xFC, 0x20, 0x0C, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x02,
  0x08, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x06, 0x10, 0x00,
  0x61, 0x00, 0x04, 0x10, 0x00, 0x43, 0x00, 0x04, 0x30, 0x00, 0x43, 0xFF,
  0xFC, 0x20, 0x00, 0xC2, 0x00, 0x08, 0x20, 0x00, 0x86, 0x00, 0x08, 0x60,
  0x00, 0x86, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x0C,
  0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x30, 0x30,
  0x30, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0xC0, 0x06,
  0x03, 0x00, 0x30, 0x08, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x80, 0x60, 0x06,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x04, 0x30,
  0x00, 0x11, 0xC0, 0x00, 0xCD, 0x80, 0x03, 0x62, 0x00, 0x0F, 0x0C, 0x00,
  0x38, 0x10, 0x00, 0xC0, 0x60, 0x02, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x01,
  0x01, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x03, 0xFF, 0xF8, 0x06, 0x00,
  0x1C, 0x18, 0x00, 0x60, 0xE0, 0x02, 0x83, 0xC0, 0x1A, 0x09, 0x00, 0x58,
  0x24, 0x03, 0x60, 0x90, 0x09, 0x02, 0x60, 0x44, 0x18, 0x83, 0x10, 0x62,
  0x08, 0x41, 0x0C, 0x63, 0x04, 0x11, 0x0C, 0x10, 0x48, 0x20, 0x41, 0x60,
  0x83, 0x07, 0x02, 0x0C, 0x08, 0x08, 0x20, 0x20, 0x20, 0x80, 0x01, 0x82,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x01, 0x04, 0x00,
  0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00, 0x02, 0x0C, 0x00, 0x08,
  0x00, 0x0E, 0x00, 0x10, 0xE0, 0x03, 0x0A, 0x00, 0x30, 0xB0, 0x02, 0x0B,
  0x00, 0x21, 0x90, 0x02, 0x19, 0x00, 0x21, 0x18, 0x06, 0x10, 0x80, 0x61,
  0x08, 0x04, 0x10, 0xC0, 0x43, 0x04, 0x04, 0x30, 0x40, 0x42, 0x06, 0x0C,
  0x20, 0x20, 0xC2, 0x02, 0x08, 0x20, 0x30, 0x86, 0x01, 0x08, 0x60, 0x10,
  0x84, 0x01, 0x88, 0x40, 0x19, 0x84, 0x00, 0x98, 0x40, 0x0D, 0x0C, 0x00,
  0xD0, 0xC0, 0x05, 0x08, 0x00, 0x70, 0x80, 0x07, 0x00, 0x00, 0xFC, 0x00,
  0xC0, 0xC0, 0x40, 0x18, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x32, 0x00,
  0x04, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x8C, 0x00,
  0x61, 0x00, 0x10, 0x60, 0x18, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x30, 0x80,
  0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x3F, 0xFE, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40,
  0x18, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x04, 0x80, 0x01,
  0x60, 0x00, 0x50, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00,
  0x1A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x8C, 0x00, 0x61, 0x00, 0x10,
  0x60, 0x18, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x81, 0x00,
  0x30, 0x60, 0x04, 0x60, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x30, 0x80, 0x03,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x10, 0x00,
  0x21, 0x00, 0x06, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x3F, 0xFE, 0x03, 0x02,
  0x00, 0x20, 0x30, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x80, 0x60,
  0x08, 0x06, 0x00, 0xC0, 0x40, 0x04, 0x04, 0x00, 0x60, 0x40, 0x02, 0x04,
  0x00, 0x30, 0xC0, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x1C, 0x07, 0x01, 0x80,
  0x0C, 0x18, 0x00, 0x30, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x21, 0x00, 0x03, 0x18, 0x00, 0x10, 0x30, 0x01, 0x00, 0xE0,
  0x30, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04,
  0x60, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x10,
  0x80, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x03, 0x10, 0x00, 0x62,
  0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x82, 0x00, 0x20, 0x40, 0x08, 0x06,
  0x06, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x02,
  0x60, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10,
  0x40, 0x06, 0x08, 0x00, 0x81, 0x80, 0x30, 0x30, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x20, 0x08, 0x0C, 0x01, 0x01, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00,
  0x43, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0xC0, 0x00,
  0xD0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x19, 0x00, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30,
  0x00, 0x11, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x60, 0x42, 0x07, 0x02,
  0x10, 0x28, 0x10, 0x81, 0x41, 0x84, 0x12, 0x08, 0x20, 0x90, 0x41, 0x0C,
  0x82, 0x08, 0x44, 0x30, 0x46, 0x31, 0x06, 0x21, 0x88, 0x33, 0x04, 0x41,
  0x90, 0x26, 0x0C, 0x81, 0x20, 0x48, 0x09, 0x02, 0x40, 0x48, 0x16, 0x02,
  0xC0, 0xA0, 0x14, 0x07, 0x00, 0xE0, 0x30, 0x07, 0x00, 0x06, 0x00, 0x03,
  0x02, 0x00, 0x04, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x18, 0x01, 0x80, 0x30,
  0x00, 0x80, 0x20, 0x00, 0xC0, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x41, 0x80,
  0x00, 0x63, 0x00, 0x00, 0x22, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x64, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x82, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0x00,
  0x04, 0x01, 0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x40,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x1E, 0x00, 0x01, 0x10,
  0x00, 0x18, 0xC0, 0x01, 0x82, 0x00, 0x18, 0x18, 0x00, 0x80, 0x40, 0x08,
  0x03, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x0C,
  0x40, 0x00, 0x26, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0xFF, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x03, 0xFE, 0x08, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC1, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x04, 0x80, 0x02, 0x20, 0x01, 0x84, 0x00, 0xC1, 0x00,
  0x20, 0x60, 0x10, 0x08, 0x0C, 0x03, 0x06, 0x00, 0x41, 0x00, 0x10, 0x80,
  0x02, 0x60, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x08, 0xFF, 0xFF, 0xC0, 0xC4,
  0x62, 0x11, 0x03, 0xF0, 0x86, 0x04, 0xC6, 0x01, 0x66, 0x00, 0x66, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x05, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32, 0x00, 0x19, 0x00, 0x18,
  0xC0, 0x14, 0x20, 0x12, 0x0C, 0x11, 0x03, 0xF0, 0xF0, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0xF8, 0x09, 0x83, 0x05, 0x00, 0xC3, 0x00, 0x33, 0x80,
  0x09, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x58,
  0x00, 0x28, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04,
  0xE0, 0x06, 0x70, 0x06, 0x26, 0x0E, 0x10, 0xFC, 0x00, 0x01, 0xF8, 0x06,
  0x0C, 0x18, 0x02, 0x10, 0x03, 0x20, 0x02, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x03, 0x40, 0x06, 0x40, 0x0C, 0x20, 0x18, 0x18, 0x30, 0x0F,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x03, 0xF0, 0x83, 0x02, 0x61,
  0x80, 0x58, 0xC0, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00,
  0x0C, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02,
  0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x30, 0xC0, 0x14, 0x10, 0x09, 0x03,
  0x04, 0x40, 0x7E, 0x30, 0x01, 0xF8, 0x06, 0x06, 0x08, 0x03, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x02, 0xC0, 0x0C, 0xC0, 0xF0,
  0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x03, 0x40, 0x02,
  0x40, 0x04, 0x20, 0x0C, 0x18, 0x30, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x80, 0x40, 0x00, 0xC0,
  0x40, 0x00, 0x60, 0x40, 0x00, 0x30, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x02, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x41, 0x81,
  0x30, 0xC0, 0x2C, 0x60, 0x06, 0x30, 0x00, 0x88, 0x00, 0x22, 0x00, 0x09,
  0x80, 0x06, 0x40, 0x01, 0x90, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x18, 0x60, 0x0A, 0x08, 0x06,
  0x81, 0x83, 0x20, 0x3F, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x20, 0x04, 0x06, 0x06, 0x00, 0x7E, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0xF8, 0x19, 0x06, 0x12, 0x02, 0x14, 0x01, 0x18,
  0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x03, 0x20, 0x03, 0x20,
  0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40,
  0x04, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x08, 0x08, 0x0E, 0x0C, 0x08, 0x06, 0x18,
  0x02, 0x10, 0x01, 0x30, 0x00, 0xB0, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x80, 0x60, 0x40, 0x40, 0x20,
  0x40, 0x10, 0x40, 0x08, 0x40, 0x04, 0xC0, 0x02, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xFC, 0x02, 0x60, 0xC0, 0x50,
  0x0C, 0x0C, 0x00, 0x83, 0x80, 0x10, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x00,
  0x10, 0x20, 0x04, 0x04, 0x03, 0x01, 0x83, 0x80, 0x31, 0x80, 0x04, 0x30,
  0x00, 0x82, 0x00, 0x90, 0x20, 0x1A, 0x06, 0x04, 0xC0, 0x43, 0x18, 0x0C,
  0xC2, 0x00, 0xB0, 0x40, 0x1C, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x04, 0x60, 0x21, 0x03, 0x04, 0x18,
  0x11, 0x80, 0xCC, 0x03, 0x40, 0x0E, 0x00, 0x19, 0xE1, 0xE0, 0xD1, 0x91,
  0x87, 0x05, 0x04, 0x30, 0x30, 0x31, 0x01, 0x81, 0x08, 0x08, 0x08, 0x40,
  0x40, 0x46, 0x02, 0x02, 0x30, 0x30, 0x11, 0x01, 0x81, 0x88, 0x08, 0x0C,
  0x40, 0x40, 0x42, 0x02, 0x02, 0x30, 0x10, 0x11, 0x81, 0x80, 0x88, 0x0C,
  0x0C, 0x40, 0x40, 0x62, 0x02, 0x02, 0x10, 0x10, 0x11, 0x81, 0x80, 0x80,
  0x18, 0xF8, 0x11, 0x06, 0x12, 0x02, 0x14, 0x01, 0x18, 0x01, 0x30, 0x01,
  0x30, 0x01, 0x20, 0x01, 0x20, 0x03, 0x20, 0x03, 0x20, 0x02, 0x60, 0x02,
  0x60, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04,
  0xC0, 0x04, 0x80, 0x04, 0x01, 0xF8, 0x03, 0x06, 0x06, 0x00, 0x82, 0x00,
  0x22, 0x00, 0x13, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x09,
  0x80, 0x0C, 0x40, 0x04, 0x30, 0x04, 0x0C, 0x0C, 0x01, 0xF8, 0x00, 0x08,
  0x7C, 0x02, 0x60, 0xC0, 0xA0, 0x18, 0x70, 0x03, 0x1C, 0x00, 0x46, 0x00,
  0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04,
  0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x70,
  0x03, 0x1C, 0x01, 0x84, 0xC1, 0xC1, 0x0F, 0xC0, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xF0, 0x86, 0x04, 0xC6, 0x01, 0x66, 0x00, 0x66, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x05, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32, 0x00, 0x19, 0x00, 0x1C,
  0xC0, 0x14, 0x20, 0x1A, 0x0C, 0x19, 0x03, 0xF1, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x7F, 0x0F, 0xF0, 0x26, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0x80, 0xC0, 0xC0, 0x0C, 0x60, 0x02, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0xC0, 0x01, 0x18, 0x00, 0xC3, 0x80, 0xE0, 0x1F, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x03, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x03, 0x81, 0x01,
  0x80, 0x41, 0x80, 0x30, 0x80, 0x0C, 0xC0, 0x02, 0x40, 0x00, 0xE0, 0x00,
  0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x18, 0x80, 0x28, 0xC0, 0x48,
  0x60, 0x98, 0x3F, 0x18, 0xFC, 0x01, 0x82, 0x00, 0x43, 0x00, 0x21, 0x80,
  0x10, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x43, 0x00, 0x61, 0x00, 0x20, 0x80, 0x30, 0x40, 0x10,
  0x20, 0x10, 0x10, 0x10, 0x18, 0x30, 0x0C, 0x70, 0x03, 0xC0, 0x00, 0x20,
  0x20, 0xC4, 0x04, 0x08, 0x80, 0x81, 0x30, 0x30, 0x26, 0x06, 0x04, 0x80,
  0x80, 0x90, 0x10, 0x1A, 0x02, 0x03, 0x40, 0x40, 0x58, 0x18, 0x0B, 0x03,
  0x01, 0x40, 0x40, 0x28, 0x08, 0x05, 0x01, 0x01, 0xA0, 0x60, 0x24, 0x0C,
  0x04, 0x82, 0x81, 0x10, 0x50, 0x63, 0x13, 0x18, 0x3C, 0x3C, 0x00, 0x03,
  0x81, 0xF0, 0x72, 0x18, 0xCE, 0x11, 0x02, 0xC0, 0xC8, 0x10, 0x02, 0x80,
  0x80, 0x14, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40, 0x30, 0x02,
  0x02, 0x80, 0x10, 0x14, 0x02, 0x81, 0x30, 0x34, 0x08, 0x86, 0x31, 0x84,
  0xC0, 0xF0, 0x1C, 0x00, 0x04, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x06,
  0x00, 0x20, 0xC0, 0x04, 0x10, 0x00, 0x82, 0x00, 0x30, 0x40, 0x06, 0x08,
  0x00, 0x83, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20,
  0x03, 0x04, 0x00, 0x40, 0x80, 0x18, 0x10, 0x05, 0x03, 0x01, 0x20, 0x30,
  0x4C, 0x03, 0xF1, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x08, 0x03, 0x03, 0xC0, 0xC0, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x61, 0x03, 0xC8, 0x40, 0x0F, 0x08, 0x00, 0x62, 0x00, 0x18, 0x40,
  0x04, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0x41, 0x80,
  0x08, 0x70, 0x01, 0x1F, 0xE0, 0x33, 0x0F, 0xE2, 0x40, 0x1F, 0x80, 0x00,
  0xFF, 0x80, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x80, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x22, 0x30, 0x04,
  0x83, 0x01, 0xB0, 0x20, 0x24, 0x02, 0x09, 0x80, 0x23, 0x20, 0x03, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 27, 23, 8, -27 },
  { 25, 9, 10, 23, 9, -28 },
  { 37, 22, 27, 23, 1, -27 },
  { 112, 21, 35, 23, 1, -31 },
  { 204, 26, 27, 23, -1, -27 },
  { 292, 22, 27, 23, 0, -27 },
  { 367, 3, 10, 23, 12, -28 },
  { 371, 12, 34, 23, 9, -29 },
  { 422, 13, 34, 23, 2, -29 },
  { 478, 20, 19, 23, 2, -21 },
  { 526, 18, 19, 23, 3, -21 },
  { 569, 6, 10, 23, 6, -4 },
  { 577, 11, 1, 23, 6, -12 },
  { 579, 4, 3, 23, 8, -3 },
  { 581, 21, 34, 23, 1, -29 },
  { 671, 18, 27, 23, 3, -27 },
  { 732, 17, 27, 23, 2, -27 },
  { 790, 18, 27, 23, 2, -27 },
  { 851, 18, 27, 23, 2, -27 },
  { 912, 20, 27, 23, 1, -27 },
  { 980, 19, 27, 23, 2, -27 },
  { 1045, 17, 27, 23, 3, -27 },
  { 1103, 18, 27, 23, 4, -27 },
  { 1164, 19, 27, 23, 2, -27 },
  { 1229, 17, 27, 23, 4, -27 },
  { 1287, 6, 20, 23, 8, -20 },
  { 1302, 8, 26, 23, 6, -20 },
  { 1328, 19, 21, 23, 3, -22 },
  { 1378, 19, 8, 23, 2, -16 },
  { 1397, 18, 21, 23, 2, -22 },
  { 1445, 15, 27, 23, 6, -27 },
  { 1496, 18, 31, 23, 3, -27 },
  { 1566, 19, 27, 23, 0, -27 },
  { 1631, 18, 27, 23, 2, -27 },
  { 1692, 18, 27, 23, 3, -27 },
  { 1753, 19, 27, 23, 2, -27 },
  { 1818, 20, 27, 23, 2, -27 },
  { 1886, 21, 27, 23, 2, -27 },
  { 1957, 18, 27, 23, 3, -27 },
  { 2018, 20, 27, 23, 2, -27 },
  { 2086, 20, 27, 23, 2, -27 },
  { 2154, 17, 27, 23, 3, -27 },
  { 2212, 22, 27, 23, 2, -27 },
  { 2287, 15, 27, 23, 4, -27 },
  { 2338, 22, 27, 23, 1, -27 },
  { 2413, 20, 27, 23, 2, -27 },
  { 2481, 18, 27, 23, 3, -27 },
  { 2542, 20, 27, 23, 2, -27 },
  { 2610, 18, 33, 23, 3, -27 },
  { 2685, 20, 27, 23, 2, -27 },
  { 2753, 21, 27, 23, 1, -27 },
  { 2824, 20, 27, 23, 4, -27 },
  { 2892, 19, 27, 23, 3, -27 },
  { 2957, 19, 27, 23, 5, -27 },
  { 3022, 21, 27, 23, 3, -27 },
  { 3093, 24, 27, 23, 0, -27 },
  { 3174, 21, 27, 23, 4, -27 },
  { 3245, 23, 27, 23, 0, -27 },
  { 3323, 15, 34, 23, 7, -29 },
  { 3387, 9, 34, 23, 7, -29 },
  { 3426, 15, 34, 23, 1, -29 },
  { 3490, 18, 15, 23, 3, -27 },
  { 3524, 18, 1, 23, 0, 5 },
  { 3527, 4, 6, 23, 9, -29 },
  { 3530, 17, 20, 23, 3, -20 },
  { 3573, 17, 28, 23, 3, -28 },
  { 3633, 16, 20, 23, 3, -20 },
  { 3673, 18, 28, 23, 3, -28 },
  { 3736, 16, 20, 23, 3, -20 },
  { 3776, 24, 36, 23, 0, -28 },
  { 3884, 18, 28, 23, 2, -20 },
  { 3947, 16, 28, 23, 3, -28 },
  { 4003, 17, 29, 23, 3, -29 },
  { 4065, 16, 37, 23, 4, -29 },
  { 4139, 19, 28, 23, 3, -28 },
  { 4206, 14, 28, 23, 5, -28 },
  { 4255, 21, 20, 23, 1, -20 },
  { 4308, 16, 20, 23, 3, -20 },
  { 4348, 17, 20, 23, 3, -20 },
  { 4391, 18, 28, 23, 2, -20 },
  { 4454, 17, 28, 23, 3, -20 },
  { 4514, 19, 20, 23, 4, -20 },
  { 4562, 18, 20, 23, 2, -20 },
  { 4607, 18, 27, 23, 3, -27 },
  { 4668, 16, 20, 23, 4, -20 },
  { 4708, 17, 20, 23, 3, -20 },
  { 4751, 19, 20, 23, 3, -20 },
  { 4799, 21, 20, 23, 1, -20 },
  { 4852, 19, 28, 23, 1, -20 },
  { 4919, 19, 20, 23, 2, -20 },
  { 4967, 17, 34, 23, 5, -29 },
  { 5040, 7, 34, 23, 8, -29 },
  { 5070, 17, 34, 23, 2, -29 },
  { 5143, 19, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC38PT7B_H_
