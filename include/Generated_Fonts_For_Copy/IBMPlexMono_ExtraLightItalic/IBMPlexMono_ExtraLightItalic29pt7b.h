#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC29PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x00, 0x00,
  0x19, 0xC0, 0x66, 0x89, 0x12, 0x24, 0x48, 0xA3, 0x00, 0x00, 0x63, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10,
  0xC0, 0x7C, 0x3F, 0x21, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18, 0x40,
  0x7C, 0x3F, 0x21, 0x08, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x08, 0x40, 0x04,
  0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x03, 0xF8, 0x0C, 0x4C, 0x18, 0x42, 0x10, 0x43, 0x30, 0x80, 0x20, 0x80,
  0x30, 0x80, 0x10, 0x80, 0x0C, 0x80, 0x07, 0x80, 0x01, 0x70, 0x01, 0x08,
  0x01, 0x0C, 0x01, 0x04, 0x01, 0x04, 0x02, 0x04, 0x82, 0x08, 0x42, 0x18,
  0x32, 0x30, 0x0F, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0xC0,
  0x30, 0x42, 0x02, 0x08, 0x20, 0x40, 0x82, 0x08, 0x10, 0x31, 0x01, 0x02,
  0x10, 0x10, 0x22, 0x01, 0x02, 0x40, 0x08, 0x48, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x13, 0x18, 0x02, 0x20, 0x80, 0x44, 0x08, 0x04, 0x40, 0x80,
  0x84, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x63, 0x0C, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0x0C, 0x01, 0x02, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x10, 0x20, 0x08, 0x10, 0x02, 0x10, 0x07, 0x30, 0x0C, 0x60, 0x08,
  0x10, 0x04, 0x08, 0x06, 0x02, 0x02, 0x01, 0x81, 0x00, 0x41, 0x80, 0x51,
  0x20, 0x2C, 0x98, 0x62, 0x83, 0xE0, 0x80, 0x69, 0x24, 0xB0, 0x01, 0x81,
  0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x60, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x18, 0x20, 0x8E, 0x5E, 0x83,
  0xC0, 0x07, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x86, 0x02, 0x04, 0x08, 0x04,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x18, 0x8C, 0x42, 0x21, 0x18, 0xFF, 0x7C, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x07, 0x0C, 0x18, 0x30, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0xC0, 0x31, 0x00, 0x82, 0x0C,
  0x07, 0xC0, 0x00, 0x60, 0x06, 0x80, 0x32, 0x01, 0x90, 0x18, 0x40, 0xC1,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F,
  0xFF, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x44, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x1F, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x80, 0x19, 0x00, 0x42, 0x06,
  0x07, 0xE0, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x40, 0x04, 0x80,
  0x11, 0x00, 0x42, 0x01, 0x04, 0x04, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80,
  0x82, 0x01, 0x08, 0x02, 0x20, 0x08, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x0F, 0xFC, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x27, 0xC0, 0xE0, 0x82, 0x01, 0x10,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x80, 0x12, 0x00, 0x86,
  0x0C, 0x07, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x27, 0xC2, 0xC1, 0x98, 0x04, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x12, 0x01, 0x08, 0x30, 0x3F, 0x00,
  0x7F, 0xFD, 0x00, 0x34, 0x00, 0x90, 0x04, 0x80, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x03,
  0xF0, 0x30, 0x61, 0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x4C,
  0x02, 0x18, 0x30, 0x1F, 0x03, 0x83, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0xC6, 0x06, 0x07, 0xE0, 0x0F, 0xC0,
  0xC1, 0x18, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x16, 0x01, 0x98, 0x34, 0x3E, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x80, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x82, 0x0C, 0x10, 0x20, 0x81, 0x06, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x00, 0x0F, 0x83, 0x06, 0x60, 0x24, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x18, 0x0E, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x03, 0xE0,
  0x10, 0x60, 0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x12, 0x1E, 0x48, 0xC6,
  0x42, 0x09, 0x10, 0x24, 0x40, 0x91, 0x02, 0x48, 0x0A, 0x20, 0x48, 0x81,
  0x21, 0x0C, 0x86, 0xD2, 0x04, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x32, 0x00, 0x42, 0x01, 0x84, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x20,
  0x60, 0x40, 0x80, 0xC3, 0xFF, 0x84, 0x01, 0x18, 0x02, 0x20, 0x04, 0xC0,
  0x09, 0x00, 0x1E, 0x00, 0x10, 0x1F, 0xF0, 0x40, 0x61, 0x00, 0x88, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x31, 0xFF, 0x04, 0x03,
  0x10, 0x04, 0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00,
  0x48, 0x06, 0x3F, 0xF0, 0x07, 0xC0, 0x61, 0x84, 0x06, 0x40, 0x16, 0x00,
  0xA0, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x06, 0x80, 0x26, 0x02, 0x18, 0x20, 0x3E,
  0x00, 0x1F, 0xE0, 0x40, 0xC1, 0x00, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x03, 0x40, 0x09,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x80, 0x12, 0x00, 0x88, 0x0C, 0x3F, 0xC0,
  0x1F, 0xFE, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xF1, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x10, 0x60, 0x80, 0xC4, 0x01, 0x20,
  0x04, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x7E, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0xC3,
  0x0D, 0x07, 0xC4, 0x08, 0x01, 0x08, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x20, 0x04, 0x3F, 0xFC, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0x0F, 0xFF, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x07,
  0xFC, 0x20, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x80, 0x63, 0x01, 0x06, 0x18, 0x0F, 0x80, 0x10, 0x03,
  0x10, 0x06, 0x10, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x20, 0x80,
  0x21, 0x00, 0x22, 0x00, 0x27, 0x00, 0x49, 0x00, 0x51, 0x80, 0x60, 0x80,
  0x40, 0xC0, 0x40, 0x40, 0xC0, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10,
  0x80, 0x18, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0x18, 0x03, 0x18, 0x03, 0x14, 0x05,
  0x14, 0x09, 0x14, 0x0A, 0x14, 0x12, 0x22, 0x22, 0x22, 0x22, 0x22, 0x42,
  0x21, 0x42, 0x21, 0x84, 0x21, 0x04, 0x41, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08, 0x0C, 0x01,
  0x0C, 0x01, 0x14, 0x02, 0x16, 0x02, 0x12, 0x02, 0x12, 0x02, 0x13, 0x02,
  0x11, 0x02, 0x21, 0x04, 0x21, 0x84, 0x20, 0x84, 0x20, 0x84, 0x20, 0x84,
  0x20, 0x44, 0x40, 0x48, 0x40, 0x48, 0x40, 0x28, 0x40, 0x28, 0x40, 0x28,
  0xC0, 0x18, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0xC0, 0x31, 0x00, 0x82, 0x0C, 0x07,
  0xC0, 0x1F, 0xF0, 0x20, 0x18, 0x40, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00,
  0xC8, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x31, 0xFF, 0x82, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0xC0, 0x31, 0x00, 0x82, 0x0C,
  0x07, 0xC0, 0x02, 0x00, 0x08, 0x20, 0x11, 0x00, 0x68, 0x00, 0xC0, 0x1F,
  0xF0, 0x20, 0x18, 0x40, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0xC8, 0x01,
  0x10, 0x02, 0x20, 0x0C, 0x40, 0x31, 0xFF, 0x82, 0x08, 0x04, 0x10, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84, 0x00,
  0x80, 0x03, 0xF8, 0x0C, 0x0C, 0x18, 0x02, 0x10, 0x03, 0x30, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x08, 0x40,
  0x18, 0x30, 0x30, 0x1F, 0xC0, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x10, 0x02, 0x20, 0x0C, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x06, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x20, 0x04, 0x40,
  0x08, 0xC0, 0x30, 0x80, 0x41, 0x83, 0x00, 0xFC, 0x00, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x09,
  0x00, 0x24, 0x00, 0xA0, 0x03, 0x80, 0x04, 0x00, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x41, 0x84, 0x42, 0x84,
  0x42, 0x84, 0x44, 0x84, 0x44, 0x88, 0x44, 0x88, 0x48, 0x88, 0x48, 0x90,
  0x50, 0x90, 0x90, 0x50, 0xA0, 0x50, 0xA0, 0x60, 0xA0, 0x60, 0xC0, 0x60,
  0x08, 0x00, 0xC3, 0x00, 0x20, 0x40, 0x10, 0x18, 0x08, 0x02, 0x04, 0x00,
  0xC2, 0x00, 0x11, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x04, 0x80, 0x03, 0x20, 0x01, 0x84, 0x00, 0x41, 0x00, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x01, 0x06, 0x00, 0x43, 0x00, 0x08, 0x80, 0x03, 0x40,
  0x06, 0x40, 0x04, 0x60, 0x08, 0x20, 0x10, 0x20, 0x30, 0x10, 0x60, 0x10,
  0x40, 0x08, 0x80, 0x09, 0x00, 0x07, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xF0,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0F,
  0xF0, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x0C,
  0x0F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x1F, 0xC0,
  0x00, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x88, 0x04, 0x20, 0x20, 0x41, 0x81,
  0x04, 0x02, 0x20, 0x09, 0x00, 0x2C, 0x00, 0x40, 0xFF, 0xFC, 0x99, 0x12,
  0x0F, 0x88, 0xC3, 0x48, 0x0A, 0xC0, 0x34, 0x01, 0x60, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x0A, 0x30, 0xD0, 0xF8,
  0xE0, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x4F,
  0x84, 0x86, 0x28, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x1A, 0x00, 0xB8, 0x09, 0x20, 0x88, 0xF8, 0x00,
  0x07, 0xC0, 0xC1, 0x0C, 0x04, 0x40, 0x34, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x04, 0x80, 0x44, 0x06, 0x18, 0x60, 0x7C,
  0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x7C, 0x86, 0x0A, 0x20, 0x19, 0x80, 0x64, 0x00, 0xB0, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x84, 0x0E, 0x18, 0x68,
  0x1E, 0x20, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x14, 0x01, 0xA0, 0x19,
  0x07, 0x9F, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x04, 0x80, 0x24, 0x02, 0x18,
  0x60, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x20, 0x40, 0x04, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00, 0x02,
  0x80, 0x00, 0x60, 0x00, 0x03, 0xE4, 0x30, 0x51, 0x00, 0xCC, 0x03, 0x20,
  0x05, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x90,
  0x04, 0x20, 0x30, 0xC3, 0x40, 0xF1, 0x00, 0x04, 0x00, 0x20, 0x00, 0x88,
  0x06, 0x18, 0x30, 0x3F, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x4F, 0x82, 0x86, 0x38, 0x11, 0x80, 0x48, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08,
  0x80, 0x48, 0x02, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x81, 0x08, 0x61, 0x08, 0x13, 0x01, 0x40, 0x18, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x08, 0x10, 0x41, 0x02, 0x10,
  0x11, 0x00, 0xA0, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0xF8, 0x1A, 0x08, 0x28, 0x08, 0x60, 0x10,
  0x80, 0x21, 0x00, 0x82, 0x02, 0x08, 0x38, 0x11, 0x80, 0x22, 0x00, 0x42,
  0x06, 0x86, 0x19, 0x04, 0x44, 0x05, 0x08, 0x0C, 0x00, 0xFE, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x02, 0x20, 0xE4, 0x60, 0x98, 0x14,
  0x03, 0x00, 0x27, 0x1C, 0x51, 0x44, 0xC3, 0x09, 0x04, 0x12, 0x08, 0x24,
  0x10, 0x50, 0x20, 0xA0, 0x41, 0x41, 0x02, 0x82, 0x09, 0x04, 0x12, 0x08,
  0x28, 0x10, 0x50, 0x40, 0xA0, 0x83, 0x00, 0x13, 0xE0, 0xA1, 0x8E, 0x04,
  0x60, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x80, 0x07, 0xC0, 0xC1, 0x8C,
  0x04, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x04, 0x80, 0x24, 0x02, 0x10, 0x60, 0x7C, 0x00, 0x09, 0xF0, 0x48,
  0x61, 0x40, 0x46, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x70, 0x11, 0x20, 0x84, 0x7C, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xC8,
  0xC1, 0x48, 0x06, 0xC0, 0x34, 0x00, 0xE0, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x0D, 0x00, 0x44, 0x06, 0x30, 0xD0, 0x78, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0xFC, 0x7C, 0x16,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x07, 0xE0, 0xC0, 0xC8, 0x02, 0x40, 0x02, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x28, 0x01, 0x30, 0x30, 0x7E,
  0x00, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xFF, 0xF0,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x82, 0x0C, 0x08, 0x60, 0x26, 0x01, 0x20, 0x07, 0x00,
  0x60, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x81, 0x4C, 0x24, 0x3C, 0x40, 0xF8,
  0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x10, 0x80, 0x88, 0x08, 0x40, 0xC2, 0x0C, 0x11, 0x80, 0xF0, 0x00,
  0x20, 0x84, 0x82, 0x14, 0x10, 0x50, 0x41, 0x41, 0x05, 0x04, 0x14, 0x10,
  0x50, 0x41, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x82, 0x86, 0x0A, 0x24,
  0x47, 0x1E, 0x00, 0x06, 0x1E, 0x1B, 0x23, 0x61, 0x41, 0x81, 0x41, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x81, 0x00, 0x83,
  0x00, 0x83, 0x02, 0x84, 0x84, 0x88, 0x98, 0x70, 0x60, 0x18, 0x04, 0x40,
  0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x20, 0x50, 0xC2, 0x40, 0xF1, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x88, 0x04, 0x10, 0x60, 0x3F, 0x00, 0x1F, 0x84,
  0x83, 0xD4, 0x01, 0x90, 0x04, 0x40, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x83, 0x01, 0x10, 0x04, 0xF0, 0x12, 0xFE, 0x48, 0x1F,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x7C, 0x02,
  0x18, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x0F, 0x81, 0xC0, 0x18, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x07,
  0xF0, 0x00, 0x3C, 0x05, 0x98, 0x14, 0x30, 0xA0, 0x66, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 7, 7, 17, 7, -21 },
  { 21, 18, 20, 17, 0, -20 },
  { 66, 16, 26, 17, 1, -23 },
  { 118, 20, 20, 17, -1, -20 },
  { 168, 17, 20, 17, 0, -20 },
  { 211, 3, 7, 17, 9, -21 },
  { 214, 9, 26, 17, 7, -22 },
  { 244, 9, 26, 17, 2, -22 },
  { 274, 15, 14, 17, 2, -16 },
  { 301, 14, 15, 17, 2, -16 },
  { 328, 5, 8, 17, 4, -3 },
  { 333, 8, 1, 17, 5, -9 },
  { 334, 3, 2, 17, 6, -2 },
  { 335, 16, 26, 17, 1, -22 },
  { 387, 14, 20, 17, 2, -20 },
  { 422, 14, 20, 17, 1, -20 },
  { 457, 15, 20, 17, 1, -20 },
  { 495, 14, 20, 17, 1, -20 },
  { 530, 15, 20, 17, 1, -20 },
  { 568, 14, 20, 17, 2, -20 },
  { 603, 13, 20, 17, 2, -20 },
  { 636, 14, 20, 17, 3, -20 },
  { 671, 14, 20, 17, 2, -20 },
  { 706, 13, 20, 17, 3, -20 },
  { 739, 5, 15, 17, 6, -15 },
  { 749, 7, 20, 17, 4, -15 },
  { 767, 13, 16, 17, 3, -17 },
  { 793, 14, 6, 17, 2, -12 },
  { 804, 14, 16, 17, 1, -17 },
  { 832, 12, 20, 17, 4, -20 },
  { 862, 14, 23, 17, 2, -20 },
  { 903, 15, 20, 17, 0, -20 },
  { 941, 14, 20, 17, 2, -20 },
  { 976, 13, 20, 17, 3, -20 },
  { 1009, 14, 20, 17, 2, -20 },
  { 1044, 15, 20, 17, 2, -20 },
  { 1082, 15, 20, 17, 2, -20 },
  { 1120, 14, 20, 17, 2, -20 },
  { 1155, 16, 20, 17, 1, -20 },
  { 1195, 16, 20, 17, 1, -20 },
  { 1235, 14, 20, 17, 2, -20 },
  { 1270, 16, 20, 17, 2, -20 },
  { 1310, 11, 20, 17, 3, -20 },
  { 1338, 16, 20, 17, 1, -20 },
  { 1378, 16, 20, 17, 1, -20 },
  { 1418, 14, 20, 17, 2, -20 },
  { 1453, 15, 20, 17, 2, -20 },
  { 1491, 14, 25, 17, 2, -20 },
  { 1535, 15, 20, 17, 2, -20 },
  { 1573, 16, 20, 17, 1, -20 },
  { 1613, 15, 20, 17, 3, -20 },
  { 1651, 15, 20, 17, 2, -20 },
  { 1689, 14, 20, 17, 4, -20 },
  { 1724, 16, 20, 17, 2, -20 },
  { 1764, 18, 20, 17, 0, -20 },
  { 1809, 16, 20, 17, 3, -20 },
  { 1849, 18, 20, 17, 0, -20 },
  { 1894, 12, 26, 17, 5, -22 },
  { 1933, 7, 26, 17, 6, -22 },
  { 1956, 11, 26, 17, 1, -22 },
  { 1992, 14, 11, 17, 2, -20 },
  { 2012, 14, 1, 17, 0, 3 },
  { 2014, 3, 5, 17, 7, -22 },
  { 2016, 13, 15, 17, 2, -15 },
  { 2041, 13, 21, 17, 2, -21 },
  { 2076, 13, 15, 17, 2, -15 },
  { 2101, 14, 21, 17, 2, -21 },
  { 2138, 13, 15, 17, 2, -15 },
  { 2163, 18, 27, 17, 0, -21 },
  { 2224, 14, 21, 17, 1, -15 },
  { 2261, 13, 21, 17, 2, -21 },
  { 2296, 12, 21, 17, 3, -21 },
  { 2328, 12, 27, 17, 3, -21 },
  { 2369, 15, 21, 17, 2, -21 },
  { 2409, 11, 21, 17, 4, -21 },
  { 2438, 15, 15, 17, 1, -15 },
  { 2467, 13, 15, 17, 2, -15 },
  { 2492, 13, 15, 17, 2, -15 },
  { 2517, 14, 21, 17, 1, -15 },
  { 2554, 13, 21, 17, 2, -15 },
  { 2589, 14, 15, 17, 3, -15 },
  { 2616, 13, 15, 17, 2, -15 },
  { 2641, 14, 20, 17, 2, -20 },
  { 2676, 12, 15, 17, 3, -15 },
  { 2699, 13, 15, 17, 2, -15 },
  { 2724, 14, 15, 17, 2, -15 },
  { 2751, 16, 15, 17, 1, -15 },
  { 2781, 14, 21, 17, 1, -15 },
  { 2818, 14, 15, 17, 2, -15 },
  { 2845, 14, 26, 17, 3, -22 },
  { 2891, 6, 26, 17, 6, -22 },
  { 2911, 13, 26, 17, 1, -22 },
  { 2954, 14, 5, 17, 2, -12 },
};

const GFXfont IBMPlexMono_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC29PT7B_H_
