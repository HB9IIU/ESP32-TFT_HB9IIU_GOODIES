#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC53PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x30, 0x33, 0x03, 0x30, 0x33,
  0x06, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xC6,
  0x0C, 0xC0, 0xCC, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xC0, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x04, 0x78, 0x01, 0xC0, 0xC0, 0xE0,
  0x38, 0x0C, 0x06, 0x07, 0x00, 0xC0, 0x30, 0x60, 0x08, 0x02, 0x06, 0x00,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x01, 0xFB, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x2F, 0xC0, 0x00,
  0x06, 0x1E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x18, 0x80, 0x08,
  0x03, 0x8C, 0x00, 0x80, 0x30, 0xE0, 0x18, 0x07, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x18, 0x1C, 0x01, 0xF1, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0C, 0x03, 0x83, 0x80, 0x03, 0x00, 0xC0, 0x18,
  0x00, 0x40, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0x80,
  0x04, 0x01, 0x80, 0x30, 0x00, 0x80, 0x20, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x18, 0x10,
  0x00, 0x60, 0x06, 0x06, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x30,
  0x60, 0x00, 0x1C, 0x1C, 0x08, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x07, 0xFC,
  0x00, 0x00, 0xC1, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x0C, 0x00, 0x0C, 0x0C,
  0x01, 0x80, 0x01, 0x83, 0x00, 0x10, 0x00, 0x60, 0x60, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x40, 0x06, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x60, 0x02, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x06, 0x00, 0x0E,
  0x0F, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x3F, 0x8E, 0x00, 0x03, 0xC7,
  0xF0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x02,
  0x00, 0x01, 0x80, 0x28, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x2C, 0x03, 0xC0,
  0x00, 0x98, 0x1B, 0x00, 0x06, 0x70, 0xC6, 0x00, 0x10, 0xC3, 0x1C, 0x01,
  0xC3, 0x98, 0x38, 0x0E, 0x06, 0xE0, 0x7F, 0xF0, 0x0F, 0x00, 0x7F, 0x00,
  0x38, 0x00, 0x33, 0x33, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x0F, 0xE0, 0x18, 0x0F,
  0x8F, 0x82, 0x0F, 0x80, 0x3E, 0x5F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x60, 0x40, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x0E, 0x00, 0xF8, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x1C, 0x00,
  0x18, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x1E, 0x40, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xC0, 0x03,
  0xC0, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0x80, 0x1C, 0x01, 0x80, 0x08,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x38, 0x00, 0x03, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x61, 0xFE, 0x00, 0x0C, 0xFF, 0xF0, 0x01,
  0xB8, 0x0F, 0x00, 0x2C, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x19, 0xFF, 0xE0,
  0x67, 0x80, 0xF0, 0xD8, 0x00, 0x73, 0x60, 0x00, 0x67, 0x80, 0x00, 0xEE,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x18, 0xE0, 0x00,
  0x60, 0xE0, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xD8, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x1C, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xE0,
  0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E,
  0x60, 0x00, 0x1E, 0x30, 0x00, 0x3C, 0x38, 0x00, 0x6C, 0x1E, 0x03, 0xCC,
  0x0F, 0xFF, 0x18, 0x03, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x78, 0x38, 0x00, 0xC3, 0x00, 0x03, 0x30,
  0x00, 0x1D, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x63, 0x00, 0x7C, 0x31, 0x80, 0xFF, 0x90, 0xC0, 0xE0, 0x48, 0xC0, 0x60,
  0x1C, 0x60, 0x60, 0x06, 0x30, 0x20, 0x03, 0x18, 0x30, 0x01, 0x88, 0x18,
  0x00, 0xCC, 0x08, 0x00, 0x46, 0x0C, 0x00, 0x63, 0x06, 0x00, 0x31, 0x83,
  0x00, 0x18, 0xC1, 0x80, 0x0C, 0x40, 0xC0, 0x06, 0x60, 0x60, 0x06, 0x30,
  0x30, 0x03, 0x18, 0x18, 0x01, 0x8C, 0x0C, 0x01, 0xC6, 0x06, 0x01, 0x63,
  0x01, 0x81, 0xB1, 0x80, 0xFF, 0x90, 0xC0, 0x3F, 0x98, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x09, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x06, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0xF0, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x08,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x70, 0x20, 0x00, 0x38, 0x18, 0x00, 0x3C, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x04, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x78, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x30,
  0x03, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x3E, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0x07,
  0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x38, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0xFF,
  0xC6, 0x00, 0x7F, 0xF3, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C,
  0x0C, 0x00, 0x0B, 0x03, 0x00, 0x06, 0xC0, 0x60, 0x03, 0x20, 0x1E, 0x03,
  0x98, 0x01, 0xFF, 0xC6, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x01,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00,
  0x61, 0xF0, 0x00, 0x01, 0x8E, 0x60, 0x00, 0x06, 0x61, 0x80, 0x00, 0x1B,
  0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1E, 0x05, 0x80, 0x00, 0xF0, 0x6C, 0x00, 0x0D, 0x83,
  0x60, 0x00, 0xC8, 0x19, 0x00, 0x06, 0x40, 0xCC, 0x00, 0x66, 0x06, 0x60,
  0x03, 0x30, 0x21, 0x00, 0x31, 0x83, 0x0C, 0x03, 0x0C, 0x18, 0x60, 0x18,
  0x40, 0xC3, 0x01, 0x82, 0x06, 0x08, 0x0C, 0x30, 0x30, 0x60, 0xC1, 0x81,
  0x03, 0x0C, 0x0C, 0x18, 0x08, 0x60, 0x60, 0xC0, 0x46, 0x02, 0x06, 0x03,
  0x20, 0x10, 0x30, 0x1B, 0x01, 0x81, 0x80, 0x70, 0x0C, 0x08, 0x03, 0x80,
  0x60, 0xC0, 0x18, 0x03, 0x06, 0x00, 0x80, 0x10, 0x30, 0x04, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x02, 0x06, 0xC0, 0x00, 0x60, 0x6C, 0x00, 0x06, 0x06, 0xC0,
  0x00, 0x60, 0x64, 0x00, 0x06, 0x06, 0x60, 0x00, 0x60, 0x46, 0x00, 0x04,
  0x0C, 0x60, 0x00, 0xC0, 0xC3, 0x00, 0x0C, 0x0C, 0x30, 0x00, 0xC0, 0xC3,
  0x00, 0x0C, 0x0C, 0x18, 0x00, 0xC0, 0x81, 0x80, 0x08, 0x18, 0x18, 0x01,
  0x81, 0x80, 0xC0, 0x18, 0x18, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x18, 0x18,
  0x06, 0x01, 0x81, 0x00, 0x60, 0x10, 0x30, 0x06, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x30, 0x03, 0x03, 0x03, 0x00, 0x30, 0x30, 0x30, 0x01, 0x83, 0x02,
  0x00, 0x18, 0x20, 0x60, 0x01, 0x86, 0x06, 0x00, 0x0C, 0x60, 0x60, 0x00,
  0xC6, 0x06, 0x00, 0x0C, 0x60, 0x60, 0x00, 0x66, 0x04, 0x00, 0x06, 0x40,
  0xC0, 0x00, 0x6C, 0x0C, 0x00, 0x02, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x38, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x78, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x3C,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x05, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x1C,
  0x00, 0x18, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x78, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x02, 0x00, 0x0C, 0x07,
  0x80, 0x03, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0C,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x3C, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x04, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x01,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x1C, 0x01, 0x82, 0x00, 0xE0, 0x0C, 0x10, 0x05, 0x00,
  0x40, 0x80, 0x68, 0x06, 0x0C, 0x03, 0x60, 0x30, 0x60, 0x33, 0x01, 0x83,
  0x01, 0x98, 0x08, 0x18, 0x18, 0xC0, 0xC0, 0xC0, 0xC6, 0x06, 0x06, 0x0C,
  0x30, 0x30, 0x30, 0x60, 0x81, 0x01, 0x82, 0x04, 0x18, 0x0C, 0x30, 0x20,
  0xC0, 0x61, 0x81, 0x86, 0x03, 0x18, 0x0C, 0x60, 0x10, 0xC0, 0x63, 0x00,
  0x8C, 0x03, 0x18, 0x04, 0x60, 0x18, 0x80, 0x62, 0x00, 0xCC, 0x03, 0x30,
  0x02, 0x60, 0x19, 0x00, 0x13, 0x00, 0xD8, 0x00, 0x90, 0x06, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xC3, 0x07, 0xC0, 0xE3, 0x0F, 0x00, 0x32, 0x0C,
  0x00, 0x16, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xB0, 0x60,
  0x01, 0xB0, 0x70, 0x03, 0x30, 0x3C, 0x0E, 0x3F, 0x1F, 0xFC, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x0F, 0xC0, 0x0C, 0x3F, 0xF0, 0x0C, 0x70, 0x3C, 0x0C, 0xC0, 0x0C, 0x0D,
  0x80, 0x06, 0x0F, 0x00, 0x06, 0x1A, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x50, 0x00, 0x18, 0xD0,
  0x00, 0x30, 0xCC, 0x00, 0xE0, 0xC7, 0x03, 0xC0, 0xC3, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0x01, 0xC0, 0x38,
  0x00, 0xC0, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x30, 0x03, 0x80, 0x78, 0x1E, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x01, 0xFC, 0x0C, 0x01, 0xFF, 0xC3, 0x00, 0xF0, 0x38, 0xC0,
  0xE0, 0x03, 0x20, 0x30, 0x00, 0x78, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18,
  0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x01, 0x80, 0x06, 0xC0, 0x70,
  0x03, 0x30, 0x0F, 0x03, 0x8C, 0x01, 0xFF, 0xC2, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x18, 0x00, 0x60,
  0x60, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x40, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00,
  0x1F, 0x08, 0x07, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x18, 0x30, 0x00, 0x70,
  0x30, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00,
  0xE1, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFC, 0x30, 0x1F, 0x03, 0x8C, 0x0E, 0x00, 0x32, 0x07, 0x00,
  0x07, 0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x03, 0xC0,
  0x60, 0x01, 0xB0, 0x1C, 0x00, 0xCC, 0x03, 0xC0, 0xE3, 0x00, 0x7F, 0xF0,
  0xC0, 0x07, 0xF0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x04,
  0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x38, 0x07, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x7E, 0x00, 0x63, 0xFF, 0x00, 0xCE, 0x07, 0x03, 0x30, 0x07, 0x06,
  0x40, 0x06, 0x0D, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60,
  0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x60,
  0x07, 0x01, 0x80, 0x70, 0x06, 0x03, 0x80, 0x10, 0x3C, 0x00, 0xC1, 0xC0,
  0x03, 0x0E, 0x00, 0x0C, 0xE0, 0x00, 0x37, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x40, 0x06, 0x01,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x60, 0x00,
  0xE0, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x1F, 0x80, 0x0C, 0x3F, 0xF8, 0x03,
  0x1C, 0x0F, 0x00, 0xCC, 0x00, 0xC0, 0x36, 0x00, 0x18, 0x0F, 0x00, 0x06,
  0x06, 0x80, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x30,
  0x01, 0xE0, 0x0C, 0x01, 0xE0, 0x03, 0x03, 0xC0, 0x00, 0xC3, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x08, 0x00, 0x06, 0x03, 0x00, 0x05, 0x80, 0x60,
  0x03, 0x60, 0x18, 0x01, 0x98, 0x03, 0x01, 0xC6, 0x00, 0xC0, 0xE3, 0x00,
  0x18, 0x70, 0xC0, 0x06, 0x38, 0x30, 0x00, 0xDC, 0x0C, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x18, 0x01,
  0xE0, 0xC0, 0x1C, 0x06, 0x03, 0x80, 0x30, 0x38, 0x01, 0x87, 0x00, 0x08,
  0x70, 0x00, 0xC7, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0xCF, 0xE1, 0xFE, 0x0D, 0x87, 0x18, 0x60, 0xF0,
  0x32, 0x03, 0x0E, 0x01, 0x40, 0x30, 0xC0, 0x14, 0x03, 0x1C, 0x01, 0x80,
  0x31, 0x80, 0x18, 0x03, 0x18, 0x01, 0x00, 0x31, 0x80, 0x30, 0x02, 0x18,
  0x03, 0x00, 0x21, 0x00, 0x30, 0x06, 0x30, 0x03, 0x00, 0x63, 0x00, 0x20,
  0x06, 0x30, 0x02, 0x00, 0x63, 0x00, 0x60, 0x04, 0x30, 0x06, 0x00, 0x42,
  0x00, 0x60, 0x0C, 0x60, 0x06, 0x00, 0xC6, 0x00, 0x40, 0x0C, 0x60, 0x04,
  0x00, 0xC6, 0x00, 0xC0, 0x08, 0x60, 0x0C, 0x00, 0x84, 0x00, 0xC0, 0x18,
  0xC0, 0x0C, 0x01, 0x8C, 0x00, 0x80, 0x18, 0xC0, 0x18, 0x01, 0x8C, 0x01,
  0x80, 0x10, 0x00, 0x0F, 0xC0, 0x0C, 0x7F, 0xE0, 0x11, 0xC0, 0xE0, 0x66,
  0x00, 0xE0, 0xC8, 0x00, 0xC1, 0xA0, 0x01, 0x83, 0x80, 0x01, 0x87, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x0C, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xC3, 0xFF, 0x00, 0x31, 0xC0, 0xF0,
  0x0C, 0xC0, 0x0C, 0x03, 0x60, 0x01, 0x80, 0xF0, 0x00, 0x60, 0x28, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x70, 0x50, 0x00, 0x18, 0x14, 0x00, 0x0C, 0x0C,
  0xC0, 0x0E, 0x03, 0x1C, 0x0F, 0x00, 0xC3, 0xFF, 0x80, 0x30, 0x3F, 0x80,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC3, 0x03, 0xC0, 0xE3, 0x0E, 0x00, 0x32, 0x0C, 0x00, 0x1E,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0xB0, 0x60, 0x01, 0xB0,
  0x70, 0x03, 0x30, 0x3C, 0x0E, 0x30, 0x1F, 0xFC, 0x30, 0x07, 0xF0, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xE0, 0x06, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x07, 0xC0, 0x3C, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x08,
  0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x18, 0x07, 0x80, 0x04, 0x07,
  0x80, 0x03, 0x03, 0x80, 0x00, 0xC3, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x0D,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x2C,
  0x30, 0x00, 0x58, 0x30, 0x01, 0x30, 0x70, 0x04, 0xC0, 0x70, 0x39, 0x80,
  0x7F, 0xC3, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x08, 0x03, 0x80, 0x08, 0x0F, 0x00, 0x18, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x30,
  0x18, 0x30, 0x06, 0x03, 0x04, 0x00, 0x80, 0x21, 0x80, 0x10, 0x06, 0x30,
  0x06, 0x00, 0xC6, 0x00, 0xC0, 0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00,
  0x62, 0x00, 0x40, 0x0C, 0xC0, 0x08, 0x01, 0x98, 0x03, 0x00, 0x33, 0x00,
  0x60, 0x06, 0x60, 0x0C, 0x00, 0xCC, 0x01, 0x80, 0x19, 0x00, 0x20, 0x03,
  0x60, 0x04, 0x00, 0x4C, 0x01, 0x80, 0x19, 0x80, 0x30, 0x03, 0x30, 0x06,
  0x00, 0x64, 0x00, 0xC0, 0x0C, 0x80, 0x38, 0x03, 0x10, 0x07, 0x00, 0x66,
  0x00, 0xC0, 0x18, 0x40, 0x2C, 0x07, 0x0C, 0x0D, 0x80, 0xC1, 0xC3, 0x18,
  0x70, 0x1F, 0xC3, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x01, 0xF0, 0x1F, 0xC0, 0x1C, 0xC0, 0xC3, 0x81, 0xC1, 0x86, 0x07, 0x1C,
  0x06, 0x30, 0x0D, 0xC0, 0x08, 0x80, 0x34, 0x00, 0x36, 0x00, 0xC0, 0x00,
  0xD0, 0x03, 0x00, 0x03, 0x40, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x0F, 0x00, 0x03, 0x00, 0x2C, 0x00, 0x0C, 0x01, 0xB0, 0x01, 0x30, 0x04,
  0x40, 0x1C, 0xC0, 0x31, 0x81, 0xC3, 0x81, 0x86, 0x1E, 0x07, 0x0C, 0x0C,
  0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x20, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x70, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x0B, 0x01, 0xC0, 0x06, 0xC0,
  0x38, 0x03, 0x30, 0x0F, 0x03, 0x98, 0x01, 0xFF, 0xC6, 0x00, 0x1F, 0xC1,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x30, 0xE0, 0x3E, 0x0C, 0x30,
  0x01, 0xE2, 0x18, 0x00, 0x0F, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x30, 0x10, 0x00, 0x38, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x04, 0x07, 0x00, 0x01,
  0x03, 0x80, 0x00, 0x41, 0xE0, 0x00, 0x18, 0xFF, 0x80, 0x06, 0x30, 0xFF,
  0x01, 0x8C, 0x03, 0xFE, 0x23, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x61, 0xFE, 0x00, 0x0C, 0x70, 0xE0, 0x03, 0x0C, 0x0C, 0x00,
  0x63, 0x00, 0xC0, 0x18, 0xC0, 0x0C, 0x03, 0x18, 0x01, 0xC0, 0xC6, 0x00,
  0x1C, 0x30, 0xC0, 0x01, 0xFC, 0x10, 0x00, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 37, 32, 12, -37 },
  { 43, 12, 14, 32, 13, -39 },
  { 64, 31, 37, 32, 1, -37 },
  { 208, 28, 49, 32, 2, -43 },
  { 380, 35, 39, 32, -1, -38 },
  { 551, 30, 39, 32, 1, -38 },
  { 698, 4, 14, 32, 17, -39 },
  { 705, 17, 47, 32, 12, -40 },
  { 805, 18, 47, 32, 3, -40 },
  { 911, 27, 26, 32, 3, -29 },
  { 999, 25, 26, 32, 4, -29 },
  { 1081, 8, 14, 32, 8, -5 },
  { 1095, 15, 2, 32, 9, -17 },
  { 1099, 4, 4, 32, 12, -4 },
  { 1101, 29, 47, 32, 2, -40 },
  { 1272, 25, 39, 32, 4, -38 },
  { 1394, 24, 37, 32, 3, -37 },
  { 1505, 26, 38, 32, 2, -38 },
  { 1629, 26, 39, 32, 2, -38 },
  { 1756, 28, 37, 32, 1, -37 },
  { 1886, 27, 38, 32, 3, -37 },
  { 2015, 23, 38, 32, 4, -37 },
  { 2125, 25, 37, 32, 6, -37 },
  { 2241, 27, 39, 32, 3, -38 },
  { 2373, 24, 38, 32, 5, -38 },
  { 2487, 8, 28, 32, 12, -28 },
  { 2515, 12, 37, 32, 8, -28 },
  { 2571, 25, 29, 32, 5, -31 },
  { 2662, 27, 12, 32, 3, -22 },
  { 2703, 25, 29, 32, 3, -31 },
  { 2794, 21, 38, 32, 8, -38 },
  { 2894, 25, 44, 32, 4, -38 },
  { 3032, 27, 37, 32, 0, -37 },
  { 3157, 26, 37, 32, 3, -37 },
  { 3278, 25, 39, 32, 5, -38 },
  { 3400, 26, 37, 32, 3, -37 },
  { 3521, 28, 37, 32, 3, -37 },
  { 3651, 28, 37, 32, 3, -37 },
  { 3781, 26, 39, 32, 4, -38 },
  { 3908, 28, 37, 32, 3, -37 },
  { 4038, 29, 37, 32, 2, -37 },
  { 4173, 25, 38, 32, 4, -37 },
  { 4292, 30, 37, 32, 3, -37 },
  { 4431, 21, 37, 32, 5, -37 },
  { 4529, 29, 37, 32, 2, -37 },
  { 4664, 28, 37, 32, 3, -37 },
  { 4794, 25, 39, 32, 4, -38 },
  { 4916, 27, 37, 32, 3, -37 },
  { 5041, 25, 47, 32, 4, -38 },
  { 5188, 27, 37, 32, 3, -37 },
  { 5313, 28, 39, 32, 2, -38 },
  { 5450, 28, 37, 32, 6, -37 },
  { 5580, 27, 38, 32, 4, -37 },
  { 5709, 26, 37, 32, 7, -37 },
  { 5830, 29, 37, 32, 4, -37 },
  { 5965, 33, 37, 32, 0, -37 },
  { 6118, 29, 37, 32, 5, -37 },
  { 6253, 32, 37, 32, 0, -37 },
  { 6401, 21, 47, 32, 10, -40 },
  { 6525, 13, 47, 32, 10, -40 },
  { 6602, 21, 47, 32, 1, -40 },
  { 6726, 25, 20, 32, 4, -37 },
  { 6789, 25, 2, 32, 0, 6 },
  { 6796, 6, 9, 32, 13, -40 },
  { 6803, 24, 29, 32, 4, -28 },
  { 6890, 24, 40, 32, 4, -39 },
  { 7010, 23, 29, 32, 4, -28 },
  { 7094, 26, 40, 32, 4, -39 },
  { 7224, 23, 29, 32, 4, -28 },
  { 7308, 34, 50, 32, -1, -39 },
  { 7521, 26, 39, 32, 2, -28 },
  { 7648, 23, 39, 32, 4, -39 },
  { 7761, 22, 41, 32, 5, -40 },
  { 7874, 23, 51, 32, 5, -40 },
  { 8021, 26, 40, 32, 4, -39 },
  { 8151, 21, 40, 32, 6, -39 },
  { 8256, 28, 28, 32, 2, -28 },
  { 8354, 23, 28, 32, 4, -28 },
  { 8435, 24, 29, 32, 4, -28 },
  { 8522, 26, 39, 32, 2, -28 },
  { 8649, 24, 39, 32, 4, -28 },
  { 8766, 26, 27, 32, 6, -27 },
  { 8854, 25, 29, 32, 3, -28 },
  { 8945, 26, 38, 32, 4, -37 },
  { 9069, 23, 28, 32, 5, -27 },
  { 9150, 24, 28, 32, 4, -28 },
  { 9234, 27, 29, 32, 3, -28 },
  { 9332, 30, 29, 32, 1, -28 },
  { 9441, 26, 38, 32, 2, -27 },
  { 9565, 26, 29, 32, 3, -28 },
  { 9660, 24, 47, 32, 6, -40 },
  { 9801, 9, 47, 32, 12, -40 },
  { 9854, 24, 47, 32, 2, -40 },
  { 9995, 27, 10, 32, 3, -21 },
};

const GFXfont IBMPlexMono_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC53PT7B_H_
