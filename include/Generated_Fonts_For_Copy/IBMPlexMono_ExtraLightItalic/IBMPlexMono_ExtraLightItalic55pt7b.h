#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC55PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3C,
  0x00, 0x30, 0x33, 0x03, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xF8, 0x63, 0xC0, 0x0F, 0x03, 0x07, 0x00,
  0xE0, 0x18, 0x0C, 0x06, 0x00, 0x80, 0x30, 0x60, 0x04, 0x01, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x3E,
  0x20, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x20, 0x70, 0x00, 0x01, 0x01, 0xC0,
  0x00, 0x08, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0x61, 0x00, 0x30, 0x07, 0x18, 0x01, 0x80, 0x30,
  0x60, 0x08, 0x03, 0x83, 0x80, 0x40, 0x38, 0x0F, 0x06, 0x03, 0x80, 0x1E,
  0x30, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x60, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x30, 0x00, 0x60, 0x03, 0x03, 0x00, 0x03, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x01, 0x81, 0x80, 0x00, 0x60, 0x1C, 0x18, 0x00, 0x03, 0x83,
  0xC1, 0x80, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x30, 0x3F, 0xE0, 0x00, 0x01, 0x83, 0x83, 0x80, 0x00,
  0x18, 0x30, 0x06, 0x00, 0x01, 0x83, 0x00, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x80, 0x00, 0xC0, 0x80, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x80, 0x06, 0x00, 0x60, 0x04, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x30,
  0x00, 0x38, 0x38, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x3F, 0xCF, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x03,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1C,
  0x01, 0x60, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x58, 0x07, 0x80, 0x01, 0x98,
  0x1B, 0x00, 0x02, 0x30, 0x63, 0x00, 0x0C, 0x30, 0xC7, 0x00, 0x30, 0x73,
  0x07, 0x81, 0xC0, 0x6C, 0x07, 0xFF, 0x00, 0x78, 0x03, 0xF8, 0x00, 0xE0,
  0x33, 0x36, 0x66, 0x66, 0x6C, 0xCC, 0xCC, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x30, 0x01, 0x70, 0x02, 0x00, 0xFB, 0xE0, 0x60, 0x7E, 0x07,
  0xC6, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x38, 0x03, 0x30, 0x0F,
  0x00, 0x6E, 0x01, 0xE0, 0x0D, 0x80, 0x1C, 0x01, 0xB0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80, 0x03, 0x80, 0xC0, 0x07, 0x80,
  0xC0, 0x07, 0x80, 0x60, 0x07, 0x80, 0x30, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x38,
  0x00, 0x06, 0x03, 0x80, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x07, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x41, 0xFE, 0x00, 0x0C, 0x7F, 0xF8, 0x00, 0xDE, 0x03,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x1F, 0xC0, 0x18, 0xFF, 0xF0, 0x1B, 0xC0, 0x7C, 0x37, 0x00, 0x1C,
  0x3C, 0x00, 0x06, 0x68, 0x00, 0x07, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0x60, 0x00, 0x2C,
  0x38, 0x00, 0xCC, 0x3E, 0x03, 0x98, 0x0F, 0xFF, 0x18, 0x03, 0xF8, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x87, 0xC3,
  0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x3E, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0xF0, 0x0F, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x76, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x08, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x07, 0xC3, 0x18, 0x07, 0xFC,
  0xC6, 0x03, 0x83, 0x21, 0x81, 0xC0, 0x38, 0x40, 0x60, 0x0E, 0x30, 0x30,
  0x01, 0x8C, 0x0C, 0x00, 0x63, 0x06, 0x00, 0x18, 0xC1, 0x80, 0x04, 0x60,
  0x60, 0x03, 0x18, 0x18, 0x00, 0xC6, 0x06, 0x00, 0x31, 0x83, 0x00, 0x0C,
  0x60, 0xC0, 0x03, 0x18, 0x30, 0x00, 0x84, 0x0C, 0x00, 0x63, 0x03, 0x00,
  0x18, 0xC0, 0xC0, 0x0E, 0x30, 0x10, 0x03, 0x8C, 0x06, 0x01, 0x63, 0x01,
  0xC0, 0x90, 0xC0, 0x3F, 0xEC, 0x30, 0x07, 0xE3, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0C, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x60, 0x00, 0x3E, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x81, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x06, 0x00, 0x1E, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xCC, 0x00,
  0xFF, 0xF3, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x06, 0x00, 0x02, 0xC1, 0xC0, 0x01, 0xB0, 0x38, 0x00, 0xD8, 0x07,
  0x80, 0xE6, 0x00, 0xFF, 0xF1, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x7C,
  0x00, 0x00, 0x31, 0xD8, 0x00, 0x00, 0xC7, 0x18, 0x00, 0x01, 0x98, 0x30,
  0x00, 0x03, 0x60, 0x30, 0x00, 0x07, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x06,
  0xC0, 0x4C, 0x00, 0x1D, 0x81, 0x98, 0x00, 0x32, 0x03, 0x30, 0x00, 0xCC,
  0x06, 0x20, 0x01, 0x98, 0x0C, 0x60, 0x06, 0x30, 0x18, 0xC0, 0x18, 0x60,
  0x21, 0x80, 0x30, 0xC0, 0xC1, 0x80, 0xC1, 0x01, 0x83, 0x01, 0x86, 0x03,
  0x06, 0x06, 0x0C, 0x06, 0x04, 0x18, 0x18, 0x0C, 0x0C, 0x30, 0x30, 0x10,
  0x18, 0xC0, 0x60, 0x60, 0x31, 0x80, 0x80, 0xC0, 0x26, 0x03, 0x01, 0x80,
  0x78, 0x06, 0x03, 0x00, 0xF0, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x08, 0x01,
  0x00, 0x30, 0x30, 0x02, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x1E, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x04, 0x05, 0x80, 0x00, 0x60,
  0x66, 0x00, 0x03, 0x03, 0x30, 0x00, 0x18, 0x19, 0x80, 0x00, 0xC0, 0xC6,
  0x00, 0x06, 0x06, 0x30, 0x00, 0x20, 0x21, 0x80, 0x03, 0x03, 0x06, 0x00,
  0x18, 0x18, 0x30, 0x00, 0xC0, 0xC1, 0x80, 0x06, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x30, 0x01, 0x01, 0x01, 0x80, 0x18, 0x18, 0x06, 0x00, 0xC0, 0xC0,
  0x30, 0x06, 0x06, 0x01, 0x80, 0x30, 0x30, 0x0E, 0x01, 0x81, 0x80, 0x30,
  0x08, 0x08, 0x01, 0x80, 0xC0, 0xC0, 0x0C, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x30, 0x01, 0x81, 0x81, 0x80, 0x0C, 0x0C, 0x0C, 0x00, 0x30, 0x40, 0x40,
  0x01, 0x86, 0x06, 0x00, 0x0C, 0x30, 0x30, 0x00, 0x31, 0x81, 0x80, 0x01,
  0x8C, 0x0C, 0x00, 0x0C, 0x60, 0x60, 0x00, 0x32, 0x02, 0x00, 0x01, 0xB0,
  0x30, 0x00, 0x0D, 0x81, 0x80, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x18, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x70,
  0x0C, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x38, 0x18, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x03, 0xC0, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x02, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x02, 0x0C, 0x01, 0xC0, 0x18, 0x30, 0x07, 0x00, 0x60, 0xC0, 0x3C, 0x01,
  0x83, 0x00, 0xF0, 0x0C, 0x0C, 0x06, 0x40, 0x30, 0x20, 0x19, 0x00, 0xC0,
  0x80, 0xC6, 0x03, 0x06, 0x03, 0x18, 0x18, 0x18, 0x08, 0x60, 0x60, 0x60,
  0x61, 0x81, 0x81, 0x81, 0x86, 0x04, 0x06, 0x0C, 0x18, 0x30, 0x18, 0x30,
  0x60, 0xC0, 0x61, 0x80, 0x83, 0x01, 0x86, 0x02, 0x08, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x10,
  0x04, 0x60, 0x0C, 0xC0, 0x13, 0x00, 0x33, 0x00, 0xCC, 0x00, 0xCC, 0x03,
  0x60, 0x01, 0x60, 0x0D, 0x80, 0x05, 0x80, 0x3C, 0x00, 0x16, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x0C, 0x30,
  0x61, 0x83, 0x04, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0xC0, 0xF0, 0x1C,
  0x60, 0xE0, 0x03, 0x20, 0xE0, 0x00, 0xB0, 0xE0, 0x00, 0x38, 0x60, 0x00,
  0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x58, 0x30, 0x00, 0x4C,
  0x0E, 0x00, 0xE4, 0x07, 0x81, 0xE3, 0xF0, 0xFF, 0xC1, 0xF8, 0x1F, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x7E, 0x00, 0x31, 0xFF, 0xC0, 0x31, 0xC0, 0x70,
  0x19, 0x80, 0x1C, 0x0D, 0x80, 0x07, 0x06, 0x80, 0x01, 0x83, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x40, 0x01, 0xC3,
  0x30, 0x01, 0xC1, 0x8E, 0x03, 0xC0, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0x80,
  0x1C, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x0F, 0x03,
  0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0xF8, 0x18, 0x03, 0xFF, 0xC3, 0x00, 0xF0, 0x1C, 0x60, 0x38, 0x00,
  0xC8, 0x0E, 0x00, 0x0B, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x05, 0x80,
  0xE0, 0x01, 0xB0, 0x0E, 0x00, 0x66, 0x00, 0xE0, 0x38, 0x80, 0x0F, 0xFE,
  0x30, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xF0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x3C, 0x60, 0x01, 0xF0, 0x60,
  0x1F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x0F, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x38, 0x04, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x0C, 0x03, 0xC0,
  0x71, 0x80, 0xE0, 0x03, 0x30, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xB0,
  0x18, 0x00, 0x36, 0x01, 0xC0, 0x0C, 0xC0, 0x3C, 0x07, 0x18, 0x01, 0xFF,
  0xC6, 0x00, 0x0F, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x07,
  0xE0, 0x06, 0x1F, 0xF8, 0x06, 0x38, 0x3C, 0x06, 0x60, 0x0E, 0x0E, 0x80,
  0x06, 0x0D, 0x00, 0x06, 0x0D, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x00, 0x60, 0x03, 0x00, 0x80, 0x1C,
  0x03, 0x00, 0x70, 0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x78, 0x00,
  0x21, 0xC0, 0x00, 0xC7, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x40, 0x03, 0x00, 0x60, 0x03, 0x00, 0xF0,
  0x03, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x02, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x07, 0xF0, 0x00, 0x61, 0xFF, 0xC0, 0x0C, 0x78, 0x1E, 0x00, 0xCE, 0x00,
  0x60, 0x0C, 0x80, 0x07, 0x00, 0xD0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00,
  0x30, 0x01, 0xE0, 0x03, 0x00, 0xF0, 0x00, 0x30, 0x7C, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x66, 0x01, 0x80, 0x0F, 0x60, 0x0C, 0x01, 0xC6, 0x00, 0xC0, 0x38, 0x60,
  0x06, 0x07, 0x06, 0x00, 0x70, 0xE0, 0xC0, 0x03, 0x1C, 0x0C, 0x00, 0x3B,
  0x80, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x40, 0xC0, 0x07, 0x06, 0x00, 0xE0, 0x30,
  0x0E, 0x03, 0x00, 0xE0, 0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x38, 0x00,
  0x33, 0x80, 0x01, 0x38, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x27, 0xF8, 0x7F, 0x83, 0x70, 0xE7, 0x0E, 0x1A, 0x03,
  0x20, 0x30, 0xE0, 0x1A, 0x01, 0x87, 0x00, 0x60, 0x0C, 0x30, 0x07, 0x00,
  0x61, 0x80, 0x30, 0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6,
  0x00, 0x60, 0x04, 0x30, 0x03, 0x00, 0x21, 0x80, 0x10, 0x03, 0x08, 0x01,
  0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x30, 0x03, 0x00,
  0x21, 0x80, 0x18, 0x03, 0x0C, 0x00, 0x80, 0x18, 0x40, 0x0C, 0x00, 0xC6,
  0x00, 0x60, 0x06, 0x30, 0x03, 0x00, 0x31, 0x80, 0x18, 0x01, 0x0C, 0x00,
  0xC0, 0x18, 0x60, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x30, 0x03, 0x00,
  0x31, 0x80, 0x18, 0x01, 0x8C, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x07, 0xE0,
  0x06, 0x1F, 0xF8, 0x06, 0x38, 0x3C, 0x06, 0x60, 0x0E, 0x06, 0x80, 0x06,
  0x0D, 0x00, 0x06, 0x0D, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x0E, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x18, 0x18, 0x00, 0x18, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x31, 0xFF, 0xC0, 0x04, 0x70, 0x1C, 0x01, 0x98, 0x01, 0xC0,
  0x36, 0x00, 0x1C, 0x06, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x40,
  0x01, 0xC0, 0xCC, 0x00, 0x70, 0x18, 0xE0, 0x3C, 0x03, 0x0F, 0xFF, 0x00,
  0x60, 0x7F, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0xC0, 0xF0, 0x1C, 0x60, 0xE0,
  0x03, 0x30, 0xE0, 0x00, 0xB0, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x58, 0x38, 0x00, 0x6C, 0x0E, 0x00,
  0x66, 0x03, 0x80, 0xE3, 0x00, 0xFF, 0xE3, 0x00, 0x1F, 0xC1, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFC, 0x00, 0xCE, 0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1E, 0x01, 0xF0, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0, 0x7C, 0x01, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0E,
  0x00, 0x60, 0x07, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x78, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x37, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0xB0, 0x60, 0x01, 0xB0, 0x60, 0x01, 0x60, 0x70, 0x06,
  0x60, 0x38, 0x1C, 0x60, 0x1F, 0xF8, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x80, 0x03,
  0x80, 0x40, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x01,
  0xC0, 0x0C, 0x03, 0xC0, 0x06, 0x07, 0x80, 0x02, 0x0F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x30, 0x18,
  0x60, 0x04, 0x03, 0x0C, 0x01, 0x80, 0x21, 0x80, 0x30, 0x06, 0x20, 0x06,
  0x00, 0xCC, 0x00, 0xC0, 0x19, 0x80, 0x18, 0x03, 0x30, 0x02, 0x00, 0x66,
  0x00, 0xC0, 0x0C, 0xC0, 0x18, 0x01, 0x90, 0x03, 0x00, 0x36, 0x00, 0x60,
  0x06, 0xC0, 0x0C, 0x00, 0xD8, 0x01, 0x00, 0x1B, 0x00, 0x60, 0x03, 0x60,
  0x0C, 0x00, 0x68, 0x01, 0x80, 0x0B, 0x00, 0x30, 0x03, 0x60, 0x06, 0x00,
  0x6C, 0x01, 0x80, 0x0D, 0x80, 0x30, 0x03, 0xB0, 0x06, 0x00, 0x64, 0x00,
  0xC0, 0x0C, 0x80, 0x28, 0x03, 0x18, 0x0D, 0x00, 0xE3, 0x03, 0x30, 0x38,
  0x70, 0xE7, 0x0E, 0x07, 0xF8, 0x7F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0x98, 0x18, 0x70, 0x3C,
  0x30, 0x60, 0x31, 0xE0, 0x31, 0x80, 0x67, 0x00, 0x66, 0x00, 0xC8, 0x00,
  0xCC, 0x01, 0x80, 0x00, 0x90, 0x03, 0x00, 0x01, 0x60, 0x06, 0x00, 0x02,
  0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x50, 0x00, 0x18, 0x00, 0xA0, 0x00,
  0x30, 0x03, 0x60, 0x00, 0x60, 0x04, 0xC0, 0x04, 0xC0, 0x19, 0x80, 0x39,
  0x80, 0x61, 0x81, 0xC1, 0x81, 0xC3, 0x0E, 0x03, 0x87, 0x07, 0x78, 0x03,
  0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x2C, 0x07, 0x00,
  0x05, 0x80, 0x60, 0x01, 0x70, 0x0E, 0x00, 0x4C, 0x00, 0xF0, 0x71, 0x80,
  0x0F, 0xFC, 0x30, 0x00, 0x7E, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x0C, 0x1C, 0x0F, 0xC1, 0x86, 0x00, 0x1E,
  0x30, 0xC0, 0x00, 0xFC, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x1C, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x10, 0x7C, 0x00, 0x03, 0x1F,
  0xF8, 0x00, 0x63, 0x07, 0xF8, 0x0C, 0x60, 0x0F, 0xF9, 0x8C, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x30,
  0xFF, 0x00, 0x03, 0x1C, 0x38, 0x00, 0x61, 0x81, 0xC0, 0x06, 0x30, 0x0E,
  0x00, 0xC2, 0x00, 0x70, 0x0C, 0x60, 0x03, 0x01, 0x84, 0x00, 0x1C, 0x70,
  0xC0, 0x00, 0xFE, 0x0C, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 10, 38, 33, 12, -38 },
  { 49, 12, 14, 33, 14, -41 },
  { 70, 33, 38, 33, 1, -38 },
  { 227, 29, 52, 33, 2, -45 },
  { 416, 37, 40, 33, -1, -39 },
  { 601, 31, 40, 33, 1, -39 },
  { 756, 4, 14, 33, 18, -41 },
  { 763, 17, 50, 33, 13, -42 },
  { 870, 17, 50, 33, 4, -42 },
  { 977, 28, 27, 33, 3, -30 },
  { 1072, 26, 28, 33, 4, -31 },
  { 1163, 9, 14, 33, 8, -5 },
  { 1179, 15, 2, 33, 9, -18 },
  { 1183, 5, 4, 33, 12, -4 },
  { 1186, 30, 50, 33, 2, -42 },
  { 1374, 27, 40, 33, 4, -39 },
  { 1509, 25, 38, 33, 3, -38 },
  { 1628, 28, 39, 33, 2, -39 },
  { 1765, 27, 40, 33, 2, -39 },
  { 1900, 29, 38, 33, 1, -38 },
  { 2038, 28, 39, 33, 3, -38 },
  { 2175, 24, 39, 33, 4, -38 },
  { 2292, 26, 38, 33, 6, -38 },
  { 2416, 28, 40, 33, 3, -39 },
  { 2556, 24, 39, 33, 6, -39 },
  { 2673, 9, 29, 33, 12, -29 },
  { 2706, 13, 38, 33, 8, -29 },
  { 2768, 26, 30, 33, 5, -32 },
  { 2866, 28, 12, 33, 3, -23 },
  { 2908, 26, 30, 33, 3, -32 },
  { 3006, 22, 39, 33, 8, -39 },
  { 3114, 26, 45, 33, 4, -39 },
  { 3261, 28, 38, 33, 0, -38 },
  { 3394, 27, 38, 33, 3, -38 },
  { 3523, 26, 40, 33, 5, -39 },
  { 3653, 28, 38, 33, 3, -38 },
  { 3786, 29, 38, 33, 3, -38 },
  { 3924, 30, 38, 33, 3, -38 },
  { 4067, 26, 40, 33, 5, -39 },
  { 4197, 29, 38, 33, 3, -38 },
  { 4335, 29, 38, 33, 3, -38 },
  { 4473, 26, 39, 33, 4, -38 },
  { 4600, 31, 38, 33, 3, -38 },
  { 4748, 22, 38, 33, 5, -38 },
  { 4853, 31, 38, 33, 2, -38 },
  { 5001, 29, 38, 33, 3, -38 },
  { 5139, 27, 40, 33, 4, -39 },
  { 5274, 29, 38, 33, 3, -38 },
  { 5412, 27, 49, 33, 4, -39 },
  { 5578, 29, 38, 33, 3, -38 },
  { 5716, 29, 40, 33, 2, -39 },
  { 5861, 29, 38, 33, 6, -38 },
  { 5999, 27, 39, 33, 5, -38 },
  { 6131, 27, 38, 33, 7, -38 },
  { 6260, 30, 38, 33, 4, -38 },
  { 6403, 34, 38, 33, 0, -38 },
  { 6565, 31, 38, 33, 5, -38 },
  { 6713, 33, 38, 33, 0, -38 },
  { 6870, 22, 50, 33, 10, -42 },
  { 7008, 13, 50, 33, 11, -42 },
  { 7090, 22, 50, 33, 1, -42 },
  { 7228, 26, 21, 33, 4, -38 },
  { 7297, 26, 2, 33, 0, 6 },
  { 7304, 6, 9, 33, 13, -42 },
  { 7311, 25, 30, 33, 4, -29 },
  { 7405, 25, 42, 33, 4, -41 },
  { 7537, 24, 30, 33, 4, -29 },
  { 7627, 27, 42, 33, 4, -41 },
  { 7769, 24, 30, 33, 4, -29 },
  { 7859, 35, 53, 33, -1, -41 },
  { 8091, 27, 41, 33, 2, -29 },
  { 8230, 24, 41, 33, 4, -41 },
  { 8353, 23, 42, 33, 5, -41 },
  { 8474, 24, 53, 33, 5, -41 },
  { 8633, 28, 42, 33, 4, -41 },
  { 8780, 21, 42, 33, 7, -41 },
  { 8891, 29, 29, 33, 2, -29 },
  { 8997, 24, 29, 33, 4, -29 },
  { 9084, 25, 30, 33, 4, -29 },
  { 9178, 27, 40, 33, 2, -29 },
  { 9313, 25, 40, 33, 4, -29 },
  { 9438, 27, 28, 33, 6, -28 },
  { 9533, 26, 30, 33, 3, -29 },
  { 9631, 27, 39, 33, 4, -38 },
  { 9763, 24, 29, 33, 5, -28 },
  { 9850, 25, 29, 33, 4, -29 },
  { 9941, 27, 30, 33, 4, -29 },
  { 10043, 31, 30, 33, 1, -29 },
  { 10160, 27, 40, 33, 2, -28 },
  { 10295, 27, 30, 33, 3, -29 },
  { 10397, 24, 50, 33, 7, -42 },
  { 10547, 10, 50, 33, 12, -42 },
  { 10610, 24, 50, 33, 3, -42 },
  { 10760, 28, 10, 33, 3, -22 },
};

const GFXfont IBMPlexMono_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC55PT7B_H_
