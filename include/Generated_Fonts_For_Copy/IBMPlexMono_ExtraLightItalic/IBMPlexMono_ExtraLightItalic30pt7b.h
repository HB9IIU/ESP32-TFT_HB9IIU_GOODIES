#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC30PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x21, 0x08, 0x00,
  0x01, 0x8C, 0x00, 0x22, 0x45, 0x0A, 0x34, 0x48, 0x91, 0x62, 0x00, 0x42,
  0x00, 0x41, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04,
  0x20, 0x7C, 0x1F, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00,
  0x42, 0x07, 0xC1, 0xF0, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x40,
  0x04, 0x20, 0x04, 0x10, 0x02, 0x10, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x03, 0xF8, 0x0E, 0x46, 0x18, 0x43, 0x10, 0x41, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x80, 0x10, 0x80, 0x18, 0x80, 0x0E, 0x80, 0x01, 0xE0, 0x00,
  0x98, 0x01, 0x0C, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x81,
  0x04, 0x42, 0x08, 0x32, 0x30, 0x0F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0xC0, 0x10, 0x42, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x10, 0x81, 0x01, 0x10, 0x10, 0x21, 0x01, 0x02, 0x20, 0x08, 0x44, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0x10, 0x80, 0x22, 0x08,
  0x04, 0x40, 0x40, 0x44, 0x04, 0x08, 0x40, 0xC1, 0x04, 0x08, 0x20, 0x40,
  0x82, 0x02, 0x10, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x82, 0x00, 0x40,
  0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x30,
  0x02, 0x08, 0x00, 0x84, 0x01, 0xDE, 0x00, 0x86, 0x00, 0x40, 0x80, 0x10,
  0x10, 0x0C, 0x04, 0x02, 0x00, 0x80, 0x80, 0x50, 0x70, 0x14, 0x24, 0x04,
  0x91, 0x82, 0x3C, 0x1F, 0x06, 0x00, 0x5E, 0xAA, 0x00, 0xC0, 0x40, 0x60,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x10, 0x20, 0x5C, 0x4F, 0x07, 0xE0, 0x03, 0x00, 0x0B, 0x00, 0x22,
  0x00, 0xC2, 0x03, 0x04, 0x04, 0x04, 0x10, 0x08, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x33, 0x26, 0x4C, 0x88, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x58,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x86, 0x0F, 0x0E, 0x14, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x18, 0x80, 0x21, 0x00, 0x81,
  0x86, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x02, 0x80, 0x32, 0x01, 0x88, 0x0C,
  0x20, 0x41, 0x82, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0xFF, 0xFC, 0x01, 0xF0, 0x0C, 0x18, 0x30, 0x18, 0xC0,
  0x11, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x0C,
  0x18, 0x20, 0x18, 0x80, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x09, 0x00, 0x11, 0x00, 0x41, 0x83, 0x01, 0xFC,
  0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x50, 0x01, 0x20, 0x04, 0x40, 0x11,
  0x00, 0x62, 0x01, 0x84, 0x02, 0x08, 0x08, 0x10, 0x20, 0x20, 0x80, 0x82,
  0x01, 0x08, 0x02, 0x30, 0x04, 0x7F, 0xFF, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x27, 0xC0, 0x70, 0x60,
  0x80, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x19, 0x00, 0x23, 0x00, 0xC3, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x27,
  0xE0, 0xE0, 0xC6, 0x01, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x38, 0x00, 0xA0,
  0x02, 0x80, 0x09, 0x00, 0x44, 0x03, 0x0C, 0x18, 0x1F, 0x80, 0x7F, 0xFE,
  0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x01, 0x08, 0x02, 0x20, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x11, 0x80, 0x32, 0x00, 0x24,
  0x00, 0xC8, 0x01, 0x08, 0x06, 0x18, 0x10, 0x0F, 0xC0, 0x60, 0xC3, 0x00,
  0x44, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x13,
  0x00, 0x43, 0x03, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0xC1, 0x88, 0x06, 0x80,
  0x14, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xD0, 0x0C,
  0xC1, 0xA1, 0xF2, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC2,
  0x18, 0x43, 0x08, 0x20, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x08, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x10, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x0F, 0xC1, 0x06, 0x20, 0x14, 0x01, 0xC0, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x06, 0x01, 0x80, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x18, 0x60, 0x80, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x0F, 0x48, 0x45,
  0x22, 0x0D, 0x18, 0x14, 0x40, 0xD1, 0x02, 0x44, 0x09, 0x10, 0x28, 0x40,
  0xA1, 0x06, 0x84, 0x2A, 0x0F, 0x48, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x03, 0x00, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80,
  0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x80, 0x41, 0xFF, 0x84, 0x01, 0x08, 0x02, 0x20, 0x02,
  0x40, 0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x20, 0x1F, 0xF0, 0x40, 0x21,
  0x00, 0x44, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x08,
  0x80, 0x47, 0xFE, 0x10, 0x0C, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02,
  0xC0, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x0C, 0xFF, 0xC0, 0x03, 0xE0, 0x30,
  0x41, 0x00, 0x8C, 0x03, 0x20, 0x05, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x12, 0x00, 0x84, 0x06, 0x18, 0x30, 0x1F, 0x00, 0x1F, 0xE0,
  0x20, 0x30, 0x40, 0x20, 0x80, 0x21, 0x00, 0x46, 0x00, 0xC8, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x0C, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x03, 0x20, 0x04, 0x40, 0x09, 0x80, 0x22, 0x00, 0x84, 0x06, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xFC,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x88, 0x03, 0x20, 0x05, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x7E, 0x82,
  0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0xCC, 0x05, 0x18,
  0x28, 0x3F, 0x20, 0x10, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x12, 0x00,
  0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0xC0, 0x09, 0xFF, 0xF2,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00,
  0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x00, 0x0F, 0xFF, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x22, 0x00, 0x8C, 0x04, 0x18, 0x20,
  0x3F, 0x00, 0x10, 0x01, 0x88, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x00, 0x83, 0x00, 0x43, 0x00, 0x23, 0x00, 0x13, 0x80, 0x0B,
  0x40, 0x0B, 0x30, 0x07, 0x08, 0x03, 0x06, 0x01, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x40, 0x18, 0x20, 0x04, 0x10, 0x03, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x08, 0x01, 0x8C, 0x01, 0xC5,
  0x00, 0xC2, 0x80, 0xA1, 0x40, 0x50, 0x90, 0x48, 0x48, 0x64, 0x44, 0x26,
  0x22, 0x22, 0x10, 0x91, 0x08, 0x50, 0x84, 0x38, 0x42, 0x18, 0x22, 0x08,
  0x31, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10,
  0x01, 0x88, 0x00, 0x80, 0x18, 0x02, 0x30, 0x04, 0x60, 0x09, 0x20, 0x12,
  0x40, 0x24, 0x80, 0x88, 0x81, 0x11, 0x02, 0x22, 0x04, 0x82, 0x09, 0x04,
  0x12, 0x08, 0x44, 0x08, 0x88, 0x11, 0x10, 0x22, 0x40, 0x64, 0x80, 0x49,
  0x00, 0xA2, 0x01, 0xC4, 0x01, 0x88, 0x03, 0x00, 0x03, 0xF0, 0x0C, 0x30,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x0F, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02,
  0x40, 0x04, 0x80, 0x18, 0x80, 0x21, 0x00, 0x81, 0x86, 0x01, 0xF0, 0x00,
  0x1F, 0xF8, 0x20, 0x18, 0x40, 0x18, 0x80, 0x11, 0x00, 0x26, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x06, 0x40, 0x08, 0x80, 0x63, 0xFF, 0x84, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x0F, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x18,
  0x80, 0x21, 0x00, 0x81, 0x86, 0x01, 0xF0, 0x00, 0x40, 0x00, 0xC2, 0x00,
  0x8E, 0x00, 0xB0, 0x01, 0x80, 0x1F, 0xF8, 0x20, 0x18, 0x40, 0x18, 0x80,
  0x11, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x06, 0x40, 0x08,
  0x80, 0x63, 0xFF, 0x84, 0x10, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x41, 0x80, 0x42, 0x00, 0x84, 0x00, 0x88, 0x01, 0x00, 0x03, 0xF8, 0x0C,
  0x06, 0x18, 0x03, 0x10, 0x02, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x40, 0x08, 0x30,
  0x30, 0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x58, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x0B, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x0C, 0x80, 0x22, 0x00, 0x88, 0x04, 0x30, 0x30, 0x3F, 0x00, 0x80, 0x07,
  0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20,
  0x10, 0x40, 0x60, 0x80, 0x81, 0x03, 0x03, 0x04, 0x02, 0x18, 0x04, 0x20,
  0x08, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x22, 0x00, 0x11, 0x06, 0x08, 0x83, 0x04, 0x42, 0x84, 0x21, 0x42, 0x10,
  0xA1, 0x08, 0x90, 0x84, 0x48, 0x82, 0x42, 0x41, 0x21, 0x20, 0xA0, 0x90,
  0x50, 0x50, 0x58, 0x28, 0x28, 0x14, 0x14, 0x0A, 0x0C, 0x06, 0x00, 0x08,
  0x00, 0x60, 0x80, 0x10, 0x10, 0x06, 0x01, 0x01, 0x80, 0x20, 0x20, 0x02,
  0x08, 0x00, 0x42, 0x00, 0x04, 0xC0, 0x00, 0xB0, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x50, 0x00, 0x12, 0x00, 0x06, 0x20, 0x01, 0x84, 0x00, 0x20,
  0x40, 0x08, 0x08, 0x02, 0x00, 0x80, 0x80, 0x10, 0x30, 0x01, 0x0C, 0x00,
  0x20, 0x80, 0x01, 0x40, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x10,
  0x10, 0x10, 0x20, 0x18, 0x40, 0x08, 0xC0, 0x0D, 0x80, 0x05, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFE, 0x00,
  0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x01, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x04, 0x08,
  0x0F, 0xF0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0xFE, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x11,
  0x00, 0x41, 0x01, 0x82, 0x02, 0x02, 0x08, 0x04, 0x20, 0x08, 0xC0, 0x09,
  0x00, 0x14, 0x00, 0x10, 0xFF, 0xFC, 0x89, 0x12, 0x07, 0xC4, 0x60, 0xA3,
  0x01, 0x98, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x0C, 0x40, 0x71, 0x82, 0x81, 0xF3, 0xC0, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0xF8, 0x34, 0x18, 0xA0, 0x23, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x16,
  0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x24, 0x01, 0x98, 0x0C, 0x90, 0x62,
  0x3E, 0x00, 0x07, 0xE0, 0x41, 0x8C, 0x06, 0x40, 0x14, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x10, 0x06, 0x80, 0x26, 0x02, 0x18,
  0x60, 0x7C, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x03, 0xE2, 0x18, 0x28, 0x60, 0x31, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x01, 0xC2, 0x02, 0x86, 0x0A, 0x03, 0xE4, 0x00, 0x03, 0xE0, 0x60,
  0xC4, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x09, 0x03, 0x9F, 0xC0, 0x80, 0x04,
  0x00, 0x10, 0x02, 0x80, 0x26, 0x02, 0x18, 0x20, 0x3E, 0x00, 0x00, 0x1F,
  0xE0, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE2, 0x18, 0x24, 0x60, 0x31, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x22, 0x00, 0xC2, 0x02, 0x86, 0x0A, 0x03, 0xE4, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x42, 0x00, 0x83, 0x06, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x3C, 0x16, 0x10,
  0xC0, 0x4C, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x60, 0x10, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x10, 0x82,
  0x08, 0xC1, 0x10, 0x16, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x42, 0x04, 0x08, 0x20, 0x31, 0x00, 0xC8,
  0x03, 0x40, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0xF8, 0x36, 0x18, 0x50, 0x10, 0xC0,
  0x21, 0x00, 0x42, 0x01, 0x84, 0x06, 0x18, 0x30, 0x23, 0x80, 0x42, 0x00,
  0x84, 0x05, 0x04, 0x12, 0x0C, 0xCC, 0x0B, 0x10, 0x0C, 0x00, 0xFE, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x24, 0x18, 0x84,
  0x13, 0x02, 0x80, 0x60, 0x00, 0x17, 0x9E, 0x28, 0xA3, 0x30, 0xC1, 0x20,
  0x41, 0x20, 0x81, 0x20, 0x81, 0x20, 0x82, 0x40, 0x82, 0x40, 0x82, 0x41,
  0x02, 0x41, 0x02, 0x41, 0x02, 0xC1, 0x04, 0x81, 0x04, 0x83, 0x04, 0x11,
  0xE0, 0xB0, 0x86, 0x02, 0x60, 0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0B, 0x00, 0x80,
  0x07, 0xE0, 0x60, 0xC3, 0x00, 0x88, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00,
  0x70, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x04, 0x40, 0x30, 0xC1,
  0x81, 0xF8, 0x00, 0x09, 0xF0, 0x14, 0x18, 0x50, 0x10, 0xC0, 0x11, 0x00,
  0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x63, 0x01, 0x89, 0x06, 0x11, 0xF0, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC4, 0x60, 0x93, 0x01,
  0x98, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x0C, 0x40, 0x51, 0x82, 0xC1, 0xF2, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0xFC, 0xFC, 0x1C, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07,
  0xE0, 0x60, 0x63, 0x00, 0x48, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x01,
  0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x80, 0x11, 0x80, 0x81,
  0xFC, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x04, 0x08, 0x18, 0x10, 0xC0,
  0x26, 0x00, 0x58, 0x00, 0xC0, 0x00, 0x20, 0x1A, 0x00, 0x90, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x19,
  0x00, 0xC8, 0x0C, 0x20, 0xA0, 0xF9, 0x00, 0xF8, 0x0C, 0x20, 0x10, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0xC4, 0x02, 0x10, 0x08, 0x40,
  0x41, 0x03, 0x08, 0x18, 0x20, 0xC0, 0x8E, 0x03, 0xC0, 0x00, 0x20, 0x84,
  0x41, 0x04, 0x82, 0x0A, 0x04, 0x14, 0x10, 0x28, 0x20, 0x50, 0x40, 0xA0,
  0x81, 0x81, 0x03, 0x02, 0x0A, 0x08, 0x14, 0x30, 0x28, 0x60, 0x91, 0x22,
  0x1C, 0x38, 0x00, 0x06, 0x0E, 0x0C, 0x98, 0x98, 0x48, 0x50, 0x28, 0x10,
  0x0C, 0x10, 0x04, 0x08, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x40, 0x80,
  0x20, 0xC0, 0x10, 0x50, 0x48, 0x48, 0x74, 0x66, 0xC1, 0xC1, 0x80, 0x08,
  0x06, 0x30, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x61, 0x00, 0xC2, 0x03, 0x02,
  0x0A, 0x03, 0xE4, 0x00, 0x08, 0x00, 0x30, 0x00, 0x42, 0x01, 0x83, 0x06,
  0x03, 0xF0, 0x00, 0x1F, 0x84, 0x83, 0xD2, 0x01, 0xD0, 0x06, 0x40, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x43, 0x01, 0x10, 0x04,
  0xF0, 0x0A, 0x7E, 0x28, 0x1F, 0x80, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x60, 0x7C, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x0F, 0xE0, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88,
  0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x20, 0x07, 0xF0, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x01, 0xF0, 0x38, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x1C, 0x02, 0x4C, 0x09, 0x0C,
  0x14, 0x08, 0x28, 0x08, 0x90, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 21, 18, 7, -21 },
  { 15, 7, 8, 18, 7, -22 },
  { 22, 17, 21, 18, 1, -21 },
  { 67, 16, 27, 18, 1, -24 },
  { 121, 20, 21, 18, -1, -21 },
  { 174, 18, 21, 18, 0, -21 },
  { 222, 2, 8, 18, 10, -22 },
  { 224, 10, 27, 18, 7, -23 },
  { 258, 10, 27, 18, 2, -23 },
  { 292, 15, 15, 18, 2, -16 },
  { 321, 14, 15, 18, 2, -17 },
  { 348, 4, 8, 18, 5, -3 },
  { 352, 8, 1, 18, 5, -10 },
  { 353, 2, 2, 18, 7, -2 },
  { 354, 16, 27, 18, 1, -23 },
  { 408, 15, 21, 18, 2, -21 },
  { 448, 14, 21, 18, 1, -21 },
  { 485, 15, 21, 18, 1, -21 },
  { 525, 15, 21, 18, 1, -21 },
  { 565, 15, 21, 18, 1, -21 },
  { 605, 15, 21, 18, 2, -21 },
  { 645, 14, 21, 18, 2, -21 },
  { 682, 15, 21, 18, 3, -21 },
  { 722, 15, 21, 18, 2, -21 },
  { 762, 13, 21, 18, 3, -21 },
  { 797, 4, 15, 18, 7, -15 },
  { 805, 6, 20, 18, 5, -15 },
  { 820, 14, 16, 18, 3, -17 },
  { 848, 15, 6, 18, 2, -12 },
  { 860, 15, 16, 18, 1, -17 },
  { 890, 12, 21, 18, 4, -21 },
  { 922, 14, 24, 18, 2, -21 },
  { 964, 15, 21, 18, 0, -21 },
  { 1004, 14, 21, 18, 2, -21 },
  { 1041, 14, 21, 18, 3, -21 },
  { 1078, 15, 21, 18, 2, -21 },
  { 1118, 16, 21, 18, 2, -21 },
  { 1160, 16, 21, 18, 2, -21 },
  { 1202, 14, 21, 18, 3, -21 },
  { 1239, 15, 21, 18, 2, -21 },
  { 1279, 16, 21, 18, 1, -21 },
  { 1321, 14, 21, 18, 2, -21 },
  { 1358, 17, 21, 18, 2, -21 },
  { 1403, 12, 21, 18, 3, -21 },
  { 1435, 17, 21, 18, 1, -21 },
  { 1480, 15, 21, 18, 2, -21 },
  { 1520, 15, 21, 18, 2, -21 },
  { 1560, 15, 21, 18, 2, -21 },
  { 1600, 15, 26, 18, 2, -21 },
  { 1649, 15, 21, 18, 2, -21 },
  { 1689, 16, 21, 18, 1, -21 },
  { 1731, 16, 21, 18, 3, -21 },
  { 1773, 14, 21, 18, 3, -21 },
  { 1810, 15, 21, 18, 4, -21 },
  { 1850, 17, 21, 18, 2, -21 },
  { 1895, 19, 21, 18, 0, -21 },
  { 1945, 16, 21, 18, 3, -21 },
  { 1987, 18, 21, 18, 0, -21 },
  { 2035, 12, 27, 18, 6, -23 },
  { 2076, 7, 27, 18, 6, -23 },
  { 2100, 12, 27, 18, 1, -23 },
  { 2141, 15, 12, 18, 2, -21 },
  { 2164, 14, 1, 18, 0, 3 },
  { 2166, 3, 5, 18, 7, -23 },
  { 2168, 14, 15, 18, 2, -15 },
  { 2195, 14, 22, 18, 2, -22 },
  { 2234, 13, 15, 18, 2, -15 },
  { 2259, 15, 22, 18, 2, -22 },
  { 2301, 13, 15, 18, 2, -15 },
  { 2326, 19, 28, 18, 0, -22 },
  { 2393, 15, 21, 18, 1, -15 },
  { 2433, 13, 22, 18, 2, -22 },
  { 2469, 12, 22, 18, 3, -22 },
  { 2502, 13, 28, 18, 3, -22 },
  { 2548, 15, 22, 18, 2, -22 },
  { 2590, 11, 22, 18, 4, -22 },
  { 2621, 16, 15, 18, 1, -15 },
  { 2651, 13, 15, 18, 2, -15 },
  { 2676, 14, 15, 18, 2, -15 },
  { 2703, 15, 21, 18, 1, -15 },
  { 2743, 14, 21, 18, 2, -15 },
  { 2780, 14, 15, 18, 4, -15 },
  { 2807, 14, 15, 18, 2, -15 },
  { 2834, 15, 21, 18, 2, -21 },
  { 2874, 13, 15, 18, 3, -15 },
  { 2899, 14, 15, 18, 2, -15 },
  { 2926, 15, 15, 18, 2, -15 },
  { 2955, 17, 15, 18, 1, -15 },
  { 2987, 15, 21, 18, 1, -15 },
  { 3027, 14, 15, 18, 2, -15 },
  { 3054, 13, 27, 18, 4, -23 },
  { 3098, 5, 27, 18, 7, -23 },
  { 3115, 14, 27, 18, 1, -23 },
  { 3163, 15, 6, 18, 2, -12 },
};

const GFXfont IBMPlexMono_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC30PT7B_H_
