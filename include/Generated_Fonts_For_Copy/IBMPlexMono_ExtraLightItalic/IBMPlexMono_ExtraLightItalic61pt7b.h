#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC61PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0xFC, 0x1F, 0x01, 0xE0,
  0x00, 0x18, 0x1C, 0x60, 0x63, 0x81, 0x8E, 0x06, 0x30, 0x18, 0xC0, 0x63,
  0x03, 0x8C, 0x0C, 0x70, 0x31, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x71,
  0x81, 0x8E, 0x06, 0x30, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x18, 0xF8, 0x00, 0x78, 0x0C, 0x0F,
  0x00, 0x38, 0x06, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x38, 0x01, 0x00,
  0x38, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xE0,
  0x40, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x06, 0x3E, 0x00, 0x00,
  0x02, 0x07, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x1C,
  0x10, 0x00, 0x80, 0x0C, 0x1C, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x00, 0x78, 0x18, 0x0E, 0x00, 0x1F, 0x8C, 0x3E,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x20, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x30, 0x30,
  0x00, 0x00, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xC0, 0x00,
  0x03, 0x03, 0x80, 0x70, 0x00, 0x01, 0x81, 0x80, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x00, 0x38, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x30, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0xE0, 0x00, 0x07, 0xCC, 0xF0, 0x00, 0x03, 0x81, 0xF8, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0B, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0B, 0x00, 0x6C, 0x00, 0x01,
  0x30, 0x1D, 0xC0, 0x00, 0x67, 0x03, 0x18, 0x00, 0x18, 0x60, 0xC3, 0x80,
  0x03, 0x0E, 0x38, 0x38, 0x01, 0xC0, 0xC6, 0x03, 0xC0, 0xF0, 0x0D, 0x80,
  0x3F, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x33, 0x33, 0x76,
  0x66, 0x66, 0xEC, 0xCC, 0xCC, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x17, 0x80, 0x18, 0x00, 0xF7, 0xE0, 0x30,
  0x1F, 0xC1, 0xF8, 0x61, 0xFC, 0x00, 0x7E, 0xDF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x03,
  0x80, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xFF,
  0xFE, 0x78, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07,
  0x70, 0x03, 0x80, 0x1D, 0x80, 0x1E, 0x00, 0x66, 0x00, 0x78, 0x01, 0x98,
  0x01, 0xE0, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x81, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x3C, 0x01, 0x80, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x03, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xC0, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x0F, 0xF0,
  0x00, 0x18, 0xFF, 0xF8, 0x00, 0x33, 0x80, 0x78, 0x00, 0x6C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x83, 0xFC, 0x00, 0x61, 0xFF, 0xF0, 0x1C, 0xF0,
  0x1F, 0x03, 0x30, 0x00, 0x70, 0x6C, 0x00, 0x07, 0x1B, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xC0, 0x78,
  0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0x67, 0x00, 0x00,
  0x7C, 0x70, 0x00, 0x1B, 0x07, 0x00, 0x0E, 0x60, 0x78, 0x07, 0x98, 0x07,
  0xFF, 0xC3, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x07,
  0x80, 0x78, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31,
  0x80, 0x0F, 0xC3, 0x18, 0x03, 0xFE, 0x31, 0x80, 0x70, 0x33, 0x30, 0x0E,
  0x00, 0xE3, 0x01, 0xC0, 0x0E, 0x30, 0x18, 0x00, 0x63, 0x03, 0x80, 0x06,
  0x30, 0x30, 0x00, 0x66, 0x03, 0x00, 0x06, 0x60, 0x30, 0x00, 0xC6, 0x06,
  0x00, 0x0C, 0x60, 0x60, 0x00, 0xC6, 0x06, 0x00, 0x0C, 0x60, 0x60, 0x00,
  0xCC, 0x06, 0x00, 0x0C, 0xC0, 0x60, 0x01, 0x8C, 0x06, 0x00, 0x18, 0xC0,
  0x60, 0x01, 0x8C, 0x06, 0x00, 0x38, 0xC0, 0x60, 0x05, 0x8C, 0x06, 0x00,
  0x58, 0xC0, 0x30, 0x0B, 0x0C, 0x03, 0xC3, 0x30, 0xC0, 0x1F, 0xE3, 0x0C,
  0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0xE6, 0x00, 0x1F, 0xFF, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x02, 0xC0, 0xC0, 0x00, 0x3E, 0x07, 0x00, 0x03, 0x60, 0x1C, 0x00, 0x33,
  0x00, 0x78, 0x07, 0x18, 0x01, 0xFF, 0xF0, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x00, 0x1C, 0x3B, 0x00, 0x00, 0x06,
  0x1C, 0xE0, 0x00, 0x01, 0x8E, 0x18, 0x00, 0x00, 0x67, 0x07, 0x00, 0x00,
  0x1B, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xEC, 0x00, 0x03, 0x60, 0x33, 0x00, 0x01, 0xD8,
  0x0C, 0xC0, 0x00, 0x66, 0x03, 0x18, 0x00, 0x39, 0x80, 0xC6, 0x00, 0x1C,
  0xE0, 0x31, 0x80, 0x06, 0x30, 0x1C, 0x60, 0x03, 0x8C, 0x06, 0x0C, 0x00,
  0xC3, 0x01, 0x83, 0x00, 0x70, 0xC0, 0x60, 0xC0, 0x38, 0x30, 0x18, 0x30,
  0x0C, 0x1C, 0x06, 0x06, 0x07, 0x06, 0x03, 0x81, 0x81, 0x81, 0x80, 0xC0,
  0x60, 0xC0, 0x60, 0x30, 0x08, 0x30, 0x18, 0x0C, 0x03, 0x18, 0x06, 0x03,
  0x00, 0xCE, 0x01, 0x80, 0xC0, 0x33, 0x00, 0xC0, 0x30, 0x07, 0x80, 0x30,
  0x18, 0x01, 0xE0, 0x0C, 0x06, 0x00, 0x70, 0x03, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x60, 0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x01, 0xE0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x03, 0x01, 0xF0, 0x00,
  0x03, 0x03, 0xB0, 0x00, 0x07, 0x03, 0x30, 0x00, 0x06, 0x03, 0x38, 0x00,
  0x06, 0x03, 0x18, 0x00, 0x06, 0x03, 0x18, 0x00, 0x06, 0x03, 0x1C, 0x00,
  0x06, 0x07, 0x0C, 0x00, 0x0E, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x0C, 0x00,
  0x0C, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x06, 0x00,
  0x0C, 0x0E, 0x07, 0x00, 0x0C, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x00,
  0x18, 0x0C, 0x03, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0x18, 0x1C, 0x01, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0xE0, 0x30, 0x18, 0x00, 0x60, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x38, 0x00, 0x70, 0x30, 0x30, 0x00, 0x30, 0x60, 0x30, 0x00, 0x30,
  0x60, 0x30, 0x00, 0x38, 0x60, 0x30, 0x00, 0x18, 0x60, 0x30, 0x00, 0x18,
  0x60, 0x70, 0x00, 0x18, 0x60, 0x60, 0x00, 0x0C, 0xE0, 0x60, 0x00, 0x0C,
  0xC0, 0x60, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x06, 0xC0, 0x60, 0x00, 0x06,
  0xC0, 0x60, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x18, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x04,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x1C, 0x00,
  0xC0, 0xC0, 0x0E, 0x00, 0x60, 0xE0, 0x0F, 0x00, 0x30, 0x60, 0x07, 0x80,
  0x18, 0x30, 0x06, 0xC0, 0x18, 0x18, 0x03, 0x30, 0x0C, 0x0C, 0x03, 0x18,
  0x06, 0x06, 0x01, 0x8C, 0x03, 0x03, 0x01, 0xC6, 0x03, 0x01, 0x80, 0xC3,
  0x01, 0x80, 0xC0, 0x61, 0x80, 0xC0, 0x60, 0x60, 0xC0, 0xE0, 0x30, 0x30,
  0x60, 0x60, 0x18, 0x30, 0x30, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x06, 0x18,
  0x06, 0x1C, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x31,
  0x80, 0x18, 0xC0, 0x19, 0x80, 0x0C, 0x60, 0x0C, 0xC0, 0x03, 0x60, 0x06,
  0xC0, 0x01, 0xB0, 0x03, 0x60, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x86, 0x1C, 0x30, 0xC1,
  0x86, 0x0C, 0x10, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0x01, 0xF0,
  0x1C, 0x30, 0x3C, 0x00, 0x67, 0x07, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x16,
  0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xB0, 0x60, 0x00,
  0x1B, 0x07, 0x00, 0x01, 0x60, 0x38, 0x00, 0x26, 0x01, 0xC0, 0x0E, 0x60,
  0x1F, 0x03, 0xC7, 0xF0, 0x7F, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x7F, 0x80,
  0x06, 0x1F, 0xFE, 0x00, 0xE3, 0x80, 0xF0, 0x0C, 0x60, 0x03, 0x80, 0xCC,
  0x00, 0x1C, 0x0D, 0x80, 0x00, 0xC0, 0xD0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x61, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x70, 0xD0, 0x00, 0x0E, 0x0C, 0x80,
  0x01, 0xC0, 0xCC, 0x00, 0x38, 0x0C, 0x78, 0x0F, 0x00, 0xC1, 0xFF, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0xC0, 0x07, 0xFF, 0x83,
  0x00, 0x7C, 0x07, 0x0C, 0x03, 0xC0, 0x06, 0x30, 0x1C, 0x00, 0x0D, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xB0, 0x18, 0x00, 0x02, 0xC0, 0x70, 0x00,
  0x17, 0x00, 0xE0, 0x00, 0xD8, 0x01, 0xC0, 0x0E, 0x60, 0x03, 0xC0, 0xF1,
  0x80, 0x07, 0xFF, 0x06, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E,
  0x60, 0x00, 0x07, 0x18, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0xC3, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0xF0,
  0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0xC0,
  0x3E, 0x03, 0x86, 0x03, 0xC0, 0x06, 0x30, 0x38, 0x00, 0x0B, 0x83, 0x80,
  0x00, 0x78, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x81, 0x80,
  0x00, 0x2C, 0x0E, 0x00, 0x02, 0x60, 0x38, 0x00, 0x37, 0x00, 0xE0, 0x07,
  0x30, 0x07, 0xC0, 0xF1, 0x80, 0x0F, 0xFE, 0x0C, 0x00, 0x1F, 0xC0, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x60, 0xFF,
  0xE0, 0x18, 0xF0, 0x3C, 0x06, 0x60, 0x03, 0x01, 0xB0, 0x00, 0xE0, 0xE8,
  0x00, 0x18, 0x34, 0x00, 0x07, 0x0D, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x03,
  0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x10,
  0x00, 0x60, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0x80,
  0x07, 0x00, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0F, 0xE0, 0x00, 0x60,
  0xFF, 0xE0, 0x03, 0x8F, 0x01, 0xC0, 0x0C, 0x70, 0x03, 0x80, 0x33, 0x00,
  0x07, 0x00, 0xD8, 0x00, 0x0C, 0x03, 0x40, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0xC0, 0x78, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x80, 0x03, 0x00,
  0xF0, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x03, 0x60, 0x0C, 0x00,
  0x19, 0x80, 0x38, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x38, 0x01, 0xC0, 0x30,
  0xC0, 0x03, 0x03, 0x83, 0x00, 0x06, 0x1C, 0x0C, 0x00, 0x18, 0xE0, 0x30,
  0x00, 0x37, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x02, 0x03, 0x00, 0x07, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x38, 0x03, 0x00, 0xF0, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x06,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x03, 0x1F, 0xE0,
  0xFF, 0x01, 0x98, 0x38, 0xC1, 0xC0, 0xD8, 0x0C, 0xC0, 0x60, 0x68, 0x06,
  0xC0, 0x30, 0x38, 0x03, 0x40, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00,
  0xE0, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x00, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x00, 0x30, 0xC0,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x18,
  0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x30, 0x01, 0x86,
  0x00, 0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x00, 0x30, 0x60, 0x03, 0x00, 0x18, 0x60, 0x01, 0x80, 0x0C,
  0x30, 0x01, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x1C, 0x00,
  0x61, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x01, 0x83, 0xFF, 0x80,
  0x63, 0xC0, 0xF0, 0x19, 0x80, 0x0C, 0x06, 0xC0, 0x03, 0x83, 0xA0, 0x00,
  0x60, 0xD0, 0x00, 0x1C, 0x34, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x78, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x38, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x87, 0xFF,
  0x80, 0x07, 0x1C, 0x07, 0x80, 0x0C, 0x60, 0x03, 0x80, 0x19, 0x80, 0x03,
  0x80, 0x36, 0x00, 0x03, 0x00, 0x68, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x78, 0x00,
  0x03, 0x80, 0xD0, 0x00, 0x0E, 0x01, 0x90, 0x00, 0x38, 0x03, 0x30, 0x00,
  0xE0, 0x06, 0x3C, 0x07, 0x80, 0x0C, 0x1F, 0xFE, 0x00, 0x38, 0x0F, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0x83, 0x01, 0xF0, 0x1C, 0x30, 0x3C, 0x00, 0x63, 0x07, 0x00,
  0x03, 0x70, 0xE0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xB0, 0x60, 0x00, 0x0B, 0x07, 0x00, 0x01, 0x70, 0x38, 0x00,
  0x36, 0x01, 0xC0, 0x0E, 0x60, 0x0F, 0x03, 0xC6, 0x00, 0x7F, 0xF0, 0x60,
  0x01, 0xFC, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xC0, 0x0C, 0x78, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x38, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x1F, 0x80, 0x3C, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x30,
  0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x78,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x01, 0x9E, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x1E, 0x0E,
  0x00, 0x0D, 0x81, 0x80, 0x02, 0x60, 0x70, 0x03, 0x18, 0x0F, 0x03, 0x86,
  0x01, 0xFF, 0xC3, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFC,
  0x00, 0x0E, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x07, 0x80,
  0x01, 0x83, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x30, 0x01, 0x80, 0x20, 0x60,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x01, 0x86, 0x00,
  0x30, 0x03, 0x0C, 0x00, 0x60, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x03,
  0x00, 0x08, 0x60, 0x06, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x33, 0x00, 0x18,
  0x00, 0x66, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x60, 0x03, 0x18, 0x01, 0x80,
  0x06, 0x30, 0x03, 0x00, 0x0C, 0xC0, 0x06, 0x00, 0x19, 0x80, 0x0C, 0x00,
  0x33, 0x00, 0x18, 0x00, 0x66, 0x00, 0x30, 0x01, 0xCC, 0x00, 0xC0, 0x03,
  0x18, 0x01, 0x80, 0x06, 0x60, 0x03, 0x00, 0x0C, 0xC0, 0x06, 0x00, 0x31,
  0x80, 0x1C, 0x00, 0x63, 0x00, 0x38, 0x01, 0xC6, 0x00, 0xF0, 0x03, 0x0C,
  0x01, 0x60, 0x0C, 0x1C, 0x06, 0x60, 0x38, 0x1C, 0x38, 0xE1, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x1F, 0xF0, 0x03, 0xCE, 0x07, 0x0F, 0x01, 0xE0, 0xC1, 0xC0,
  0x60, 0xF0, 0x18, 0x70, 0x0C, 0x78, 0x01, 0x8C, 0x01, 0xCC, 0x00, 0x33,
  0x00, 0x38, 0x00, 0x06, 0x60, 0x03, 0x00, 0x00, 0xC8, 0x00, 0x60, 0x00,
  0x0B, 0x00, 0x0C, 0x00, 0x01, 0x40, 0x03, 0x00, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x1A, 0x00, 0x00, 0xC0, 0x02, 0x40, 0x00, 0x18, 0x00, 0xCC, 0x00,
  0x23, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x06, 0x30, 0x07, 0x0E, 0x01, 0x87,
  0x03, 0xC0, 0xC0, 0x70, 0x61, 0xE0, 0x1C, 0x1C, 0x0E, 0x70, 0x01, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xF0, 0x0C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x16, 0x00, 0x60, 0x00,
  0x98, 0x01, 0xC0, 0x0C, 0x60, 0x03, 0xC0, 0xE1, 0x80, 0x07, 0xFF, 0x0E,
  0x00, 0x07, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x04, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x0C, 0x07, 0xFF, 0xE0,
  0x30, 0x38, 0x0F, 0xF0, 0xC1, 0x80, 0x07, 0xF3, 0x06, 0x00, 0x03, 0xFC,
  0x30, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x01, 0xC0, 0x20, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x80,
  0x03, 0x80, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x04, 0x1F, 0xE0,
  0x00, 0x18, 0x67, 0xF8, 0x00, 0x61, 0x81, 0xFF, 0x01, 0x8E, 0x00, 0x3F,
  0xE6, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x0C, 0x3C, 0x78, 0x00, 0x18,
  0x60, 0x38, 0x00, 0x61, 0x80, 0x30, 0x00, 0xC6, 0x00, 0x30, 0x03, 0x0C,
  0x00, 0x70, 0x0E, 0x30, 0x00, 0x70, 0x38, 0x60, 0x00, 0x70, 0xE0, 0x80,
  0x00, 0x7F, 0x83, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 11, 43, 37, 13, -43 },
  { 61, 14, 16, 37, 15, -45 },
  { 89, 36, 43, 37, 1, -43 },
  { 283, 33, 56, 37, 2, -49 },
  { 514, 41, 44, 37, -1, -43 },
  { 740, 35, 44, 37, 1, -43 },
  { 933, 4, 16, 37, 20, -45 },
  { 941, 20, 54, 37, 14, -46 },
  { 1076, 20, 54, 37, 4, -46 },
  { 1211, 31, 30, 37, 4, -33 },
  { 1328, 29, 30, 37, 4, -34 },
  { 1437, 10, 16, 37, 9, -6 },
  { 1457, 17, 2, 37, 10, -20 },
  { 1462, 6, 5, 37, 13, -5 },
  { 1466, 33, 54, 37, 2, -46 },
  { 1689, 30, 44, 37, 4, -43 },
  { 1854, 28, 43, 37, 3, -43 },
  { 2005, 31, 43, 37, 2, -43 },
  { 2172, 29, 44, 37, 3, -43 },
  { 2332, 31, 43, 37, 2, -43 },
  { 2499, 31, 44, 37, 3, -43 },
  { 2670, 27, 44, 37, 5, -43 },
  { 2819, 29, 43, 37, 7, -43 },
  { 2975, 31, 44, 37, 3, -43 },
  { 3146, 27, 43, 37, 6, -43 },
  { 3292, 10, 32, 37, 13, -32 },
  { 3332, 14, 42, 37, 9, -32 },
  { 3406, 30, 33, 37, 5, -35 },
  { 3530, 31, 13, 37, 3, -25 },
  { 3581, 29, 33, 37, 3, -35 },
  { 3701, 24, 43, 37, 9, -43 },
  { 3830, 28, 50, 37, 5, -43 },
  { 4005, 31, 43, 37, 0, -43 },
  { 4172, 30, 43, 37, 3, -43 },
  { 4334, 29, 44, 37, 5, -43 },
  { 4494, 30, 43, 37, 4, -43 },
  { 4656, 32, 43, 37, 4, -43 },
  { 4828, 32, 43, 37, 4, -43 },
  { 5000, 29, 44, 37, 5, -43 },
  { 5160, 32, 43, 37, 3, -43 },
  { 5332, 33, 43, 37, 3, -43 },
  { 5510, 29, 44, 37, 4, -43 },
  { 5670, 34, 43, 37, 4, -43 },
  { 5853, 24, 43, 37, 6, -43 },
  { 5982, 34, 43, 37, 2, -43 },
  { 6165, 32, 43, 37, 3, -43 },
  { 6337, 30, 44, 37, 4, -43 },
  { 6502, 31, 43, 37, 4, -43 },
  { 6669, 30, 54, 37, 4, -43 },
  { 6872, 31, 43, 37, 4, -43 },
  { 7039, 33, 44, 37, 2, -43 },
  { 7221, 33, 43, 37, 6, -43 },
  { 7399, 30, 44, 37, 5, -43 },
  { 7564, 31, 43, 37, 7, -43 },
  { 7731, 33, 43, 37, 5, -43 },
  { 7909, 38, 43, 37, 0, -43 },
  { 8114, 34, 43, 37, 6, -43 },
  { 8297, 37, 43, 37, 0, -43 },
  { 8496, 24, 54, 37, 12, -46 },
  { 8658, 14, 54, 37, 12, -46 },
  { 8753, 24, 54, 37, 2, -46 },
  { 8915, 29, 23, 37, 5, -43 },
  { 8999, 29, 2, 37, 0, 7 },
  { 9007, 6, 10, 37, 15, -46 },
  { 9015, 28, 33, 37, 4, -32 },
  { 9131, 28, 46, 37, 5, -45 },
  { 9292, 26, 33, 37, 5, -32 },
  { 9400, 30, 46, 37, 4, -45 },
  { 9573, 26, 33, 37, 5, -32 },
  { 9681, 39, 58, 37, -1, -45 },
  { 9964, 29, 45, 37, 3, -32 },
  { 10128, 26, 45, 37, 5, -45 },
  { 10275, 26, 46, 37, 5, -45 },
  { 10425, 26, 58, 37, 6, -45 },
  { 10614, 30, 46, 37, 5, -45 },
  { 10787, 24, 46, 37, 7, -45 },
  { 10925, 33, 32, 37, 2, -32 },
  { 11057, 26, 32, 37, 5, -32 },
  { 11161, 27, 33, 37, 5, -32 },
  { 11273, 31, 44, 37, 2, -32 },
  { 11444, 28, 44, 37, 4, -32 },
  { 11598, 29, 31, 37, 7, -31 },
  { 11711, 28, 33, 37, 4, -32 },
  { 11827, 29, 44, 37, 5, -43 },
  { 11987, 26, 32, 37, 6, -31 },
  { 12091, 28, 32, 37, 5, -32 },
  { 12203, 31, 33, 37, 4, -32 },
  { 12331, 35, 33, 37, 1, -32 },
  { 12476, 30, 44, 37, 2, -31 },
  { 12641, 30, 33, 37, 3, -32 },
  { 12765, 28, 54, 37, 7, -46 },
  { 12954, 11, 54, 37, 13, -46 },
  { 13029, 27, 54, 37, 3, -46 },
  { 13212, 31, 11, 37, 3, -24 },
};

const GFXfont IBMPlexMono_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC61PT7B_H_
