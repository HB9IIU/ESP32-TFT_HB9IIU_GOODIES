#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC60PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0E, 0x00, 0x38,
  0x19, 0xC0, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x19, 0xC0, 0xCC, 0x06,
  0x60, 0x33, 0x03, 0x98, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x18, 0xF8, 0x00, 0xF0, 0x18,
  0x1C, 0x01, 0xC0, 0x10, 0x0E, 0x01, 0x80, 0x30, 0x07, 0x03, 0x80, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x00, 0xF8, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x01, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x40, 0x06, 0x00,
  0x70, 0xE0, 0x06, 0x00, 0x60, 0x70, 0x06, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x1E, 0x04, 0x07, 0x80, 0x0F, 0xC4, 0x1F, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0x00, 0x78, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x38, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x80, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x70, 0x00, 0x00,
  0xFF, 0xC0, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06,
  0x03, 0xFF, 0x00, 0x00, 0x0C, 0x07, 0x07, 0x80, 0x00, 0x0C, 0x0C, 0x01,
  0x80, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x1E, 0x00, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xFC,
  0x1C, 0x00, 0x00, 0xFB, 0x9E, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x07, 0x00, 0x2C, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x58, 0x07, 0xC0, 0x00, 0x37, 0x01, 0xB0, 0x00,
  0x08, 0xC0, 0xC6, 0x00, 0x06, 0x38, 0x31, 0xC0, 0x03, 0x06, 0x18, 0x38,
  0x01, 0xC0, 0xCE, 0x07, 0x81, 0xE0, 0x3B, 0x00, 0xFF, 0xE0, 0x07, 0x80,
  0x0F, 0xE0, 0x00, 0xC0, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x73, 0x18, 0xC6,
  0x73, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0xC0, 0x0F, 0x7E, 0x03, 0x03, 0xF8, 0x3F, 0x0C, 0x7E,
  0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x36, 0x00, 0x78, 0x01, 0xB0, 0x03, 0xC0, 0x0D, 0x80, 0x1E,
  0x00, 0xEC, 0x00, 0xE0, 0x07, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0F, 0x18, 0x00,
  0x01, 0xE1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x88, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x70, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x3F, 0xC0, 0x00, 0x63, 0xFF, 0xE0, 0x01, 0xBC, 0x03, 0xC0,
  0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x81, 0xFE, 0x00, 0x31, 0xFF, 0xF0, 0x0C, 0x78, 0x0F, 0x81, 0xB8,
  0x00, 0x78, 0x74, 0x00, 0x03, 0x0D, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06,
  0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x07, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x58, 0x70, 0x00, 0x1B, 0x0F, 0x00, 0x0E, 0xC0, 0xF8,
  0x07, 0x18, 0x07, 0xFF, 0xC6, 0x00, 0x3F, 0xC0, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xC0, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0x80,
  0x78, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x30, 0x03, 0xF0,
  0xC6, 0x00, 0xFF, 0x98, 0x80, 0x38, 0x1B, 0x30, 0x0C, 0x01, 0x66, 0x03,
  0x00, 0x1C, 0xC0, 0x60, 0x03, 0x98, 0x18, 0x00, 0x66, 0x03, 0x00, 0x0C,
  0xC0, 0x60, 0x01, 0x98, 0x18, 0x00, 0x33, 0x03, 0x00, 0x06, 0x60, 0x60,
  0x00, 0xDC, 0x0C, 0x00, 0x33, 0x01, 0x80, 0x06, 0x60, 0x60, 0x00, 0xCC,
  0x0C, 0x00, 0x19, 0x81, 0x80, 0x03, 0x30, 0x30, 0x00, 0xE6, 0x06, 0x00,
  0x18, 0xC0, 0x60, 0x07, 0x18, 0x0C, 0x01, 0x62, 0x01, 0xC0, 0x6C, 0x40,
  0x1C, 0x39, 0x88, 0x01, 0xFE, 0x31, 0x80, 0x0F, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x78, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xE0, 0x03, 0xE0, 0x06, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0xFF, 0xE6, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x2C, 0x07, 0x00, 0x03, 0x60,
  0x1C, 0x00, 0x73, 0x00, 0x78, 0x0F, 0x18, 0x01, 0xFF, 0xE1, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x01, 0x87, 0x30, 0x00,
  0x00, 0xC7, 0x1C, 0x00, 0x00, 0x67, 0x06, 0x00, 0x00, 0x37, 0x03, 0x80,
  0x00, 0x1F, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x36, 0x03, 0xE0,
  0x00, 0x0D, 0x80, 0xCC, 0x00, 0x06, 0x60, 0x33, 0x00, 0x01, 0xB0, 0x0C,
  0xC0, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x63, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x71, 0x80, 0x0C, 0x30, 0x18, 0x60, 0x07, 0x0C, 0x06, 0x0C, 0x01, 0x86,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18,
  0x18, 0x0E, 0x06, 0x0E, 0x06, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC0, 0x61,
  0x80, 0xC0, 0x30, 0x08, 0x60, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x00,
  0xD8, 0x03, 0x01, 0xC0, 0x36, 0x00, 0xC0, 0x60, 0x07, 0x00, 0x30, 0x18,
  0x01, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x06, 0x03, 0x60, 0x00, 0x06, 0x03, 0x70, 0x00, 0x06,
  0x03, 0x30, 0x00, 0x06, 0x03, 0x30, 0x00, 0x06, 0x03, 0x38, 0x00, 0x0E,
  0x03, 0x18, 0x00, 0x0C, 0x07, 0x18, 0x00, 0x0C, 0x06, 0x1C, 0x00, 0x0C,
  0x06, 0x0C, 0x00, 0x0C, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x0E, 0x00, 0x1C,
  0x06, 0x06, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x07, 0x00, 0x18,
  0x0C, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x80, 0x38,
  0x0C, 0x01, 0x80, 0x30, 0x1C, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0x30,
  0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0x70,
  0x18, 0x00, 0x60, 0x60, 0x38, 0x00, 0x60, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x30, 0x00, 0x30, 0x60, 0x30, 0x00, 0x30, 0x60, 0x30, 0x00, 0x30, 0xE0,
  0x30, 0x00, 0x38, 0xC0, 0x70, 0x00, 0x18, 0xC0, 0x60, 0x00, 0x18, 0xC0,
  0x60, 0x00, 0x1C, 0xC0, 0x60, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x0D, 0xC0,
  0x60, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x0F, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x20, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x01, 0x81, 0x80, 0x1C, 0x00, 0xC1, 0xC0, 0x1E, 0x00,
  0x60, 0xC0, 0x0F, 0x00, 0x60, 0x60, 0x07, 0x80, 0x30, 0x30, 0x06, 0xC0,
  0x18, 0x18, 0x03, 0x60, 0x0C, 0x0C, 0x03, 0x30, 0x0C, 0x06, 0x01, 0x98,
  0x06, 0x03, 0x01, 0x84, 0x03, 0x01, 0x80, 0xC3, 0x01, 0x80, 0xC0, 0x61,
  0x81, 0x80, 0x60, 0x60, 0xC0, 0xC0, 0x30, 0x30, 0x60, 0x60, 0x18, 0x30,
  0x30, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x06, 0x0C,
  0x06, 0x0C, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x86, 0x00, 0xC6, 0x00, 0xC3,
  0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x19,
  0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0xC0, 0x03, 0x30, 0x03,
  0x60, 0x01, 0x98, 0x01, 0xE0, 0x00, 0x58, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x61, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFE, 0x0C, 0x07, 0xC0, 0xF1, 0x81, 0xC0, 0x03, 0x30,
  0x70, 0x00, 0x26, 0x1C, 0x00, 0x02, 0xC3, 0x00, 0x00, 0x78, 0xC0, 0x00,
  0x06, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0F, 0x0C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x58, 0x38, 0x00, 0x1B, 0x03, 0x00, 0x06, 0x60,
  0x70, 0x01, 0x8C, 0x07, 0x80, 0xE1, 0xF8, 0x3F, 0xF8, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x03, 0xF8, 0x00,
  0x30, 0xFF, 0xE0, 0x06, 0x1C, 0x0F, 0x80, 0x63, 0x00, 0x38, 0x06, 0x60,
  0x01, 0xC0, 0x6C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x78, 0x00, 0x03, 0x06, 0x80, 0x00, 0x70, 0x6C, 0x00,
  0x0E, 0x06, 0x60, 0x01, 0xC0, 0x63, 0x80, 0xF8, 0x06, 0x1F, 0xFE, 0x00,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7C,
  0x0F, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x06, 0x30, 0x00, 0x02, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0,
  0x30, 0x01, 0xFF, 0xE1, 0xC0, 0x1F, 0x01, 0xC6, 0x00, 0xE0, 0x01, 0x98,
  0x07, 0x00, 0x03, 0x60, 0x38, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x1E, 0x06,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x3C, 0x06, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x0D, 0x80, 0x30, 0x00, 0x66, 0x00, 0x70, 0x03,
  0x18, 0x01, 0xE0, 0x38, 0x60, 0x01, 0xFF, 0xC3, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x18, 0x00, 0x07, 0x8C, 0x00,
  0x0F, 0x83, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x18, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0xE1, 0xC0, 0x3E, 0x03, 0x8C, 0x03, 0x80, 0x06, 0x60, 0x38,
  0x00, 0x1B, 0x03, 0x80, 0x00, 0x58, 0x18, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x81, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x06, 0xC0, 0x30, 0x00,
  0x66, 0x01, 0xE0, 0x06, 0x30, 0x07, 0x80, 0xE1, 0x80, 0x0F, 0xFE, 0x1C,
  0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x10, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x30, 0xFF, 0xE0,
  0x18, 0xE0, 0x78, 0x0C, 0xC0, 0x0E, 0x0E, 0xC0, 0x03, 0x06, 0xC0, 0x01,
  0xC3, 0x40, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x20, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x0C, 0x07, 0x80, 0x03, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x0E, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x30, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x0C, 0x3F, 0xFC, 0x00, 0x61,
  0xC0, 0x78, 0x01, 0x8C, 0x00, 0x70, 0x06, 0x60, 0x00, 0xC0, 0x1B, 0x00,
  0x03, 0x00, 0x78, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x06,
  0x00, 0x0E, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x60, 0x3E, 0x00, 0x01, 0x83,
  0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xCC, 0x01, 0x80, 0x07, 0x30, 0x06, 0x00,
  0x38, 0xC0, 0x0C, 0x01, 0xC6, 0x00, 0x30, 0x0E, 0x18, 0x00, 0x60, 0x70,
  0x60, 0x01, 0xC3, 0x81, 0x80, 0x03, 0x1C, 0x06, 0x00, 0x0E, 0xE0, 0x18,
  0x00, 0x1F, 0x00, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x70,
  0x18, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x81, 0xE0, 0x03,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x06, 0x3F, 0xC3,
  0xFC, 0x06, 0x61, 0xC7, 0x0E, 0x06, 0x80, 0xEC, 0x07, 0x07, 0x00, 0x68,
  0x03, 0x0F, 0x00, 0x78, 0x03, 0x0E, 0x00, 0x70, 0x03, 0x0E, 0x00, 0x60,
  0x03, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60,
  0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0,
  0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0,
  0x0C, 0x38, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80,
  0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80,
  0x18, 0x70, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00,
  0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00,
  0x30, 0xE0, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x07, 0xF0, 0x03, 0x0F, 0xFE, 0x01, 0x8E, 0x07, 0x80, 0xCC,
  0x00, 0xE0, 0xEC, 0x00, 0x30, 0x6C, 0x00, 0x1C, 0x34, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x8C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1E, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x0F, 0xFE,
  0x00, 0x18, 0x70, 0x3E, 0x00, 0x63, 0x00, 0x38, 0x01, 0x98, 0x00, 0x70,
  0x06, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x0C, 0x06, 0x80,
  0x00, 0x70, 0x1B, 0x00, 0x03, 0x80, 0x66, 0x00, 0x1C, 0x01, 0x8E, 0x03,
  0xE0, 0x06, 0x1F, 0xFE, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0x01, 0xF0, 0x1C,
  0x60, 0x38, 0x00, 0x66, 0x07, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x16, 0x0C,
  0x00, 0x01, 0xE1, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0x60, 0x30, 0x00, 0x66, 0x01, 0xC0, 0x0C, 0x60, 0x1E,
  0x03, 0x86, 0x00, 0x7F, 0xF0, 0xE0, 0x01, 0xFC, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x0C, 0x70, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x1E, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x18,
  0x3C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x2C, 0x30, 0x00, 0x36, 0x1C, 0x00, 0x37, 0x07,
  0x00, 0x33, 0x01, 0xE0, 0x71, 0x80, 0x7F, 0xF0, 0xC0, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xDF, 0xF0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x1C, 0x00, 0x30, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x01, 0x83,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x30, 0x30, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0x30, 0x06,
  0x18, 0x00, 0xC0, 0x18, 0x60, 0x03, 0x00, 0x31, 0x80, 0x18, 0x00, 0xC6,
  0x00, 0x60, 0x03, 0x18, 0x01, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x33, 0x00,
  0x18, 0x00, 0xCC, 0x00, 0x60, 0x03, 0x30, 0x03, 0x00, 0x0C, 0xC0, 0x0C,
  0x00, 0x33, 0x00, 0x30, 0x00, 0xD8, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x00,
  0x0D, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x60, 0x01, 0x98, 0x01, 0x80, 0x06,
  0x60, 0x06, 0x00, 0x1B, 0x00, 0x18, 0x00, 0xEC, 0x00, 0x60, 0x03, 0x30,
  0x03, 0x80, 0x0C, 0xC0, 0x0E, 0x00, 0x73, 0x00, 0x38, 0x01, 0x8C, 0x01,
  0x60, 0x0E, 0x30, 0x0D, 0x80, 0x70, 0xE0, 0x66, 0x03, 0x81, 0xC3, 0x8E,
  0x1C, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x0F, 0x30, 0x1C, 0x38, 0x0F, 0x0E,
  0x0C, 0x06, 0x0F, 0x01, 0x86, 0x00, 0xCF, 0x00, 0x61, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x0C, 0x00, 0x03, 0x20, 0x03, 0x00, 0x00, 0xD8, 0x00, 0xC0,
  0x00, 0x34, 0x00, 0x30, 0x00, 0x0D, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x0B, 0x00, 0x00, 0xC0, 0x02, 0xC0, 0x00, 0x30, 0x01, 0xB0, 0x00, 0x8C,
  0x00, 0x46, 0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0xE0, 0x18, 0x60, 0x38,
  0x18, 0x0C, 0x0C, 0x3C, 0x07, 0x07, 0x03, 0x3C, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x05,
  0x80, 0x60, 0x00, 0x6C, 0x03, 0x80, 0x06, 0x60, 0x0E, 0x00, 0x67, 0x00,
  0x3C, 0x0E, 0x30, 0x00, 0xFF, 0xE1, 0x80, 0x01, 0xFC, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x30, 0x38, 0x0F, 0x81, 0x81, 0x80, 0x07,
  0xC6, 0x06, 0x00, 0x03, 0xD8, 0x30, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x20, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x30, 0x67, 0xF8, 0x00, 0xC1, 0x81,
  0xFF, 0x01, 0x8C, 0x00, 0x7F, 0xC6, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x06, 0x0F, 0xF0, 0x00, 0x0C, 0x38, 0x70, 0x00, 0x30, 0xE0,
  0x30, 0x00, 0x61, 0x80, 0x70, 0x01, 0x86, 0x00, 0x70, 0x03, 0x0C, 0x00,
  0x60, 0x0C, 0x30, 0x00, 0x60, 0x30, 0x60, 0x00, 0x70, 0xE1, 0x80, 0x00,
  0x7F, 0x83, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 11, 42, 36, 13, -42 },
  { 59, 13, 15, 36, 15, -44 },
  { 84, 36, 42, 36, 1, -42 },
  { 273, 32, 56, 36, 2, -49 },
  { 497, 40, 44, 36, -1, -43 },
  { 717, 34, 44, 36, 1, -43 },
  { 904, 5, 15, 36, 19, -44 },
  { 914, 19, 54, 36, 14, -46 },
  { 1043, 19, 54, 36, 4, -46 },
  { 1172, 30, 30, 36, 4, -33 },
  { 1285, 29, 30, 36, 4, -33 },
  { 1394, 10, 16, 36, 9, -6 },
  { 1414, 17, 2, 36, 10, -19 },
  { 1419, 5, 5, 36, 13, -5 },
  { 1423, 33, 54, 36, 2, -46 },
  { 1646, 29, 44, 36, 4, -43 },
  { 1806, 28, 42, 36, 3, -42 },
  { 1953, 30, 43, 36, 2, -43 },
  { 2115, 29, 44, 36, 3, -43 },
  { 2275, 30, 42, 36, 2, -42 },
  { 2433, 30, 43, 36, 3, -42 },
  { 2595, 27, 43, 36, 4, -42 },
  { 2741, 28, 42, 36, 7, -42 },
  { 2888, 30, 44, 36, 3, -43 },
  { 3053, 27, 43, 36, 6, -43 },
  { 3199, 10, 32, 36, 13, -32 },
  { 3239, 14, 42, 36, 9, -32 },
  { 3313, 29, 33, 36, 5, -35 },
  { 3433, 31, 13, 36, 3, -25 },
  { 3484, 29, 33, 36, 3, -35 },
  { 3604, 24, 43, 36, 9, -43 },
  { 3733, 27, 49, 36, 5, -43 },
  { 3899, 31, 42, 36, 0, -42 },
  { 4062, 29, 42, 36, 3, -42 },
  { 4215, 29, 44, 36, 5, -43 },
  { 4375, 29, 42, 36, 4, -42 },
  { 4528, 31, 42, 36, 4, -42 },
  { 4691, 32, 42, 36, 4, -42 },
  { 4859, 29, 44, 36, 5, -43 },
  { 5019, 32, 42, 36, 3, -42 },
  { 5187, 32, 42, 36, 3, -42 },
  { 5355, 28, 43, 36, 4, -42 },
  { 5506, 33, 42, 36, 4, -42 },
  { 5680, 23, 42, 36, 6, -42 },
  { 5801, 34, 42, 36, 2, -42 },
  { 5980, 32, 42, 36, 3, -42 },
  { 6148, 29, 44, 36, 4, -43 },
  { 6308, 31, 42, 36, 4, -42 },
  { 6471, 29, 53, 36, 4, -43 },
  { 6664, 31, 42, 36, 4, -42 },
  { 6827, 32, 44, 36, 2, -43 },
  { 7003, 32, 42, 36, 6, -42 },
  { 7171, 30, 43, 36, 5, -42 },
  { 7333, 30, 42, 36, 7, -42 },
  { 7491, 33, 42, 36, 4, -42 },
  { 7665, 37, 42, 36, 0, -42 },
  { 7860, 33, 42, 36, 6, -42 },
  { 8034, 36, 42, 36, 0, -42 },
  { 8223, 24, 54, 36, 11, -46 },
  { 8385, 14, 54, 36, 12, -46 },
  { 8480, 23, 54, 36, 2, -46 },
  { 8636, 28, 23, 36, 5, -42 },
  { 8717, 29, 2, 36, 0, 7 },
  { 8725, 7, 10, 36, 14, -46 },
  { 8734, 27, 33, 36, 4, -32 },
  { 8846, 28, 45, 36, 4, -44 },
  { 9004, 25, 33, 36, 5, -32 },
  { 9108, 30, 45, 36, 4, -44 },
  { 9277, 26, 33, 36, 5, -32 },
  { 9385, 38, 57, 36, -1, -44 },
  { 9656, 29, 45, 36, 3, -32 },
  { 9820, 25, 44, 36, 5, -44 },
  { 9958, 26, 46, 36, 5, -45 },
  { 10108, 25, 58, 36, 6, -45 },
  { 10290, 30, 45, 36, 4, -44 },
  { 10459, 23, 45, 36, 7, -44 },
  { 10589, 32, 32, 36, 2, -32 },
  { 10717, 25, 32, 36, 5, -32 },
  { 10817, 26, 33, 36, 5, -32 },
  { 10925, 30, 44, 36, 2, -32 },
  { 11090, 28, 44, 36, 4, -32 },
  { 11244, 29, 31, 36, 7, -31 },
  { 11357, 28, 33, 36, 4, -32 },
  { 11473, 28, 43, 36, 5, -42 },
  { 11624, 25, 32, 36, 6, -31 },
  { 11724, 27, 31, 36, 5, -31 },
  { 11829, 30, 32, 36, 4, -31 },
  { 11949, 34, 33, 36, 1, -32 },
  { 12090, 29, 44, 36, 2, -31 },
  { 12250, 30, 33, 36, 3, -32 },
  { 12374, 27, 54, 36, 7, -46 },
  { 12557, 11, 54, 36, 13, -46 },
  { 12632, 27, 54, 36, 3, -46 },
  { 12815, 31, 11, 36, 3, -24 },
};

const GFXfont IBMPlexMono_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC60PT7B_H_
