#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC59PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3E,
  0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x30, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0x63,
  0x03, 0x38, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0xC0,
  0xCC, 0x0E, 0x60, 0x63, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7C, 0x11, 0xF0, 0x00, 0xF0, 0x30, 0x3C, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x30, 0x06, 0x03, 0x00, 0x30, 0x07, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x40, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0x7E,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xBF, 0x00, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x01, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x70, 0x40, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x00, 0xE0, 0x70, 0x06,
  0x00, 0xC0, 0x38, 0x04, 0x01, 0xC0, 0x1E, 0x0C, 0x07, 0x80, 0x0F, 0x8C,
  0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x01, 0xE0, 0xE0, 0x00,
  0x30, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x03, 0x00, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0x40, 0x03, 0x01, 0x80, 0x00, 0x80, 0x06, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x03, 0x80, 0x70, 0x30, 0x00, 0x03, 0x83, 0xC0,
  0xC0, 0x00, 0x03, 0xFF, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x03, 0xFE, 0x00,
  0x00, 0x18, 0x1E, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x3C, 0x1C, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x01, 0xE3, 0xFC,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x1B, 0x00, 0x00, 0x98,
  0x0E, 0xC0, 0x00, 0x27, 0x03, 0x38, 0x00, 0x18, 0xC1, 0x86, 0x00, 0x0C,
  0x18, 0xE0, 0xE0, 0x06, 0x07, 0x30, 0x3C, 0x07, 0x00, 0xD8, 0x03, 0xFF,
  0x80, 0x3E, 0x00, 0x3F, 0x80, 0x07, 0x00, 0x39, 0x8C, 0x63, 0x39, 0x8C,
  0x63, 0x19, 0xCC, 0x63, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xBE, 0x00,
  0xC0, 0x1F, 0x3F, 0x03, 0x07, 0xF0, 0x1F, 0x98, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x0C,
  0x0E, 0x06, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x70,
  0x03, 0x30, 0x03, 0xC0, 0x19, 0x80, 0x3C, 0x00, 0xCC, 0x00, 0xE0, 0x06,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x00,
  0xF1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0x81, 0x80,
  0x01, 0xE0, 0x30, 0x00, 0x70, 0x06, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x00, 0x18, 0xFF, 0xF0, 0x00,
  0x6F, 0x01, 0xF0, 0x01, 0x60, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x04,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x0F, 0xE0, 0x01, 0x8F, 0xFF, 0x80, 0x67, 0x80, 0x78, 0x0D, 0xC0,
  0x03, 0x83, 0x60, 0x00, 0x38, 0x68, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x16, 0x70, 0x00, 0x0F, 0x0C, 0x00, 0x06, 0xC3, 0xC0, 0x03,
  0x30, 0x7C, 0x07, 0x98, 0x07, 0xFF, 0x86, 0x00, 0x7F, 0x83, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x87,
  0xC3, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x3E, 0x03, 0xC0, 0xE0,
  0x01, 0xC3, 0x80, 0x01, 0xC6, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0xFC,
  0x30, 0xC0, 0x3F, 0xE3, 0x0C, 0x07, 0x83, 0x31, 0x80, 0xE0, 0x0A, 0x18,
  0x0C, 0x00, 0xE1, 0x81, 0x80, 0x06, 0x18, 0x18, 0x00, 0x63, 0x01, 0x80,
  0x06, 0x30, 0x30, 0x00, 0x63, 0x03, 0x00, 0x0C, 0x30, 0x30, 0x00, 0xC3,
  0x03, 0x00, 0x0C, 0x70, 0x30, 0x00, 0xC6, 0x06, 0x00, 0x0C, 0x60, 0x60,
  0x00, 0xC6, 0x06, 0x00, 0x18, 0x60, 0x60, 0x01, 0x86, 0x06, 0x00, 0x18,
  0x60, 0x60, 0x03, 0x86, 0x06, 0x00, 0x38, 0x40, 0x30, 0x05, 0x8C, 0x03,
  0x00, 0x90, 0xC0, 0x1C, 0x3B, 0x0C, 0x01, 0xFF, 0x30, 0x40, 0x07, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x60, 0x03, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0C, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x78,
  0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x07, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFC,
  0xC0, 0x03, 0xFF, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0B, 0x07, 0x00, 0x01,
  0xB0, 0x38, 0x00, 0x36, 0x01, 0xC0, 0x06, 0x60, 0x0F, 0x01, 0xC6, 0x00,
  0x7F, 0xF8, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x03, 0x0E,
  0xC0, 0x00, 0x01, 0x8E, 0x30, 0x00, 0x00, 0xCE, 0x18, 0x00, 0x00, 0x6E,
  0x06, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x36, 0x00, 0x01,
  0xB0, 0x1B, 0x00, 0x00, 0xD8, 0x0C, 0xC0, 0x00, 0xCC, 0x06, 0x60, 0x00,
  0xC6, 0x03, 0x30, 0x00, 0x63, 0x03, 0x8C, 0x00, 0x63, 0x01, 0x86, 0x00,
  0x31, 0x80, 0xC3, 0x00, 0x30, 0xC0, 0x61, 0x80, 0x30, 0x60, 0x30, 0x60,
  0x18, 0x30, 0x18, 0x30, 0x18, 0x18, 0x1C, 0x18, 0x1C, 0x18, 0x0C, 0x04,
  0x0C, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x03, 0x01, 0x86, 0x03, 0x01, 0x80,
  0xC6, 0x01, 0x80, 0xC0, 0x37, 0x00, 0xC0, 0xE0, 0x1B, 0x00, 0xC0, 0x60,
  0x0F, 0x00, 0x60, 0x30, 0x03, 0x80, 0x30, 0x18, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x03, 0xC0,
  0x00, 0x0C, 0x0F, 0x80, 0x00, 0x18, 0x1B, 0x00, 0x00, 0x30, 0x36, 0x00,
  0x00, 0xC0, 0x66, 0x00, 0x01, 0x80, 0xCC, 0x00, 0x03, 0x01, 0x98, 0x00,
  0x06, 0x06, 0x18, 0x00, 0x0C, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x60, 0x00,
  0x60, 0x30, 0x60, 0x00, 0xC0, 0x60, 0xC0, 0x01, 0x80, 0xC1, 0x80, 0x03,
  0x03, 0x01, 0x80, 0x06, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x03, 0x03, 0x00, 0x30, 0x06, 0x06, 0x00, 0x60, 0x18, 0x0C,
  0x00, 0xE0, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x01, 0x80, 0xC0, 0xC0,
  0x03, 0x81, 0x81, 0x80, 0x03, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x06, 0x00,
  0x0E, 0x18, 0x0C, 0x00, 0x0C, 0x30, 0x18, 0x00, 0x18, 0x60, 0x60, 0x00,
  0x38, 0xC0, 0xC0, 0x00, 0x31, 0x81, 0x80, 0x00, 0x66, 0x03, 0x00, 0x00,
  0xEC, 0x06, 0x00, 0x00, 0xD8, 0x0C, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x03,
  0xE0, 0x60, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x78,
  0x18, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x78, 0x18, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x40, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x01, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0E,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x38, 0x01, 0x81, 0x80, 0x1C, 0x00, 0xC0, 0xC0, 0x0F, 0x00, 0x60, 0x60,
  0x0D, 0x80, 0x30, 0x30, 0x06, 0xC0, 0x30, 0x18, 0x06, 0x60, 0x18, 0x0C,
  0x03, 0x30, 0x0C, 0x06, 0x03, 0x18, 0x06, 0x03, 0x01, 0x8C, 0x06, 0x01,
  0x81, 0x86, 0x03, 0x00, 0xC0, 0xC3, 0x01, 0x80, 0x60, 0x60, 0xC1, 0x80,
  0x30, 0x60, 0x60, 0xC0, 0x30, 0x30, 0x30, 0x60, 0x18, 0x30, 0x18, 0x30,
  0x0C, 0x18, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x0C,
  0x01, 0x8C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x23,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x0D, 0x80, 0x06,
  0xC0, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xB0, 0x01, 0x60, 0x00,
  0xD8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x50, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x41,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFE, 0x0C, 0x07, 0x80, 0xE1, 0x81, 0xC0, 0x06, 0x70, 0x70, 0x00,
  0x2C, 0x1C, 0x00, 0x05, 0x87, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x02, 0xC1,
  0x80, 0x00, 0x98, 0x18, 0x00, 0x36, 0x03, 0x80, 0x0C, 0xC0, 0x3C, 0x0F,
  0x1F, 0xC3, 0xFF, 0xC1, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x01, 0x83, 0xFF, 0x80, 0x31,
  0xE0, 0x78, 0x06, 0x70, 0x03, 0x80, 0xD8, 0x00, 0x38, 0x1A, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x70, 0xD0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x40, 0x00, 0x30, 0x6C,
  0x00, 0x0E, 0x0C, 0xC0, 0x07, 0x81, 0x8E, 0x03, 0xE0, 0x60, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x78,
  0x0F, 0x00, 0x70, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x70, 0x00, 0x05, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x30, 0x03,
  0xFF, 0xC1, 0x80, 0x3C, 0x07, 0x8C, 0x03, 0x80, 0x0C, 0x60, 0x38, 0x00,
  0x16, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x58, 0x0E, 0x00, 0x04, 0xC0, 0x30, 0x00, 0x6E,
  0x01, 0xC0, 0x06, 0x60, 0x07, 0x80, 0xE3, 0x00, 0x1F, 0xFE, 0x18, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7C,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xE3,
  0x00, 0x07, 0xE1, 0x80, 0x7F, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x30, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x78,
  0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0F, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0x00, 0xF0,
  0x1E, 0x30, 0x1C, 0x00, 0x73, 0x03, 0x80, 0x01, 0x60, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x0B, 0x03, 0x00, 0x01, 0xB0, 0x18, 0x00,
  0x33, 0x01, 0xC0, 0x06, 0x70, 0x0F, 0x01, 0xC6, 0x00, 0x7F, 0xF8, 0x60,
  0x01, 0xFE, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x18, 0x7F, 0xF0,
  0x1C, 0x70, 0x3C, 0x0C, 0x60, 0x07, 0x06, 0x60, 0x01, 0x83, 0x60, 0x00,
  0xC1, 0xA0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x0C, 0x70, 0x00,
  0x06, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x18, 0x01, 0xC0,
  0x0C, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01, 0x87, 0x80,
  0x01, 0x87, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x60, 0xFF, 0xE0, 0x01,
  0x87, 0x01, 0xC0, 0x06, 0x70, 0x03, 0x80, 0x19, 0x00, 0x07, 0x00, 0x68,
  0x00, 0x0C, 0x03, 0xC0, 0x00, 0x30, 0x0D, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x8C, 0x03, 0x00, 0x07, 0x30, 0x06, 0x00, 0x39, 0xC0, 0x18,
  0x01, 0xC6, 0x00, 0x30, 0x0C, 0x18, 0x00, 0xE0, 0x60, 0x60, 0x01, 0x83,
  0x01, 0x80, 0x07, 0x18, 0x06, 0x00, 0x0D, 0xC0, 0x38, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x04, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x18, 0x03, 0x80,
  0x60, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x06,
  0x38, 0x00, 0x18, 0xE0, 0x00, 0x33, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x0C, 0x7F, 0x07, 0xF8, 0x19, 0x87,
  0x18, 0x38, 0x34, 0x06, 0x60, 0x30, 0x70, 0x05, 0x80, 0x61, 0xA0, 0x0E,
  0x00, 0xC3, 0x80, 0x18, 0x01, 0x86, 0x00, 0x30, 0x03, 0x0C, 0x00, 0x60,
  0x06, 0x18, 0x01, 0x80, 0x0C, 0x20, 0x03, 0x00, 0x18, 0xC0, 0x06, 0x00,
  0x31, 0x80, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x01, 0x86, 0x00, 0x30, 0x03,
  0x0C, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x0C, 0x60, 0x03, 0x00, 0x18,
  0xC0, 0x06, 0x00, 0x21, 0x80, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0x01, 0x86,
  0x00, 0x60, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x0C, 0x60,
  0x03, 0x00, 0x10, 0xC0, 0x06, 0x00, 0x61, 0x80, 0x18, 0x00, 0xC3, 0x00,
  0x30, 0x01, 0x8C, 0x00, 0x60, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x03, 0x0F, 0xFE, 0x01, 0x8E, 0x07,
  0x81, 0x8C, 0x00, 0xE0, 0xCC, 0x00, 0x30, 0x6C, 0x00, 0x18, 0x34, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1E,
  0x03, 0xC0, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0C, 0x1F, 0xFC, 0x00, 0x63, 0xC0, 0xF0, 0x03,
  0x38, 0x01, 0xC0, 0x1B, 0x00, 0x07, 0x00, 0xD0, 0x00, 0x18, 0x0F, 0x00,
  0x00, 0xE0, 0x68, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x06, 0x80,
  0x00, 0x60, 0x36, 0x00, 0x07, 0x01, 0x98, 0x00, 0xF0, 0x0C, 0x70, 0x1F,
  0x00, 0xC1, 0xFF, 0xE0, 0x06, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x0C, 0x07, 0x80, 0xF1, 0x81, 0xC0,
  0x06, 0x30, 0x70, 0x00, 0x2C, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x0C, 0x00, 0x02, 0xC1, 0xC0, 0x00, 0xD8, 0x18, 0x00, 0x33, 0x03, 0x80,
  0x0C, 0xC0, 0x3C, 0x07, 0x18, 0x03, 0xFF, 0xC3, 0x00, 0x0F, 0xE0, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x33, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x18,
  0x01, 0xE0, 0x01, 0x80, 0x78, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x83, 0xC0,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x37, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xB0, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x58, 0x38, 0x00, 0x4C, 0x0E, 0x00, 0x66, 0x03, 0x80, 0xE3,
  0x00, 0xFF, 0xC1, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xBF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x3C, 0x00, 0x60,
  0x3C, 0x00, 0x18, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x60, 0x06, 0x01, 0x83, 0x00, 0x30, 0x04, 0x30,
  0x01, 0x80, 0x31, 0x80, 0x0C, 0x01, 0x8C, 0x00, 0xC0, 0x0C, 0x60, 0x06,
  0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x19, 0x80, 0x0C, 0x00,
  0xCC, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x33, 0x00, 0x30, 0x01, 0x98,
  0x01, 0x80, 0x0C, 0xC0, 0x0C, 0x00, 0x6C, 0x00, 0x60, 0x03, 0x60, 0x03,
  0x00, 0x1B, 0x00, 0x30, 0x00, 0xD8, 0x01, 0x80, 0x06, 0xC0, 0x0C, 0x00,
  0x76, 0x00, 0x60, 0x03, 0x60, 0x03, 0x00, 0x1B, 0x00, 0x38, 0x00, 0xD8,
  0x01, 0x80, 0x0C, 0xC0, 0x0C, 0x00, 0x66, 0x00, 0xA0, 0x07, 0x30, 0x05,
  0x00, 0x31, 0x80, 0x6C, 0x03, 0x0C, 0x06, 0x60, 0x38, 0x38, 0x61, 0x87,
  0x81, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x0F, 0x30, 0x38, 0x70, 0x0F, 0x0E, 0x1C,
  0x06, 0x0F, 0x01, 0x86, 0x01, 0x8F, 0x00, 0x63, 0x00, 0x63, 0x00, 0x18,
  0x80, 0x18, 0x00, 0x03, 0x60, 0x07, 0x00, 0x00, 0xD0, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0xB0, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x03, 0x00, 0x1B,
  0x00, 0x00, 0xC0, 0x06, 0xC0, 0x00, 0x30, 0x03, 0x30, 0x01, 0x8C, 0x00,
  0xC6, 0x01, 0xF3, 0x80, 0x61, 0x81, 0xE0, 0x60, 0x30, 0x60, 0xE0, 0x1C,
  0x38, 0x0C, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x16, 0x01,
  0x80, 0x00, 0xF0, 0x0C, 0x00, 0x0B, 0x80, 0x70, 0x00, 0x98, 0x01, 0xC0,
  0x0C, 0xC0, 0x0F, 0x01, 0xC6, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x7F, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x20, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x18, 0x1F, 0xFF, 0xC0, 0xC1, 0xE0, 0x7F, 0x86, 0x0C,
  0x00, 0x3F, 0xB0, 0xC0, 0x00, 0x3F, 0x86, 0x00, 0x00, 0x78, 0x30, 0x00,
  0x03, 0x81, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x02,
  0x00, 0x0E, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x04, 0x1F, 0xC0,
  0x00, 0x30, 0xDF, 0xE0, 0x01, 0x8E, 0x0F, 0xF8, 0x0C, 0x60, 0x03, 0xFE,
  0x63, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x0C, 0x1F, 0xE0, 0x00, 0x30, 0xE1, 0xC0, 0x00,
  0xC7, 0x03, 0x80, 0x06, 0x18, 0x07, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0xC3,
  0x00, 0x18, 0x07, 0x18, 0x00, 0x70, 0x18, 0x60, 0x00, 0xE1, 0xC3, 0x00,
  0x01, 0xFE, 0x0C, 0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 41, 35, 13, -41 },
  { 53, 13, 15, 35, 15, -44 },
  { 78, 35, 41, 35, 1, -41 },
  { 258, 32, 55, 35, 2, -48 },
  { 478, 39, 43, 35, -1, -42 },
  { 688, 34, 43, 35, 1, -42 },
  { 871, 5, 15, 35, 19, -44 },
  { 881, 19, 53, 35, 14, -45 },
  { 1007, 19, 53, 35, 4, -45 },
  { 1133, 30, 29, 35, 4, -32 },
  { 1242, 28, 29, 35, 4, -33 },
  { 1344, 9, 15, 35, 9, -5 },
  { 1361, 16, 2, 35, 10, -19 },
  { 1365, 5, 5, 35, 13, -5 },
  { 1369, 32, 53, 35, 2, -45 },
  { 1581, 29, 43, 35, 4, -42 },
  { 1737, 27, 41, 35, 3, -41 },
  { 1876, 30, 42, 35, 2, -42 },
  { 2034, 29, 43, 35, 2, -42 },
  { 2190, 30, 41, 35, 2, -41 },
  { 2344, 30, 42, 35, 3, -41 },
  { 2502, 27, 42, 35, 4, -41 },
  { 2644, 28, 41, 35, 7, -41 },
  { 2788, 30, 43, 35, 3, -42 },
  { 2950, 26, 42, 35, 6, -42 },
  { 3087, 9, 31, 35, 13, -31 },
  { 3122, 13, 41, 35, 9, -31 },
  { 3189, 28, 32, 35, 5, -34 },
  { 3301, 30, 12, 35, 3, -24 },
  { 3346, 28, 32, 35, 3, -34 },
  { 3458, 23, 42, 35, 9, -42 },
  { 3579, 28, 48, 35, 4, -42 },
  { 3747, 30, 41, 35, 0, -41 },
  { 3901, 29, 41, 35, 3, -41 },
  { 4050, 28, 43, 35, 5, -42 },
  { 4201, 29, 41, 35, 4, -41 },
  { 4350, 31, 41, 35, 4, -41 },
  { 4509, 31, 41, 35, 4, -41 },
  { 4668, 28, 43, 35, 5, -42 },
  { 4819, 31, 41, 35, 3, -41 },
  { 4978, 31, 41, 35, 3, -41 },
  { 5137, 28, 42, 35, 4, -41 },
  { 5284, 33, 41, 35, 4, -41 },
  { 5454, 23, 41, 35, 6, -41 },
  { 5572, 33, 41, 35, 2, -41 },
  { 5742, 31, 41, 35, 3, -41 },
  { 5901, 29, 43, 35, 4, -42 },
  { 6057, 30, 41, 35, 4, -41 },
  { 6211, 29, 52, 35, 4, -42 },
  { 6400, 30, 41, 35, 4, -41 },
  { 6554, 32, 43, 35, 2, -42 },
  { 6726, 32, 41, 35, 6, -41 },
  { 6890, 29, 42, 35, 5, -41 },
  { 7043, 30, 41, 35, 7, -41 },
  { 7197, 33, 41, 35, 4, -41 },
  { 7367, 37, 41, 35, 0, -41 },
  { 7557, 32, 41, 35, 6, -41 },
  { 7721, 36, 41, 35, 0, -41 },
  { 7906, 24, 53, 35, 11, -45 },
  { 8065, 14, 53, 35, 11, -45 },
  { 8158, 23, 53, 35, 2, -45 },
  { 8311, 28, 23, 35, 5, -41 },
  { 8392, 28, 2, 35, 0, 7 },
  { 8399, 7, 10, 35, 14, -45 },
  { 8408, 27, 32, 35, 4, -31 },
  { 8516, 27, 45, 35, 4, -44 },
  { 8668, 25, 32, 35, 5, -31 },
  { 8768, 29, 45, 35, 4, -44 },
  { 8932, 25, 32, 35, 5, -31 },
  { 9032, 38, 57, 35, -1, -44 },
  { 9303, 28, 44, 35, 3, -31 },
  { 9457, 25, 44, 35, 5, -44 },
  { 9595, 25, 45, 35, 5, -44 },
  { 9736, 25, 57, 35, 6, -44 },
  { 9915, 30, 45, 35, 4, -44 },
  { 10084, 23, 45, 35, 7, -44 },
  { 10214, 31, 31, 35, 2, -31 },
  { 10335, 25, 31, 35, 5, -31 },
  { 10432, 26, 32, 35, 5, -31 },
  { 10536, 29, 43, 35, 2, -31 },
  { 10692, 27, 43, 35, 4, -31 },
  { 10838, 28, 30, 35, 7, -30 },
  { 10943, 28, 32, 35, 3, -31 },
  { 11055, 28, 42, 35, 5, -41 },
  { 11202, 25, 31, 35, 6, -30 },
  { 11299, 26, 31, 35, 5, -31 },
  { 11400, 29, 32, 35, 4, -31 },
  { 11516, 34, 32, 35, 1, -31 },
  { 11652, 29, 43, 35, 2, -30 },
  { 11808, 29, 32, 35, 3, -31 },
  { 11924, 27, 53, 35, 7, -45 },
  { 12103, 11, 53, 35, 13, -45 },
  { 12176, 26, 53, 35, 3, -45 },
  { 12349, 30, 11, 35, 3, -23 },
};

const GFXfont IBMPlexMono_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC59PT7B_H_
