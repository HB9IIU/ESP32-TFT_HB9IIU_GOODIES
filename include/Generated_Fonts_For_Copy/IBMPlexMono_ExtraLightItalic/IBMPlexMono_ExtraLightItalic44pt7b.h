#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC44PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0E, 0x1C, 0x38, 0x00, 0x20, 0xC8, 0x26, 0x09, 0x86, 0x61, 0x98,
  0x64, 0x19, 0x04, 0xC1, 0x30, 0xCC, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x08, 0x00,
  0x02, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x40, 0x00, 0x10, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x60,
  0x60, 0x00, 0x10, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x10, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x20, 0x00, 0x08, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xE3, 0x3C, 0x01, 0x82, 0x06, 0x02, 0x02, 0x03,
  0x06, 0x02, 0x02, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x04, 0x00,
  0x06, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0B, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x08, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x0C,
  0x00, 0x10, 0x08, 0x00, 0x30, 0x08, 0x40, 0x30, 0x18, 0xC0, 0x20, 0x10,
  0x60, 0x20, 0x30, 0x38, 0x20, 0x60, 0x0E, 0x21, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7C, 0x00, 0x0C, 0x06, 0x08, 0x00, 0x40, 0x30, 0x10, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x40, 0x10, 0x02, 0x02, 0x00, 0x40,
  0x08, 0x18, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x01, 0x82, 0x00, 0x30, 0x04,
  0x10, 0x00, 0xC0, 0x10, 0xC0, 0x01, 0x00, 0xC6, 0x00, 0x04, 0x06, 0x10,
  0x00, 0x0C, 0x30, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x0C, 0x30, 0x00,
  0x10, 0x40, 0x60, 0x00, 0xC3, 0x00, 0x80, 0x06, 0x08, 0x02, 0x00, 0x10,
  0x60, 0x08, 0x00, 0x81, 0x80, 0x20, 0x06, 0x04, 0x00, 0x80, 0x30, 0x10,
  0x02, 0x00, 0x80, 0x40, 0x18, 0x04, 0x01, 0x00, 0x60, 0x30, 0x04, 0x01,
  0x01, 0x80, 0x08, 0x08, 0x04, 0x00, 0x30, 0xC0, 0x20, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x00,
  0x40, 0x01, 0x80, 0x10, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04,
  0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x18, 0x01, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x0E, 0x8C, 0x00, 0x0C, 0x3C, 0x00, 0x04, 0x06, 0x00, 0x02, 0x00,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x04, 0x00, 0x10, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xA0,
  0x34, 0x00, 0x2C, 0x09, 0x00, 0x09, 0x04, 0x60, 0x04, 0x63, 0x0C, 0x03,
  0x0C, 0x81, 0x81, 0x81, 0x40, 0x1F, 0x80, 0x70, 0x32, 0x26, 0x66, 0x44,
  0x4C, 0xC0, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x30, 0x1C, 0xF0, 0xC7, 0xC0,
  0x7A, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00, 0x19,
  0x80, 0x00, 0xC2, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60,
  0x0C, 0x00, 0xC0, 0x20, 0x01, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0x41, 0x82, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x60, 0x40,
  0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09,
  0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00,
  0x05, 0x80, 0xC0, 0x28, 0x0E, 0x03, 0x40, 0x70, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0,
  0x03, 0x02, 0x00, 0x10, 0x18, 0x03, 0x00, 0x70, 0x70, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0xC3,
  0x00, 0x30, 0x20, 0x06, 0x02, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80,
  0x30, 0x03, 0x01, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0E,
  0x07, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x19, 0x80, 0x00, 0x8C, 0x00, 0x08,
  0x30, 0x00, 0xC0, 0xE0, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x02, 0xC0, 0x00, 0x09, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0x60, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x04,
  0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x0F, 0xE0, 0x02, 0x60, 0x60, 0x05, 0x00, 0x30,
  0x1C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x82, 0x00, 0x02, 0x0E, 0x00,
  0x0C, 0x06, 0x00, 0x30, 0x07, 0x01, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x0F, 0xE0, 0x33, 0x03, 0x83,
  0x40, 0x0C, 0x68, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x06, 0x40, 0x00, 0x46, 0x00, 0x0C, 0x20, 0x01, 0x83, 0x00,
  0x30, 0x1C, 0x0E, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFB, 0x00, 0x00, 0xD0,
  0x00, 0x0C, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0xE0, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x40, 0x40, 0x01, 0x80, 0x40, 0x06, 0x00, 0x60, 0x30, 0x00,
  0x3F, 0x80, 0x07, 0x81, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80,
  0x00, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x38, 0x03, 0x01, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x30, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x06, 0x30, 0x00,
  0x22, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x64, 0x00, 0x06, 0x60,
  0x00, 0xE2, 0x00, 0x16, 0x30, 0x02, 0x41, 0xC0, 0xCC, 0x07, 0xF0, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x1C, 0x38, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0x81, 0xC1, 0x80, 0x18, 0xC0, 0x02, 0x60,
  0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x06, 0x06, 0x00, 0x60, 0x08, 0x06, 0x00, 0x20, 0x60,
  0x01, 0x02, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18,
  0x80, 0x7C, 0xC4, 0x0C, 0x16, 0x60, 0xC0, 0x63, 0x04, 0x03, 0x10, 0x60,
  0x18, 0x82, 0x00, 0xC4, 0x10, 0x06, 0x61, 0x80, 0x33, 0x0C, 0x01, 0x18,
  0x60, 0x08, 0x82, 0x00, 0x44, 0x10, 0x06, 0x20, 0x80, 0x31, 0x04, 0x01,
  0x98, 0x20, 0x18, 0xC1, 0x81, 0x46, 0x06, 0x12, 0x30, 0x1F, 0x11, 0x80,
  0x01, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00, 0x06,
  0x40, 0x00, 0x11, 0x00, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x41, 0x80, 0x03, 0x02, 0x00, 0x08, 0x08, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x30, 0x01, 0x00, 0xC0, 0x06, 0x07, 0xFF, 0xF8, 0x18, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x40, 0x07, 0xFF, 0xC0, 0x18, 0x01, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x06,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x81, 0x80, 0x0C, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0xC0,
  0x40, 0x00, 0x81, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x00, 0x0E, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x30,
  0x00, 0x30, 0x80, 0x03, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0x70, 0x70,
  0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x20, 0x0E, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x01,
  0x18, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00,
  0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x62, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x80, 0x02, 0x0C, 0x00, 0x20, 0x60, 0x0E, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0E, 0x0E, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x60,
  0xC0, 0x01, 0x0C, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xFF,
  0x20, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x18, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x70,
  0x80, 0x03, 0x06, 0x00, 0x28, 0x18, 0x02, 0x40, 0x60, 0x66, 0x00, 0xFC,
  0x00, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x02, 0x0F, 0xFF, 0xFC, 0x10,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x83, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x20, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x04, 0x00, 0x60, 0x30, 0x06, 0x00, 0xE0,
  0xE0, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x60, 0x08, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1C,
  0x00, 0x10, 0x30, 0x00, 0x10, 0x60, 0x00, 0x10, 0xE0, 0x00, 0x31, 0xA0,
  0x00, 0x33, 0x30, 0x00, 0x36, 0x10, 0x00, 0x2C, 0x18, 0x00, 0x38, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFC, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0D,
  0x00, 0x1A, 0x09, 0x00, 0x1A, 0x09, 0x80, 0x36, 0x09, 0x80, 0x66, 0x18,
  0x80, 0x66, 0x18, 0x80, 0xC6, 0x18, 0xC0, 0x84, 0x10, 0x41, 0x84, 0x10,
  0x41, 0x0C, 0x10, 0x43, 0x0C, 0x30, 0x66, 0x0C, 0x30, 0x24, 0x0C, 0x30,
  0x2C, 0x08, 0x20, 0x38, 0x08, 0x20, 0x38, 0x08, 0x20, 0x10, 0x18, 0x60,
  0x20, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x07, 0x00, 0x02, 0x0E,
  0x00, 0x04, 0x16, 0x00, 0x08, 0x2C, 0x00, 0x30, 0x48, 0x00, 0x61, 0x90,
  0x00, 0xC3, 0x30, 0x01, 0x06, 0x20, 0x02, 0x08, 0x40, 0x04, 0x10, 0xC0,
  0x18, 0x21, 0x80, 0x30, 0xC1, 0x00, 0x61, 0x83, 0x00, 0x83, 0x06, 0x01,
  0x04, 0x04, 0x02, 0x08, 0x0C, 0x0C, 0x10, 0x18, 0x18, 0x60, 0x10, 0x30,
  0xC0, 0x30, 0x41, 0x80, 0x60, 0x82, 0x00, 0x41, 0x04, 0x00, 0xC6, 0x08,
  0x01, 0x8C, 0x30, 0x01, 0x18, 0x60, 0x03, 0x20, 0xC0, 0x06, 0x41, 0x00,
  0x04, 0x82, 0x00, 0x0F, 0x04, 0x00, 0x1E, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x08, 0x0C, 0x00,
  0x60, 0x40, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x01, 0x30,
  0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00,
  0x30, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x18, 0x03, 0x00, 0x70, 0x70, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x10,
  0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x38, 0x3F, 0xFF,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x08,
  0x0C, 0x00, 0x60, 0x40, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00,
  0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02,
  0x10, 0x00, 0x30, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x18, 0x03, 0x00, 0x70,
  0x70, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x10,
  0x00, 0x31, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xC0, 0x10,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0x38, 0x3F, 0xFF, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x80,
  0x08, 0x06, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x18,
  0x01, 0x80, 0x40, 0x02, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xE0, 0x3C, 0x01, 0x80, 0x06, 0x02, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x18, 0xE0, 0x00, 0x10, 0x60, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00,
  0x02, 0x30, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0xC0, 0x00, 0x66,
  0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00,
  0x62, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x60,
  0x00, 0x62, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C,
  0x20, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x30, 0x03, 0x00, 0xC0,
  0x70, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x08,
  0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00,
  0x60, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x18, 0x04, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x06, 0x06, 0x00, 0x08,
  0x10, 0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x33, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x01, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x18, 0x0C,
  0x20, 0x38, 0x0C, 0x20, 0x28, 0x08, 0x20, 0x68, 0x08, 0x60, 0x68, 0x18,
  0x60, 0x48, 0x18, 0x60, 0xCC, 0x10, 0x60, 0x8C, 0x10, 0x61, 0x8C, 0x30,
  0x61, 0x0C, 0x30, 0x63, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x60,
  0x46, 0x04, 0x60, 0x44, 0x04, 0x40, 0x4C, 0x06, 0x40, 0x48, 0x06, 0xC0,
  0x58, 0x06, 0x80, 0xD0, 0x06, 0x80, 0xF0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x10, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x01,
  0x83, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x10, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x04, 0x20, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0F,
  0xFE, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x06, 0x10, 0x00, 0x60, 0xC0, 0x02,
  0x02, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x02, 0x01, 0x00, 0x18,
  0x18, 0x00, 0x41, 0x80, 0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00,
  0x03, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xF8, 0x88, 0xC4, 0x62, 0x31, 0x00,
  0xFC, 0x30, 0x30, 0x33, 0x0C, 0x00, 0xB1, 0x80, 0x0B, 0x10, 0x00, 0x63,
  0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06,
  0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0x80, 0x00,
  0xC8, 0x00, 0x0C, 0x80, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x02, 0x84, 0x00,
  0x38, 0x60, 0x05, 0x83, 0x00, 0x98, 0x18, 0x31, 0xF0, 0x7E, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x3F, 0x00, 0x8C, 0x1C, 0x09, 0x00, 0x61, 0xA0, 0x02, 0x1C, 0x00,
  0x31, 0xC0, 0x01, 0x18, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x13, 0x00,
  0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x03, 0x20,
  0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x46,
  0x00, 0x0C, 0x50, 0x01, 0x8C, 0x80, 0x30, 0xC6, 0x0E, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x01, 0xC1, 0xC0, 0xC0, 0x18, 0x60, 0x03, 0x30, 0x00, 0xC8,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x06, 0x0C,
  0x03, 0x01, 0x81, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x0F, 0xC1,
  0x00, 0xC0, 0xCC, 0x0C, 0x00, 0xB0, 0x60, 0x02, 0xC1, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x20, 0x00, 0x21, 0x80, 0x01, 0x84, 0x00, 0x06, 0x10, 0x00,
  0x18, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x10,
  0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0,
  0x02, 0x81, 0x00, 0x0E, 0x06, 0x00, 0x58, 0x0C, 0x02, 0x60, 0x18, 0x31,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0xE0, 0xC0, 0x0C, 0x60,
  0x03, 0x10, 0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xE8, 0x00, 0xE2, 0x03, 0xE0, 0xFF, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x3C, 0x00, 0x1B, 0x00,
  0x04, 0x60, 0x02, 0x0C, 0x01, 0x81, 0x81, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x08, 0x0C,
  0x0C, 0xC1, 0x80, 0x16, 0x18, 0x00, 0x70, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x40, 0x00, 0x46, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00,
  0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x88,
  0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x08, 0x00, 0x50, 0x60, 0x05,
  0x81, 0x80, 0x6C, 0x06, 0x0C, 0x60, 0x1F, 0xC2, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x08, 0x00, 0x20,
  0x60, 0x06, 0x01, 0xC0, 0xE0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x87, 0xE0, 0x66, 0x0C, 0x1A,
  0x00, 0x85, 0x00, 0x31, 0xC0, 0x0C, 0xE0, 0x01, 0x30, 0x00, 0x4C, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x09,
  0x80, 0x02, 0x40, 0x01, 0x90, 0x00, 0x64, 0x00, 0x1B, 0x00, 0x04, 0xC0,
  0x01, 0x30, 0x00, 0x48, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x20, 0x40, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x32, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x08, 0x03, 0x03, 0x80, 0x60, 0x18, 0x08, 0x01, 0x81, 0x00,
  0x18, 0x20, 0x01, 0x8C, 0x00, 0x09, 0x80, 0x00, 0xB0, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC3, 0xF0, 0x02, 0x30, 0x30, 0x09, 0x00, 0x60,
  0x68, 0x01, 0x81, 0xC0, 0x02, 0x07, 0x00, 0x08, 0x18, 0x00, 0x20, 0x60,
  0x01, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x00, 0xC0, 0x18,
  0x03, 0x03, 0x00, 0x08, 0x70, 0x00, 0x20, 0x80, 0x01, 0x83, 0x00, 0x06,
  0x04, 0x00, 0x58, 0x18, 0x02, 0x60, 0x20, 0x11, 0x00, 0xC0, 0x84, 0x01,
  0x84, 0x30, 0x06, 0x20, 0xC0, 0x0D, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x80, 0xC1, 0x80,
  0x41, 0x80, 0x21, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x06, 0x00, 0x00, 0x19,
  0xF0, 0x78, 0x34, 0x31, 0x18, 0x50, 0x2C, 0x18, 0xC0, 0x50, 0x31, 0x80,
  0xC0, 0x66, 0x01, 0x80, 0xCC, 0x02, 0x01, 0x98, 0x04, 0x03, 0x20, 0x18,
  0x04, 0x40, 0x30, 0x08, 0x80, 0x60, 0x13, 0x00, 0x80, 0x66, 0x01, 0x00,
  0xCC, 0x02, 0x01, 0x90, 0x0C, 0x02, 0x20, 0x18, 0x04, 0x40, 0x30, 0x09,
  0x80, 0x40, 0x33, 0x00, 0x80, 0x66, 0x01, 0x00, 0xC8, 0x06, 0x01, 0x10,
  0x0C, 0x02, 0x20, 0x18, 0x0C, 0x00, 0x18, 0x7E, 0x06, 0x60, 0xC1, 0xA0,
  0x08, 0x50, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x03,
  0x30, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x02, 0x60, 0x00, 0x98,
  0x00, 0x24, 0x00, 0x19, 0x00, 0x06, 0x40, 0x01, 0xB0, 0x00, 0x4C, 0x00,
  0x13, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x30, 0x00, 0xFE,
  0x00, 0x38, 0x38, 0x06, 0x00, 0xC0, 0xC0, 0x06, 0x18, 0x00, 0x21, 0x00,
  0x02, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x06, 0xC0, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0xC6, 0x00, 0x08,
  0x20, 0x01, 0x01, 0x00, 0x20, 0x0C, 0x0C, 0x00, 0x7F, 0x00, 0x06, 0x1F,
  0x80, 0x23, 0x07, 0x01, 0x20, 0x0C, 0x1A, 0x00, 0x20, 0xE0, 0x01, 0x87,
  0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00,
  0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x40,
  0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x01, 0x8C, 0x00, 0x08,
  0x60, 0x00, 0xC2, 0x80, 0x0C, 0x12, 0x00, 0xC1, 0x8C, 0x1C, 0x0C, 0x3F,
  0x80, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC,
  0x10, 0x30, 0x33, 0x0C, 0x00, 0xB1, 0x80, 0x0B, 0x10, 0x00, 0x63, 0x00,
  0x06, 0x20, 0x00, 0x26, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0xC0,
  0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0xC8,
  0x00, 0x0C, 0x80, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x84, 0x00, 0x28,
  0x60, 0x05, 0x83, 0x00, 0x98, 0x18, 0x31, 0x00, 0xFC, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0xFF, 0x87, 0xF8, 0x04, 0xC0, 0x00,
  0x68, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x70, 0x1C,
  0x0C, 0x00, 0x60, 0x80, 0x03, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x68, 0x00, 0x04, 0xC0, 0x00, 0xC6,
  0x00, 0x18, 0x1C, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x08, 0x03, 0x00, 0x70, 0x0C, 0x06, 0x00, 0x20, 0x30, 0x00, 0x83, 0x00,
  0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x23, 0x00, 0x04, 0x60,
  0x01, 0x88, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x11, 0x80,
  0x02, 0x30, 0x00, 0x44, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0x46, 0x00,
  0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x05, 0x84, 0x00,
  0xA0, 0xC0, 0x24, 0x0C, 0x18, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0x60, 0x80,
  0x0C, 0x10, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0x43, 0x00,
  0x08, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x8C, 0x00,
  0x21, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x03,
  0x02, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x63, 0x80,
  0x0F, 0xC0, 0x00, 0x10, 0x08, 0x18, 0x40, 0x20, 0x23, 0x00, 0x80, 0x8C,
  0x06, 0x03, 0x30, 0x18, 0x0C, 0x80, 0x60, 0x32, 0x01, 0x00, 0xC8, 0x04,
  0x03, 0x60, 0x10, 0x0D, 0x80, 0x40, 0x36, 0x03, 0x00, 0xD0, 0x0C, 0x03,
  0x40, 0x30, 0x0D, 0x00, 0x80, 0x24, 0x02, 0x00, 0xB0, 0x08, 0x02, 0xC0,
  0x60, 0x1B, 0x01, 0x80, 0x48, 0x06, 0x01, 0x20, 0x28, 0x0C, 0x80, 0xA0,
  0x23, 0x04, 0x81, 0x04, 0x23, 0x18, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x3E,
  0x03, 0x98, 0x21, 0x87, 0x04, 0x20, 0x46, 0x02, 0x20, 0x34, 0x01, 0x90,
  0x18, 0x00, 0xD0, 0x0C, 0x00, 0x28, 0x06, 0x00, 0x18, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x28, 0x00, 0x40, 0x14, 0x00, 0x20, 0x0A, 0x00, 0x10, 0x09, 0x00, 0x48,
  0x0C, 0xC0, 0xC6, 0x04, 0x21, 0xC1, 0x8C, 0x1B, 0x80, 0x78, 0x07, 0x00,
  0x04, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0,
  0x01, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x20,
  0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x08, 0x00,
  0x30, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x70, 0x20, 0x05, 0x81, 0x80, 0x48, 0x06, 0x0C, 0x40, 0x1F, 0x82,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x08, 0x00, 0x60, 0x60, 0x06, 0x01, 0xC0, 0xE0, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x0C, 0x18, 0x3E, 0x30, 0x80, 0x1E, 0xC6, 0x00, 0x0E, 0x10,
  0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x30,
  0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x4E, 0x00, 0x21, 0x07, 0xC0,
  0xCC, 0x00, 0xF3, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x01,
  0xFF, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x06, 0x10, 0x80, 0x08, 0x40, 0x80, 0x11, 0x01, 0x80,
  0x62, 0x01, 0x80, 0x88, 0x01, 0x02, 0x10, 0x01, 0x08, 0x60, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 10, -31 },
  { 29, 10, 11, 26, 11, -33 },
  { 43, 26, 31, 26, 1, -31 },
  { 144, 24, 40, 26, 1, -35 },
  { 264, 30, 32, 26, -1, -31 },
  { 384, 26, 32, 26, 0, -31 },
  { 488, 4, 11, 26, 14, -33 },
  { 494, 14, 39, 26, 10, -33 },
  { 563, 14, 39, 26, 3, -33 },
  { 632, 22, 22, 26, 3, -24 },
  { 693, 21, 21, 26, 3, -24 },
  { 749, 7, 11, 26, 7, -4 },
  { 759, 13, 1, 26, 7, -14 },
  { 761, 3, 4, 26, 10, -4 },
  { 763, 23, 39, 26, 2, -33 },
  { 876, 21, 32, 26, 3, -31 },
  { 960, 20, 31, 26, 2, -31 },
  { 1038, 22, 31, 26, 2, -31 },
  { 1124, 21, 32, 26, 2, -31 },
  { 1208, 23, 31, 26, 1, -31 },
  { 1298, 23, 32, 26, 2, -31 },
  { 1390, 20, 32, 26, 3, -31 },
  { 1470, 21, 31, 26, 5, -31 },
  { 1552, 23, 32, 26, 2, -31 },
  { 1644, 20, 31, 26, 4, -31 },
  { 1722, 7, 24, 26, 10, -24 },
  { 1743, 10, 31, 26, 7, -24 },
  { 1782, 21, 24, 26, 4, -25 },
  { 1845, 23, 9, 26, 2, -18 },
  { 1871, 21, 24, 26, 2, -25 },
  { 1934, 18, 31, 26, 6, -31 },
  { 2004, 21, 36, 26, 3, -31 },
  { 2099, 22, 31, 26, 0, -31 },
  { 2185, 22, 31, 26, 2, -31 },
  { 2271, 21, 32, 26, 4, -31 },
  { 2355, 21, 31, 26, 3, -31 },
  { 2437, 23, 31, 26, 3, -31 },
  { 2527, 23, 31, 26, 3, -31 },
  { 2617, 21, 32, 26, 4, -31 },
  { 2701, 23, 31, 26, 2, -31 },
  { 2791, 24, 31, 26, 2, -31 },
  { 2884, 21, 32, 26, 3, -31 },
  { 2968, 24, 31, 26, 3, -31 },
  { 3061, 18, 31, 26, 4, -31 },
  { 3131, 24, 31, 26, 2, -31 },
  { 3224, 23, 31, 26, 2, -31 },
  { 3314, 21, 32, 26, 3, -31 },
  { 3398, 22, 31, 26, 3, -31 },
  { 3484, 21, 38, 26, 3, -31 },
  { 3584, 22, 31, 26, 3, -31 },
  { 3670, 24, 32, 26, 1, -31 },
  { 3766, 23, 31, 26, 5, -31 },
  { 3856, 21, 32, 26, 4, -31 },
  { 3940, 22, 31, 26, 5, -31 },
  { 4026, 24, 31, 26, 3, -31 },
  { 4119, 27, 31, 26, 0, -31 },
  { 4224, 25, 31, 26, 4, -31 },
  { 4321, 27, 31, 26, 0, -31 },
  { 4426, 18, 39, 26, 8, -33 },
  { 4514, 10, 39, 26, 9, -33 },
  { 4563, 18, 39, 26, 1, -33 },
  { 4651, 21, 17, 26, 3, -31 },
  { 4696, 21, 1, 26, 0, 5 },
  { 4699, 4, 8, 26, 11, -34 },
  { 4703, 20, 24, 26, 3, -23 },
  { 4763, 20, 34, 26, 3, -33 },
  { 4848, 18, 24, 26, 4, -23 },
  { 4902, 22, 34, 26, 3, -33 },
  { 4996, 18, 24, 26, 4, -23 },
  { 5050, 27, 42, 26, 0, -33 },
  { 5192, 21, 32, 26, 2, -23 },
  { 5276, 18, 33, 26, 4, -33 },
  { 5351, 19, 34, 26, 4, -33 },
  { 5432, 19, 42, 26, 4, -33 },
  { 5532, 22, 34, 26, 3, -33 },
  { 5626, 17, 34, 26, 5, -33 },
  { 5699, 23, 23, 26, 2, -23 },
  { 5766, 18, 23, 26, 4, -23 },
  { 5818, 20, 24, 26, 3, -23 },
  { 5878, 21, 32, 26, 2, -23 },
  { 5962, 20, 32, 26, 3, -23 },
  { 6042, 21, 23, 26, 5, -23 },
  { 6103, 20, 24, 26, 3, -23 },
  { 6163, 22, 32, 26, 3, -31 },
  { 6251, 19, 24, 26, 4, -23 },
  { 6308, 19, 23, 26, 4, -23 },
  { 6363, 22, 24, 26, 3, -23 },
  { 6429, 25, 24, 26, 1, -23 },
  { 6504, 21, 32, 26, 2, -23 },
  { 6588, 22, 24, 26, 2, -23 },
  { 6654, 20, 39, 26, 5, -33 },
  { 6752, 8, 39, 26, 10, -33 },
  { 6791, 20, 39, 26, 2, -33 },
  { 6889, 23, 8, 26, 2, -17 },
};

const GFXfont IBMPlexMono_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC44PT7B_H_
