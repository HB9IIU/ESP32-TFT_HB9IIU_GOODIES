#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC33PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x00, 0x00, 0x00, 0x63, 0x8E, 0x00, 0x23, 0x62, 0x42, 0x42, 0x42,
  0x46, 0x44, 0xC4, 0x00, 0x20, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21,
  0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x08, 0x20, 0x3F, 0x07,
  0xE0, 0x21, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00, 0x08, 0x20,
  0x3F, 0x07, 0xE0, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x61, 0x00,
  0x08, 0x20, 0x01, 0x04, 0x00, 0x61, 0x00, 0x08, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x06, 0x23, 0x03, 0x08, 0x21,
  0x82, 0x04, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0x61,
  0x00, 0x0C, 0x40, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x30, 0x00, 0x82,
  0x00, 0x20, 0xC0, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xCC,
  0x10, 0x21, 0x84, 0x18, 0x39, 0x18, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x18, 0x40, 0x20, 0x40, 0x81,
  0x82, 0x02, 0x04, 0x08, 0x08, 0x20, 0x20, 0x21, 0x00, 0x80, 0x8C, 0x02,
  0x04, 0x20, 0x08, 0x11, 0x00, 0x30, 0x88, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x02, 0x21, 0x80, 0x11, 0x02, 0x00, 0x8C, 0x08,
  0x04, 0x20, 0x20, 0x10, 0x80, 0x80, 0x82, 0x02, 0x04, 0x08, 0x08, 0x20,
  0x20, 0x40, 0x80, 0x42, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x60,
  0x80, 0x08, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00,
  0x80, 0x30, 0x10, 0x02, 0x02, 0x00, 0x60, 0x80, 0x0C, 0x20, 0x0E, 0x78,
  0x02, 0x08, 0x00, 0x80, 0x80, 0x10, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x10,
  0x18, 0x03, 0x07, 0x00, 0xA0, 0xA0, 0x12, 0x24, 0x02, 0x44, 0x61, 0x85,
  0x07, 0xC0, 0xC0, 0x57, 0xAA, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x03, 0x82, 0x0E, 0x39, 0x78, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xB0,
  0x00, 0x88, 0x00, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x40, 0xC0, 0x30, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x18, 0x8C, 0x46,
  0x21, 0x10, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xF8, 0x06, 0x04, 0x0C, 0x02, 0x08, 0x03, 0x10, 0x01,
  0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x41, 0x81, 0x41, 0xC1, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x0F, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x0C, 0x80, 0x31, 0x00, 0xC2, 0x02, 0x04, 0x08,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0x83,
  0x01, 0x00, 0x41, 0x00, 0x20, 0x80, 0x18, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x01,
  0x83, 0x03, 0x00, 0x41, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x98, 0x00, 0x86, 0x00, 0x81, 0x81, 0x80, 0x3F, 0x80, 0x00, 0x03,
  0x00, 0x02, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x01, 0x04, 0x01, 0x06, 0x01, 0x82, 0x01, 0x81, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0x80, 0x30, 0xC0, 0x10, 0xC0, 0x08, 0x7F, 0xFF,
  0xC0, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x07,
  0xFF, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x13, 0xF0, 0x2C, 0x18, 0x30, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x80, 0x08, 0xC0, 0x18, 0x70, 0x30, 0x1F, 0xC0, 0x00, 0x1C, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x67, 0xE0, 0xB0, 0x63, 0x80, 0x26, 0x00, 0x6C, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x66, 0x01,
  0x86, 0x06, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x80, 0x07, 0x00, 0x14, 0x00,
  0x68, 0x00, 0x90, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x00, 0x01, 0xF8, 0x06, 0x06, 0x08, 0x03, 0x10, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x30, 0x01, 0x10, 0x03, 0x10, 0x02, 0x0C, 0x0C, 0x03, 0xF0, 0x1C,
  0x18, 0x20, 0x04, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x06, 0xC0, 0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x03,
  0xF0, 0x18, 0x30, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x33, 0x00, 0xA3, 0x06, 0xC1,
  0xF1, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xE3, 0x80, 0x06, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0x80, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xC1, 0x81,
  0x98, 0x04, 0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x70, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03,
  0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x31, 0x00, 0x24, 0x00, 0x48, 0x00,
  0xA0, 0x79, 0x43, 0x0A, 0x84, 0x09, 0x10, 0x16, 0x20, 0x28, 0x40, 0x50,
  0x80, 0xA3, 0x03, 0x44, 0x04, 0x88, 0x09, 0x08, 0x32, 0x10, 0xA4, 0x1E,
  0x48, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0B, 0x00, 0x04, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x06, 0x00, 0x81, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x3F, 0xF8, 0x10, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x26, 0x00, 0x12, 0x00,
  0x0F, 0x00, 0x02, 0x0F, 0xF8, 0x18, 0x06, 0x10, 0x02, 0x10, 0x03, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x04, 0x20,
  0x08, 0x3F, 0xF0, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x06, 0xC0, 0x04, 0x80, 0x0C, 0x80, 0x18, 0xFF,
  0xE0, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x06, 0x10, 0x02, 0x30, 0x03, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x08, 0x80, 0x0C, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0x80, 0x0F,
  0xF0, 0x08, 0x0C, 0x18, 0x06, 0x18, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x03, 0x60, 0x03, 0x60, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x60, 0xFF, 0x80, 0x0F, 0xFF, 0x84,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC2, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC2, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xF8, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x06, 0x10, 0x02, 0x20, 0x02,
  0x20, 0x01, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x81, 0xFC, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x08, 0xC0, 0x18, 0x40, 0x28, 0x30, 0x48, 0x1F, 0x98,
  0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x31, 0x00, 0x10, 0x80,
  0x08, 0xC0, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x87,
  0xFF, 0xC6, 0x00, 0x23, 0x00, 0x11, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x04,
  0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x20, 0x1F, 0xFF, 0x80, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x80, 0x10, 0xC0, 0x10, 0x40, 0x20, 0x20, 0xC0, 0x1F, 0x80,
  0x08, 0x00, 0x61, 0x00, 0x30, 0x60, 0x0C, 0x08, 0x03, 0x01, 0x00, 0xC0,
  0x20, 0x30, 0x04, 0x0C, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x04, 0x30, 0x00,
  0x8E, 0x00, 0x12, 0x40, 0x02, 0x8C, 0x00, 0x60, 0x80, 0x18, 0x18, 0x02,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x60, 0x20, 0x04, 0x0C,
  0x00, 0xC1, 0x00, 0x08, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0xFF, 0xE0, 0x0C, 0x00, 0x61,
  0x80, 0x18, 0x30, 0x07, 0x0D, 0x00, 0xA1, 0x20, 0x24, 0x24, 0x04, 0x84,
  0x81, 0x20, 0x88, 0x64, 0x11, 0x08, 0x86, 0x22, 0x10, 0x84, 0x42, 0x10,
  0x50, 0x42, 0x0E, 0x10, 0x41, 0x82, 0x08, 0x20, 0x43, 0x00, 0x08, 0x40,
  0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80,
  0x04, 0x20, 0x00, 0x80, 0x18, 0x00, 0x8A, 0x00, 0x45, 0x00, 0x22, 0x80,
  0x31, 0x20, 0x10, 0x90, 0x08, 0xC8, 0x04, 0x46, 0x02, 0x21, 0x01, 0x10,
  0x81, 0x88, 0x60, 0x84, 0x10, 0x46, 0x08, 0x22, 0x06, 0x11, 0x01, 0x08,
  0x80, 0x8C, 0x40, 0x64, 0x20, 0x12, 0x30, 0x09, 0x10, 0x06, 0x88, 0x01,
  0x44, 0x00, 0xE2, 0x00, 0x60, 0x01, 0xF8, 0x06, 0x04, 0x0C, 0x02, 0x08,
  0x03, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x60, 0x10, 0x30,
  0x60, 0x0F, 0xC0, 0x0F, 0xFC, 0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x31,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x30, 0x01, 0x98, 0x00,
  0x88, 0x00, 0xC4, 0x00, 0xC3, 0xFF, 0x81, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x06, 0x04, 0x0C, 0x02, 0x08, 0x03,
  0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60,
  0x0F, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x00, 0x82, 0x00, 0xCC, 0x00, 0x58,
  0x00, 0x30, 0x0F, 0xFC, 0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x31, 0x00,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x30, 0x01, 0x98, 0x00, 0x88,
  0x00, 0xC4, 0x00, 0xC3, 0xFF, 0x81, 0x04, 0x01, 0x81, 0x00, 0xC0, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x04, 0x08, 0x02, 0x0C, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x30, 0x01, 0xFC, 0x01, 0x80, 0xC0, 0xC0, 0x08, 0x60, 0x01,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x33, 0x00, 0x08,
  0x60, 0x04, 0x0E, 0x06, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x01, 0x20, 0x01, 0x20, 0x03, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0xC0,
  0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x10, 0xC0, 0x30, 0x60, 0x60, 0x3F, 0x80, 0x80, 0x01, 0xC0,
  0x01, 0xB0, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20,
  0x80, 0x10, 0x60, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x04,
  0x01, 0x02, 0x00, 0x82, 0x00, 0x61, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0xC0, 0x02, 0x40, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x08, 0x83, 0x06, 0x60, 0xC1, 0x18, 0x50, 0x44, 0x14, 0x11, 0x09,
  0x08, 0x42, 0x62, 0x11, 0x88, 0x84, 0x42, 0x21, 0x10, 0x90, 0x48, 0x24,
  0x12, 0x09, 0x05, 0x02, 0x41, 0x40, 0xA0, 0x60, 0x28, 0x18, 0x0A, 0x0E,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x20, 0x01, 0x01, 0x80, 0x18, 0x04, 0x01,
  0x80, 0x30, 0x18, 0x00, 0x80, 0x80, 0x06, 0x08, 0x00, 0x10, 0x80, 0x00,
  0xCC, 0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x05, 0x00,
  0x00, 0x48, 0x00, 0x06, 0x20, 0x00, 0x61, 0x00, 0x06, 0x04, 0x00, 0x20,
  0x20, 0x02, 0x01, 0x80, 0x20, 0x04, 0x03, 0x00, 0x30, 0x30, 0x00, 0x83,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x26, 0x00, 0x10, 0x80, 0x0C,
  0x30, 0x06, 0x04, 0x03, 0x01, 0x80, 0x80, 0x20, 0x40, 0x08, 0x30, 0x01,
  0x18, 0x00, 0x4C, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x7F, 0xC0, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x07, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x7F,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x80, 0x11, 0x00, 0x61, 0x00, 0x82,
  0x02, 0x02, 0x08, 0x04, 0x30, 0x0C, 0x40, 0x09, 0x00, 0x14, 0x00, 0x18,
  0x00, 0x20, 0xFF, 0xFF, 0x8C, 0x46, 0x23, 0x03, 0xE2, 0x18, 0x24, 0x40,
  0x29, 0x00, 0x32, 0x00, 0x68, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x05,
  0x00, 0x0A, 0x00, 0x34, 0x00, 0x4C, 0x00, 0x88, 0x03, 0x10, 0x0A, 0x18,
  0x64, 0x1F, 0x1E, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x11, 0xF0, 0x12, 0x0C, 0x14, 0x06, 0x18,
  0x02, 0x10, 0x02, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x40, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x60, 0x18, 0x58,
  0x30, 0xC7, 0xC0, 0x07, 0xE0, 0x60, 0xC3, 0x00, 0x98, 0x02, 0x40, 0x07,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x1A, 0x00, 0x44, 0x02, 0x08, 0x30, 0x1F, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x07, 0xC4, 0x0C, 0x12, 0x08, 0x05, 0x08, 0x01, 0x84, 0x00, 0xC4, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x06, 0x20,
  0x02, 0x18, 0x01, 0x04, 0x01, 0x82, 0x01, 0x40, 0xC3, 0x20, 0x3F, 0x30,
  0x03, 0xE0, 0x30, 0x61, 0x00, 0xC8, 0x01, 0x40, 0x05, 0x00, 0x28, 0x01,
  0xA0, 0x78, 0xFE, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02, 0x80, 0x0B, 0x00,
  0x44, 0x03, 0x0C, 0x18, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x60,
  0x80, 0x03, 0x18, 0x00, 0x09, 0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xF1, 0x06, 0x0D, 0x08, 0x05, 0x10, 0x03, 0x10, 0x03, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04,
  0x60, 0x04, 0x20, 0x0C, 0x20, 0x14, 0x18, 0x64, 0x0F, 0x8C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x40, 0x30, 0xE0, 0x60, 0x1F, 0x80,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x78, 0x36, 0x18, 0xA0, 0x23, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0xB0, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x10, 0x40, 0x83, 0x0C, 0x08, 0x40, 0x26, 0x00, 0xA0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x80, 0xC1, 0x02, 0x03, 0x08, 0x06,
  0x20, 0x0C, 0x80, 0x1A, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x21, 0xF0,
  0x13, 0x0C, 0x0A, 0x03, 0x06, 0x00, 0x82, 0x00, 0x43, 0x00, 0x41, 0x00,
  0x60, 0x80, 0x60, 0x40, 0xC0, 0x23, 0x80, 0x11, 0x00, 0x18, 0x40, 0x28,
  0x30, 0x24, 0x08, 0x22, 0x06, 0x61, 0x01, 0x61, 0x80, 0x60, 0xFF, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x84, 0x0E, 0x20, 0x81, 0x18, 0x09, 0x80, 0xB0, 0x07,
  0x00, 0x13, 0x87, 0x85, 0x12, 0x21, 0x85, 0x0C, 0xC1, 0x81, 0x30, 0x60,
  0xC8, 0x10, 0x22, 0x04, 0x08, 0x81, 0x02, 0x20, 0x40, 0x98, 0x10, 0x24,
  0x08, 0x19, 0x02, 0x04, 0x40, 0x81, 0x10, 0x20, 0x44, 0x08, 0x13, 0x02,
  0x04, 0x81, 0x03, 0x00, 0x31, 0xE0, 0x98, 0x62, 0x80, 0x8C, 0x03, 0x30,
  0x0C, 0x80, 0x36, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90,
  0x06, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x30, 0x07, 0xE0,
  0x60, 0xC3, 0x00, 0x98, 0x01, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x03,
  0x18, 0x18, 0x1F, 0x80, 0x08, 0xF8, 0x04, 0x83, 0x02, 0x80, 0xC1, 0x80,
  0x20, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x10, 0x01, 0x08,
  0x00, 0x84, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x30,
  0x58, 0x30, 0x23, 0xE0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x03, 0xE2, 0x18, 0x24, 0x40,
  0x29, 0x00, 0x32, 0x00, 0x68, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x05,
  0x00, 0x0A, 0x00, 0x34, 0x00, 0x4C, 0x00, 0x88, 0x03, 0x10, 0x0A, 0x18,
  0x64, 0x1F, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0xFE, 0x7F, 0x06, 0x80, 0x05, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x09, 0x80, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x50, 0x00, 0xB0, 0x03, 0x18, 0x0C, 0x0F, 0xE0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xFF, 0x81,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x18, 0x20, 0xC0, 0x42, 0x01,
  0x98, 0x02, 0xC0, 0x07, 0x00, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x03, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x6C,
  0x01, 0x20, 0x04, 0x80, 0x72, 0x01, 0x44, 0x0B, 0x18, 0x4C, 0x3E, 0x20,
  0xF8, 0x04, 0x10, 0x08, 0x60, 0x10, 0x80, 0x31, 0x00, 0x62, 0x00, 0xC4,
  0x01, 0x08, 0x02, 0x10, 0x04, 0x60, 0x10, 0x80, 0x21, 0x00, 0x82, 0x03,
  0x04, 0x0C, 0x08, 0x30, 0x11, 0x80, 0x3C, 0x00, 0x20, 0x41, 0x10, 0x20,
  0x88, 0x10, 0x44, 0x08, 0x32, 0x04, 0x0B, 0x04, 0x05, 0x02, 0x02, 0x81,
  0x01, 0x40, 0x81, 0x20, 0x40, 0x90, 0x60, 0x58, 0x20, 0x28, 0x10, 0x34,
  0x08, 0x12, 0x0C, 0x19, 0x89, 0x18, 0x78, 0x70, 0x00, 0x07, 0x07, 0x87,
  0x62, 0x33, 0x09, 0x05, 0x02, 0x81, 0x00, 0xA0, 0x40, 0x10, 0x10, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x02, 0x02, 0x00,
  0x81, 0x40, 0x20, 0x90, 0x28, 0x24, 0x33, 0x11, 0xB0, 0x78, 0x38, 0x00,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x03, 0x18, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x30, 0x04, 0x20, 0x04,
  0x20, 0x0C, 0x20, 0x14, 0x10, 0x2C, 0x18, 0x6C, 0x0F, 0x88, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x80, 0x30, 0x60, 0xE0, 0x1F, 0x80,
  0x0F, 0xC1, 0x10, 0x79, 0x20, 0x0F, 0x20, 0x06, 0x20, 0x08, 0x20, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x08, 0x18, 0x08,
  0x30, 0x04, 0x40, 0x04, 0xFC, 0x04, 0x8F, 0xE4, 0x80, 0xFC, 0x01, 0xFE,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x60,
  0x3F, 0x00, 0x03, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x07, 0xF8, 0x00, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x86,
  0x10, 0x41, 0x04, 0x10, 0xC2, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x07, 0xC0, 0xE0, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x03, 0xF8, 0x00, 0x1E,
  0x01, 0x11, 0x80, 0x90, 0x40, 0x48, 0x10, 0x48, 0x04, 0x44, 0x01, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 23, 20, 7, -23 },
  { 19, 8, 8, 20, 8, -24 },
  { 27, 19, 23, 20, 1, -23 },
  { 82, 18, 29, 20, 1, -26 },
  { 148, 22, 23, 20, -1, -23 },
  { 212, 19, 23, 20, 0, -23 },
  { 267, 2, 8, 20, 11, -24 },
  { 269, 10, 30, 20, 8, -25 },
  { 307, 11, 30, 20, 2, -25 },
  { 349, 17, 16, 20, 2, -18 },
  { 383, 16, 17, 20, 2, -19 },
  { 417, 5, 8, 20, 5, -3 },
  { 422, 9, 1, 20, 6, -11 },
  { 424, 3, 3, 20, 7, -3 },
  { 426, 18, 30, 20, 1, -25 },
  { 494, 16, 23, 20, 2, -23 },
  { 540, 15, 23, 20, 2, -23 },
  { 584, 17, 23, 20, 1, -23 },
  { 633, 17, 23, 20, 1, -23 },
  { 682, 17, 23, 20, 1, -23 },
  { 731, 16, 23, 20, 2, -23 },
  { 777, 15, 23, 20, 2, -23 },
  { 821, 15, 23, 20, 4, -23 },
  { 865, 16, 23, 20, 2, -23 },
  { 911, 15, 23, 20, 3, -23 },
  { 955, 6, 18, 20, 7, -18 },
  { 969, 8, 23, 20, 5, -18 },
  { 992, 16, 18, 20, 3, -19 },
  { 1028, 17, 7, 20, 2, -14 },
  { 1043, 15, 18, 20, 2, -19 },
  { 1077, 13, 23, 20, 5, -23 },
  { 1115, 15, 27, 20, 3, -23 },
  { 1166, 17, 23, 20, 0, -23 },
  { 1215, 16, 23, 20, 2, -23 },
  { 1261, 16, 23, 20, 3, -23 },
  { 1307, 16, 23, 20, 2, -23 },
  { 1353, 17, 23, 20, 2, -23 },
  { 1402, 18, 23, 20, 2, -23 },
  { 1454, 16, 23, 20, 3, -23 },
  { 1500, 17, 23, 20, 2, -23 },
  { 1549, 17, 23, 20, 2, -23 },
  { 1598, 16, 23, 20, 2, -23 },
  { 1644, 19, 23, 20, 2, -23 },
  { 1699, 13, 23, 20, 3, -23 },
  { 1737, 19, 23, 20, 1, -23 },
  { 1792, 17, 23, 20, 2, -23 },
  { 1841, 16, 23, 20, 2, -23 },
  { 1887, 17, 23, 20, 2, -23 },
  { 1936, 16, 29, 20, 2, -23 },
  { 1994, 17, 23, 20, 2, -23 },
  { 2043, 18, 23, 20, 1, -23 },
  { 2095, 18, 23, 20, 3, -23 },
  { 2147, 16, 23, 20, 3, -23 },
  { 2193, 17, 23, 20, 4, -23 },
  { 2242, 18, 23, 20, 2, -23 },
  { 2294, 21, 23, 20, 0, -23 },
  { 2355, 18, 23, 20, 3, -23 },
  { 2407, 20, 23, 20, 0, -23 },
  { 2465, 13, 30, 20, 6, -25 },
  { 2514, 8, 30, 20, 6, -25 },
  { 2544, 13, 30, 20, 1, -25 },
  { 2593, 15, 13, 20, 3, -23 },
  { 2618, 16, 1, 20, 0, 4 },
  { 2620, 4, 6, 20, 8, -26 },
  { 2623, 15, 17, 20, 2, -17 },
  { 2655, 16, 24, 20, 2, -24 },
  { 2703, 14, 17, 20, 3, -17 },
  { 2733, 17, 24, 20, 2, -24 },
  { 2784, 14, 17, 20, 3, -17 },
  { 2814, 20, 31, 20, 0, -24 },
  { 2892, 16, 24, 20, 1, -17 },
  { 2940, 14, 24, 20, 3, -24 },
  { 2982, 14, 24, 20, 3, -24 },
  { 3024, 14, 31, 20, 3, -24 },
  { 3079, 17, 24, 20, 2, -24 },
  { 3130, 13, 24, 20, 4, -24 },
  { 3169, 18, 17, 20, 1, -17 },
  { 3208, 14, 17, 20, 3, -17 },
  { 3238, 14, 17, 20, 3, -17 },
  { 3268, 17, 24, 20, 1, -17 },
  { 3319, 15, 24, 20, 2, -17 },
  { 3364, 16, 17, 20, 4, -17 },
  { 3398, 15, 17, 20, 2, -17 },
  { 3430, 15, 23, 20, 3, -23 },
  { 3474, 14, 17, 20, 3, -17 },
  { 3504, 15, 17, 20, 3, -17 },
  { 3536, 17, 17, 20, 2, -17 },
  { 3573, 18, 17, 20, 1, -17 },
  { 3612, 16, 24, 20, 1, -17 },
  { 3660, 16, 17, 20, 2, -17 },
  { 3694, 15, 30, 20, 4, -25 },
  { 3751, 6, 30, 20, 7, -25 },
  { 3774, 14, 30, 20, 2, -25 },
  { 3827, 17, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC33PT7B_H_
