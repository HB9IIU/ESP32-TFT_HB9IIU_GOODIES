#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC52PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x3E, 0x0E, 0x00, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x36,
  0x06, 0xC0, 0xD8, 0x33, 0x06, 0x60, 0xCC, 0x1B, 0x03, 0x60, 0x6C, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xC4, 0x06, 0x03, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x80, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x0C, 0x78,
  0x03, 0xC0, 0xC1, 0xC0, 0x30, 0x08, 0x0E, 0x06, 0x00, 0x80, 0x70, 0x60,
  0x18, 0x04, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x82, 0x00, 0x00, 0x3E, 0x20,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x63, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x40, 0x70, 0x00, 0x04,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01,
  0x80, 0x30, 0xC0, 0x18, 0x03, 0x0E, 0x01, 0x80, 0x60, 0x70, 0x10, 0x0E,
  0x03, 0x81, 0x01, 0xC0, 0x1F, 0x10, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0C, 0x03, 0x83, 0x80, 0x03, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x06, 0x02, 0x00, 0x18, 0x00, 0x80, 0xC0, 0x03, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x06, 0x0C, 0x00, 0x0C, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x70,
  0x60, 0x00, 0x1C, 0x1C, 0x18, 0x00, 0x01, 0xFF, 0x06, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x3F, 0xE0, 0x00, 0x06, 0x0E, 0x0E,
  0x00, 0x01, 0x83, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x08, 0x18,
  0x01, 0x80, 0x03, 0x02, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x70, 0x0C, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0x7F, 0xBC, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x02, 0x00, 0x03, 0x80, 0x2C,
  0x00, 0x0B, 0x01, 0xF0, 0x00, 0x2C, 0x0C, 0xC0, 0x01, 0x18, 0x33, 0x80,
  0x0C, 0x71, 0x87, 0x00, 0x60, 0xC6, 0x0E, 0x07, 0x81, 0xB0, 0x1F, 0xF8,
  0x07, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x33, 0x66, 0x66, 0x66, 0xCC, 0xCC,
  0xC0, 0x00, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x1B, 0xF0, 0x10, 0x1F, 0x87, 0xC6,
  0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x30, 0x04, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0xD8, 0x07, 0x80, 0x6C, 0x01, 0xC0, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x78, 0x60, 0x00, 0xF0,
  0x40, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xC0, 0x0F, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0x80, 0xF0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x80, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x01, 0x80, 0x02, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x03,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC3, 0xF8, 0x00,
  0x33, 0xFF, 0xC0, 0x0B, 0xC0, 0x78, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x01, 0xE0, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x0F, 0xE0, 0x0C, 0xFF, 0xF0, 0x33, 0x80,
  0xF0, 0x6C, 0x00, 0x71, 0xB0, 0x00, 0x73, 0x80, 0x00, 0x67, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x70, 0x60,
  0x01, 0xC0, 0x70, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0x01, 0xC0, 0x70, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0xB1, 0xC0, 0x07, 0x41, 0xE0, 0x39, 0x81, 0xFF, 0xE2, 0x00,
  0xFE, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x7C,
  0x1C, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x04,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0E, 0x03, 0xC1, 0x80,
  0x0E, 0x30, 0x00, 0x76, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x06, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x18, 0x03, 0xE3,
  0x18, 0x0F, 0xF3, 0x10, 0x1C, 0x1B, 0x30, 0x38, 0x0B, 0x30, 0x30, 0x06,
  0x30, 0x60, 0x06, 0x20, 0x60, 0x06, 0x60, 0x40, 0x06, 0x60, 0xC0, 0x06,
  0x60, 0xC0, 0x06, 0x60, 0xC0, 0x04, 0x60, 0xC0, 0x04, 0x40, 0x80, 0x0C,
  0xC0, 0x80, 0x0C, 0xC0, 0x80, 0x0C, 0xC0, 0x80, 0x1C, 0xC0, 0xC0, 0x18,
  0xC0, 0xC0, 0x28, 0xC0, 0xE0, 0x58, 0xC0, 0x7B, 0xD8, 0xC0, 0x3F, 0x98,
  0xC0, 0x04, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x10, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x38,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0x00,
  0x07, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x78, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF0,
  0x38, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x38, 0x02,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x7F,
  0xE2, 0x00, 0x7F, 0xF3, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x84, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x28, 0x18, 0x00, 0x2C, 0x0E, 0x00, 0x36, 0x03, 0xC0, 0x73, 0x00,
  0x7F, 0xE1, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xC0, 0xE0, 0x01, 0x80, 0x60, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x20, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00, 0xC7, 0x60, 0x00, 0x06, 0x71,
  0x80, 0x00, 0x37, 0x0C, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x0F, 0x01, 0x80,
  0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x14, 0x0D, 0x00, 0x01, 0x60, 0x6C, 0x00, 0x1B, 0x03, 0x60, 0x00,
  0x98, 0x19, 0x00, 0x0C, 0xC0, 0xCC, 0x00, 0xC6, 0x04, 0x60, 0x04, 0x20,
  0x63, 0x00, 0x63, 0x03, 0x08, 0x02, 0x18, 0x18, 0x60, 0x30, 0xC0, 0xC3,
  0x03, 0x06, 0x06, 0x08, 0x10, 0x30, 0x20, 0x61, 0x81, 0x03, 0x03, 0x18,
  0x18, 0x18, 0x18, 0xC0, 0xC0, 0xC0, 0x4C, 0x06, 0x06, 0x03, 0xC0, 0x30,
  0x30, 0x1E, 0x01, 0x81, 0x00, 0x60, 0x08, 0x18, 0x02, 0x00, 0xC0, 0xC0,
  0x10, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0xF0, 0x00, 0x0C, 0x1E, 0x00, 0x01,
  0x83, 0x60, 0x00, 0x30, 0x6C, 0x00, 0x04, 0x0D, 0x80, 0x01, 0x81, 0x18,
  0x00, 0x30, 0x63, 0x00, 0x06, 0x0C, 0x60, 0x00, 0xC1, 0x86, 0x00, 0x18,
  0x30, 0xC0, 0x02, 0x06, 0x18, 0x00, 0xC0, 0x81, 0x80, 0x18, 0x30, 0x30,
  0x03, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x60, 0x0C, 0x18, 0x0C, 0x01, 0x03,
  0x01, 0x80, 0x60, 0x40, 0x10, 0x0C, 0x18, 0x03, 0x01, 0x83, 0x00, 0x60,
  0x30, 0x60, 0x04, 0x06, 0x0C, 0x00, 0xC0, 0x81, 0x80, 0x18, 0x30, 0x20,
  0x01, 0x06, 0x0C, 0x00, 0x30, 0xC1, 0x80, 0x06, 0x18, 0x30, 0x00, 0x43,
  0x06, 0x00, 0x0C, 0x40, 0xC0, 0x01, 0x98, 0x10, 0x00, 0x33, 0x06, 0x00,
  0x03, 0x60, 0xC0, 0x00, 0x6C, 0x18, 0x00, 0x0D, 0x83, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3C,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0C, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0C, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x40, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x10,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x08, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20,
  0x0E, 0x00, 0xC2, 0x00, 0xE0, 0x18, 0x20, 0x0E, 0x01, 0x86, 0x01, 0xE0,
  0x18, 0x60, 0x16, 0x01, 0x06, 0x03, 0x20, 0x30, 0x60, 0x32, 0x03, 0x06,
  0x06, 0x30, 0x30, 0x60, 0x63, 0x02, 0x06, 0x0C, 0x30, 0x60, 0x60, 0xC3,
  0x06, 0x06, 0x08, 0x30, 0x60, 0x61, 0x83, 0x04, 0x04, 0x10, 0x30, 0xC0,
  0x43, 0x01, 0x0C, 0x04, 0x30, 0x10, 0xC0, 0x46, 0x01, 0x08, 0x0C, 0x60,
  0x19, 0x80, 0xCC, 0x01, 0x98, 0x0C, 0xC0, 0x19, 0x80, 0xC8, 0x01, 0x90,
  0x0D, 0x80, 0x1B, 0x00, 0xD0, 0x01, 0xB0, 0x0F, 0x00, 0x0B, 0x00, 0xF0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0x98, 0x00, 0x01, 0x84, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x43, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x04, 0x00, 0x3F, 0x03, 0x00, 0xFF,
  0xE3, 0x03, 0xC0, 0x73, 0x07, 0x00, 0x13, 0x0E, 0x00, 0x0B, 0x0C, 0x00,
  0x0A, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x50, 0x30, 0x00, 0x90, 0x38, 0x01, 0xB0, 0x1E, 0x07,
  0x3F, 0x0F, 0xFE, 0x1F, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x0F, 0xC0, 0x0C, 0x3F, 0xF0, 0x0C, 0xE0,
  0x78, 0x0D, 0x80, 0x1C, 0x0D, 0x00, 0x0E, 0x1A, 0x00, 0x06, 0x1C, 0x00,
  0x06, 0x1C, 0x00, 0x02, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x50, 0x00,
  0x38, 0xD0, 0x00, 0x70, 0xC8, 0x00, 0xE0, 0xCE, 0x03, 0xC0, 0xC3, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x0F,
  0x01, 0xC0, 0x0E, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x02, 0x40,
  0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x38, 0x01,
  0xC0, 0x78, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x04,
  0x00, 0xFF, 0xE3, 0x00, 0xF0, 0x1C, 0xC0, 0x70, 0x01, 0xB0, 0x38, 0x00,
  0x2C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x06, 0x04, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x16, 0x03,
  0x00, 0x0D, 0x00, 0xE0, 0x06, 0x40, 0x1E, 0x07, 0x30, 0x03, 0xFF, 0x8C,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0xC1, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x98, 0x00, 0x02, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE2,
  0x00, 0x0F, 0x84, 0x03, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x46, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x38, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0,
  0x80, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC1, 0x80, 0x3F, 0xF8, 0xC0, 0x78, 0x0E, 0x60, 0x70, 0x01,
  0xB0, 0x70, 0x00, 0x58, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x40,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x08, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x01, 0x60, 0x60, 0x01, 0xB0,
  0x38, 0x01, 0x90, 0x0F, 0x03, 0x98, 0x03, 0xFF, 0x8C, 0x00, 0x7F, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x07, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x83, 0xF0, 0x0C, 0x3F, 0xF0, 0x31,
  0xC1, 0xE0, 0xCC, 0x01, 0x83, 0x40, 0x03, 0x0F, 0x00, 0x0C, 0x38, 0x00,
  0x31, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x10,
  0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x20, 0x18, 0x03, 0xC0, 0x60, 0x1C,
  0x01, 0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x70, 0x00, 0xC7, 0x00, 0x03,
  0x38, 0x00, 0x0B, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x10, 0x01, 0x80,
  0xE0, 0x06, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x40, 0x03, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x0C, 0x3F, 0xF0, 0x03, 0x1C,
  0x0E, 0x00, 0xCC, 0x00, 0xC0, 0x34, 0x00, 0x30, 0x1A, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x03,
  0x80, 0x0C, 0x07, 0x80, 0x03, 0x0F, 0x80, 0x00, 0x81, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x08, 0x00, 0x26, 0x03, 0x00, 0x1D, 0x80, 0x60, 0x0E,
  0x60, 0x18, 0x07, 0x10, 0x03, 0x03, 0x8C, 0x00, 0xC1, 0xC3, 0x00, 0x18,
  0xE0, 0xC0, 0x07, 0x60, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x30,
  0x60, 0x07, 0x06, 0x01, 0xE0, 0x60, 0x38, 0x06, 0x07, 0x00, 0x41, 0xC0,
  0x0C, 0x38, 0x00, 0xCE, 0x00, 0x0D, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x7C, 0x0F, 0x81, 0x9F, 0xC3, 0xF8, 0x36, 0x1C, 0xC3, 0x87,
  0x81, 0xB0, 0x30, 0xA0, 0x1C, 0x02, 0x38, 0x03, 0x00, 0x47, 0x00, 0xE0,
  0x08, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x40,
  0x0C, 0x01, 0x98, 0x01, 0x00, 0x33, 0x00, 0x20, 0x04, 0x60, 0x0C, 0x00,
  0x8C, 0x01, 0x80, 0x31, 0x80, 0x30, 0x06, 0x20, 0x06, 0x00, 0xCC, 0x00,
  0x80, 0x19, 0x80, 0x30, 0x02, 0x30, 0x06, 0x00, 0xC6, 0x00, 0xC0, 0x18,
  0x80, 0x18, 0x03, 0x10, 0x03, 0x00, 0x66, 0x00, 0x40, 0x08, 0xC0, 0x18,
  0x01, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x0F, 0xC0,
  0x30, 0xFF, 0xC0, 0xC7, 0x07, 0x83, 0x30, 0x06, 0x0D, 0x00, 0x0C, 0x3C,
  0x00, 0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x23,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00,
  0x01, 0x98, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x38, 0x01, 0xC0,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x88, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x30, 0x38, 0x00, 0xC0,
  0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x03, 0xF0,
  0x00, 0xC3, 0xFF, 0x00, 0x33, 0x81, 0xE0, 0x0D, 0x80, 0x1C, 0x02, 0x40,
  0x03, 0x81, 0xA0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x02, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x40, 0x00, 0xE0,
  0xD0, 0x00, 0x70, 0x32, 0x00, 0x38, 0x0C, 0xE0, 0x3C, 0x03, 0x0F, 0xFE,
  0x00, 0xC0, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x81, 0x00, 0xFF, 0xE3, 0x03, 0xC0, 0x73, 0x07, 0x00, 0x1B, 0x0E, 0x00,
  0x0B, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x58, 0x30, 0x00, 0xD0, 0x38, 0x01,
  0xB0, 0x1E, 0x07, 0x30, 0x0F, 0xFE, 0x30, 0x03, 0xF8, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xFF, 0xC0, 0x19, 0xC0, 0x00, 0x09,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3E, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x38, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x01, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x08, 0x03, 0x80,
  0x0C, 0x07, 0x80, 0x06, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x9E, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80,
  0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x01, 0x63, 0x00, 0x05, 0x0C, 0x00,
  0x2C, 0x38, 0x00, 0xB0, 0x60, 0x04, 0xC1, 0xE0, 0x63, 0x03, 0xFF, 0x0C,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x06, 0xFF, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x04, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0xE0, 0x08, 0x01, 0xC0, 0x08, 0x07, 0x80,
  0x18, 0x0E, 0x00, 0x18, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x0C, 0x01, 0x01, 0x82, 0x00, 0x40, 0x21, 0x80, 0x30, 0x0C, 0x60, 0x0C,
  0x03, 0x18, 0x03, 0x00, 0xC6, 0x00, 0xC0, 0x11, 0x80, 0x20, 0x04, 0x40,
  0x08, 0x01, 0x10, 0x06, 0x00, 0x4C, 0x01, 0x80, 0x13, 0x00, 0x60, 0x04,
  0xC0, 0x18, 0x01, 0x30, 0x04, 0x00, 0x48, 0x01, 0x00, 0x32, 0x00, 0xC0,
  0x0D, 0x80, 0x30, 0x03, 0x60, 0x0C, 0x00, 0xD8, 0x03, 0x00, 0x36, 0x00,
  0x80, 0x19, 0x00, 0x60, 0x06, 0x40, 0x18, 0x01, 0xB0, 0x06, 0x00, 0xCC,
  0x02, 0x80, 0x33, 0x00, 0xA0, 0x18, 0x60, 0x4C, 0x0E, 0x1C, 0x73, 0x87,
  0x03, 0xF8, 0x7F, 0x80, 0x7C, 0x0F, 0x80, 0x00, 0x38, 0x03, 0xE0, 0x07,
  0xE0, 0x7F, 0x80, 0xF3, 0x07, 0x0E, 0x0E, 0x0C, 0x70, 0x31, 0xC0, 0x63,
  0x01, 0xB8, 0x03, 0x30, 0x04, 0x00, 0x09, 0x00, 0x20, 0x00, 0x58, 0x01,
  0x00, 0x03, 0x80, 0x08, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x01, 0x80, 0x14, 0x00, 0x0C, 0x00, 0xB0, 0x00, 0x60,
  0x0D, 0x80, 0x13, 0x00, 0x4C, 0x01, 0xD8, 0x06, 0x20, 0x38, 0xC0, 0x61,
  0x87, 0x03, 0x8E, 0x0E, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40,
  0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x81, 0x80, 0x02, 0xC0, 0xC0, 0x01, 0x40, 0x70, 0x01,
  0x60, 0x18, 0x01, 0xB0, 0x0F, 0x03, 0x98, 0x03, 0xFF, 0x0C, 0x00, 0x7F,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x60, 0x38,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x01, 0x83, 0xFF, 0xE0, 0xC3, 0x81, 0xFE, 0x61, 0x80, 0x0F,
  0xF1, 0x80, 0x00, 0xF8, 0xC0, 0x00, 0x38, 0x40, 0x00, 0x38, 0x20, 0x00,
  0x30, 0x10, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x02, 0x00,
  0xC0, 0x01, 0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x11,
  0xFF, 0x00, 0x08, 0xC3, 0xF8, 0x06, 0x60, 0x1F, 0xE3, 0x30, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x43, 0xF8, 0x00, 0x31, 0xC7, 0x00, 0x0C, 0xE0, 0x60, 0x06, 0x30, 0x1C,
  0x01, 0x98, 0x03, 0x80, 0xC6, 0x00, 0x60, 0x73, 0x00, 0x0E, 0x38, 0xC0,
  0x01, 0xFC, 0x20, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 36, 31, 11, -36 },
  { 42, 11, 13, 31, 13, -38 },
  { 60, 31, 36, 31, 1, -36 },
  { 200, 28, 48, 31, 2, -42 },
  { 368, 35, 38, 31, -1, -37 },
  { 535, 30, 38, 31, 1, -37 },
  { 678, 4, 13, 31, 17, -38 },
  { 685, 17, 47, 31, 12, -40 },
  { 785, 17, 47, 31, 3, -40 },
  { 885, 27, 26, 31, 3, -29 },
  { 973, 25, 26, 31, 4, -29 },
  { 1055, 8, 14, 31, 8, -5 },
  { 1069, 14, 2, 31, 9, -17 },
  { 1073, 5, 4, 31, 11, -4 },
  { 1076, 28, 47, 31, 2, -40 },
  { 1241, 25, 38, 31, 4, -37 },
  { 1360, 24, 36, 31, 2, -36 },
  { 1468, 26, 37, 31, 2, -37 },
  { 1589, 26, 38, 31, 2, -37 },
  { 1713, 27, 36, 31, 1, -36 },
  { 1835, 26, 37, 31, 3, -36 },
  { 1956, 23, 37, 31, 4, -36 },
  { 2063, 25, 36, 31, 6, -36 },
  { 2176, 26, 38, 31, 3, -37 },
  { 2300, 23, 37, 31, 5, -37 },
  { 2407, 9, 27, 31, 11, -27 },
  { 2438, 12, 36, 31, 8, -27 },
  { 2492, 24, 28, 31, 5, -30 },
  { 2576, 26, 12, 31, 3, -22 },
  { 2615, 25, 28, 31, 2, -30 },
  { 2703, 20, 37, 31, 8, -37 },
  { 2796, 24, 43, 31, 4, -37 },
  { 2925, 27, 36, 31, 0, -36 },
  { 3047, 25, 36, 31, 3, -36 },
  { 3160, 24, 38, 31, 5, -37 },
  { 3274, 26, 36, 31, 3, -36 },
  { 3391, 28, 36, 31, 3, -36 },
  { 3517, 28, 36, 31, 3, -36 },
  { 3643, 25, 38, 31, 4, -37 },
  { 3762, 27, 36, 31, 3, -36 },
  { 3884, 28, 36, 31, 2, -36 },
  { 4010, 24, 37, 31, 4, -36 },
  { 4121, 29, 36, 31, 3, -36 },
  { 4252, 21, 36, 31, 5, -36 },
  { 4347, 29, 36, 31, 2, -36 },
  { 4478, 27, 36, 31, 3, -36 },
  { 4600, 25, 38, 31, 4, -37 },
  { 4719, 27, 36, 31, 3, -36 },
  { 4841, 25, 46, 31, 4, -37 },
  { 4985, 27, 36, 31, 3, -36 },
  { 5107, 28, 38, 31, 2, -37 },
  { 5240, 28, 36, 31, 5, -36 },
  { 5366, 26, 37, 31, 4, -36 },
  { 5487, 26, 36, 31, 6, -36 },
  { 5604, 28, 36, 31, 4, -36 },
  { 5730, 32, 36, 31, 0, -36 },
  { 5874, 29, 36, 31, 5, -36 },
  { 6005, 31, 36, 31, 0, -36 },
  { 6145, 20, 47, 31, 10, -40 },
  { 6263, 12, 47, 31, 10, -40 },
  { 6334, 21, 47, 31, 1, -40 },
  { 6458, 25, 20, 31, 4, -36 },
  { 6521, 25, 2, 31, 0, 6 },
  { 6528, 6, 9, 31, 12, -40 },
  { 6535, 24, 28, 31, 3, -27 },
  { 6619, 24, 39, 31, 4, -38 },
  { 6736, 22, 28, 31, 4, -27 },
  { 6813, 26, 39, 31, 3, -38 },
  { 6940, 23, 28, 31, 4, -27 },
  { 7021, 33, 49, 31, -1, -38 },
  { 7224, 25, 38, 31, 2, -27 },
  { 7343, 22, 38, 31, 4, -38 },
  { 7448, 22, 40, 31, 5, -39 },
  { 7558, 22, 50, 31, 5, -39 },
  { 7696, 26, 39, 31, 4, -38 },
  { 7823, 20, 39, 31, 6, -38 },
  { 7921, 27, 27, 31, 2, -27 },
  { 8013, 22, 27, 31, 4, -27 },
  { 8088, 23, 28, 31, 4, -27 },
  { 8169, 26, 37, 31, 2, -27 },
  { 8290, 24, 37, 31, 3, -27 },
  { 8401, 25, 27, 31, 6, -27 },
  { 8486, 24, 28, 31, 3, -27 },
  { 8570, 25, 37, 31, 4, -36 },
  { 8686, 22, 28, 31, 5, -27 },
  { 8763, 24, 27, 31, 4, -27 },
  { 8844, 26, 28, 31, 3, -27 },
  { 8935, 29, 28, 31, 1, -27 },
  { 9037, 25, 38, 31, 2, -27 },
  { 9156, 25, 28, 31, 3, -27 },
  { 9244, 24, 47, 31, 6, -40 },
  { 9385, 10, 47, 31, 11, -40 },
  { 9444, 24, 47, 31, 2, -40 },
  { 9585, 26, 10, 31, 3, -21 },
};

const GFXfont IBMPlexMono_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC52PT7B_H_
