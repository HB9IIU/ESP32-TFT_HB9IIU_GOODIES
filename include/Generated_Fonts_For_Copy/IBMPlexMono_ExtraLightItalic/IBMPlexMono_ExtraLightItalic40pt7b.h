#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC40PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x87, 0x00, 0x21, 0xB0, 0xD8, 0x4C, 0x24, 0x12, 0x19, 0x0D, 0x86, 0xC2,
  0x61, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x30, 0x00,
  0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x20, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x1F, 0xC0, 0xFF, 0x20,
  0xC1, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x83, 0x00, 0x01,
  0x02, 0x00, 0x03, 0x02, 0x00, 0xFF, 0x07, 0xF8, 0x02, 0x04, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0x80, 0x06, 0x11, 0xC0, 0x20, 0x41, 0x81, 0x01, 0x03,
  0x0C, 0x0C, 0x08, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x08,
  0x08, 0x00, 0x20, 0x20, 0x00, 0xC1, 0x80, 0x01, 0x84, 0x00, 0x03, 0x90,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0x70, 0x00, 0x04, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x81, 0x80, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x30, 0x00,
  0x80, 0x80, 0x06, 0x02, 0x10, 0x10, 0x18, 0xE0, 0x40, 0xC0, 0xC1, 0x06,
  0x01, 0xC4, 0x70, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x60, 0x20, 0x80, 0x18,
  0x08, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x04,
  0x0C, 0x02, 0x00, 0x81, 0x00, 0x40, 0x10, 0x40, 0x08, 0x02, 0x18, 0x01,
  0x00, 0x86, 0x00, 0x10, 0x10, 0x80, 0x03, 0x0C, 0x20, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x63, 0x0C, 0x00, 0x18, 0xC0, 0xC0, 0x06, 0x10, 0x08, 0x00, 0x86, 0x01,
  0x00, 0x20, 0x80, 0x20, 0x0C, 0x10, 0x04, 0x03, 0x02, 0x00, 0x80, 0x40,
  0x40, 0x30, 0x10, 0x08, 0x04, 0x06, 0x01, 0x81, 0x81, 0x80, 0x18, 0x60,
  0x60, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x00, 0x40, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x80, 0x00, 0xC1, 0x00, 0x07, 0x46, 0x00, 0x18, 0x78,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x10, 0x00, 0x40, 0x18, 0x00, 0x40, 0x08,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x02, 0xC0, 0x05,
  0x03, 0x40, 0x05, 0x04, 0x60, 0x08, 0x84, 0x20, 0x18, 0xC8, 0x38, 0x30,
  0x58, 0x0F, 0xC0, 0x30, 0x6D, 0xA4, 0xB6, 0xD0, 0x00, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x04, 0x07, 0xBC, 0x21, 0xE0, 0x3D, 0x78, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x09, 0x00, 0x00, 0x8C, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x80,
  0x0C, 0x04, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0x40, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x71, 0x86,
  0x30, 0xC2, 0x18, 0x41, 0x0C, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x30, 0x70, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80,
  0x06, 0x20, 0x00, 0xCC, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x2C, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xF0, 0x38,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00,
  0x68, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x18, 0x40, 0x06,
  0x04, 0x01, 0x80, 0x60, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x0D,
  0x00, 0x06, 0x40, 0x03, 0x10, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC0,
  0x40, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x30, 0x30, 0x18, 0x01, 0x02, 0x00, 0x30, 0xC0, 0x02, 0x30,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x70, 0x30, 0x18,
  0x03, 0x06, 0x00, 0x30, 0x80, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x24, 0x00, 0x0C, 0xC0, 0x03, 0x0C, 0x00, 0xC0, 0xE0, 0x70, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x02, 0x40,
  0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x30,
  0x40, 0x01, 0x02, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01,
  0x80, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x01, 0x80, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0x7F, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x8F, 0xC0, 0x1B, 0x07, 0x01,
  0x40, 0x18, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x84, 0x00, 0x18, 0xC0, 0x01, 0x06, 0x00, 0x20, 0x38, 0x0C, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC7, 0xE0, 0x26, 0x06, 0x1A, 0x00, 0xC5, 0x00, 0x19, 0x80,
  0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xA0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04, 0x40, 0x02, 0x08, 0x01, 0x81,
  0x81, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xE8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x20, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x60, 0x40, 0x03, 0x0C, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x30, 0x80, 0x02,
  0x08, 0x00, 0x60, 0x40, 0x0C, 0x03, 0x03, 0x00, 0x0F, 0xC0, 0x0F, 0x03,
  0x01, 0x80, 0x08, 0x30, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0x60,
  0x01, 0x82, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01,
  0x81, 0x81, 0x80, 0x10, 0xC0, 0x06, 0x20, 0x00, 0x90, 0x00, 0x34, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06,
  0xC0, 0x01, 0x90, 0x00, 0xE6, 0x00, 0x50, 0xE0, 0x64, 0x0F, 0xE2, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x38, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x07, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x10, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1C, 0x1C, 0x30,
  0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x07,
  0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x08, 0x03, 0x02, 0x00,
  0x20, 0xC0, 0x04, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x30, 0x3E,
  0x64, 0x0C, 0x28, 0x83, 0x03, 0x10, 0xC0, 0x66, 0x10, 0x0C, 0xC2, 0x01,
  0x90, 0x40, 0x32, 0x18, 0x04, 0x43, 0x00, 0x88, 0x40, 0x13, 0x08, 0x02,
  0x61, 0x00, 0xC8, 0x20, 0x19, 0x04, 0x06, 0x20, 0x41, 0x44, 0x0E, 0xC8,
  0x80, 0x60, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x05, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x80, 0x01, 0x98, 0x00, 0x10,
  0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x40, 0xC0, 0x0C,
  0x0C, 0x00, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x04, 0x02,
  0x00, 0x60, 0x60, 0x06, 0x07, 0xFF, 0xE0, 0xC0, 0x02, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x01,
  0x60, 0x00, 0x1C, 0x00, 0x01, 0x07, 0xFF, 0x00, 0x40, 0x0C, 0x0C, 0x00,
  0x60, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80,
  0x02, 0x18, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x41, 0x00, 0x0C, 0x10,
  0x03, 0x81, 0xFF, 0xC0, 0x30, 0x03, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x42,
  0x00, 0x04, 0x20, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x04,
  0x60, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0xC0, 0x06,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1C, 0x18, 0x03, 0x00, 0xC0, 0x40,
  0x06, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x86, 0x00, 0x10, 0x20, 0x03, 0x03, 0x00, 0x60, 0x1C, 0x1C, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x01, 0x00, 0x60, 0x20, 0x06, 0x04, 0x00, 0x61, 0x80,
  0x04, 0x30, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00,
  0x19, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x08, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x06,
  0x10, 0x01, 0x82, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xFF, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x08,
  0x03, 0x02, 0x00, 0x30, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x01, 0xFE, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00,
  0x62, 0x00, 0x1C, 0x60, 0x05, 0x06, 0x00, 0xA0, 0x60, 0x64, 0x03, 0xF0,
  0x80, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x1F,
  0xFF, 0xF0, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00,
  0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x20, 0x01, 0x84,
  0x00, 0x20, 0xC0, 0x0C, 0x08, 0x03, 0x01, 0xC1, 0xC0, 0x0F, 0xE0, 0x00,
  0x06, 0x00, 0x06, 0x08, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x08,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x0E,
  0x00, 0x02, 0x34, 0x00, 0x04, 0xCC, 0x00, 0x1B, 0x08, 0x00, 0x3C, 0x18,
  0x00, 0x70, 0x10, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x40, 0x01, 0x80,
  0x80, 0x01, 0x01, 0x00, 0x03, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xE0,
  0x03, 0x82, 0x80, 0x0A, 0x1A, 0x00, 0x48, 0x6C, 0x03, 0x61, 0x10, 0x09,
  0x84, 0x40, 0x44, 0x11, 0x03, 0x10, 0x46, 0x08, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x0C, 0x20, 0xC8, 0x30, 0x81, 0x60, 0x82, 0x05, 0x02, 0x08, 0x1C,
  0x08, 0x60, 0x60, 0x21, 0x81, 0x01, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x30, 0x80,
  0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x06, 0x00,
  0x08, 0x70, 0x00, 0x43, 0xC0, 0x06, 0x16, 0x00, 0x30, 0x90, 0x01, 0x04,
  0xC0, 0x08, 0x26, 0x00, 0x43, 0x10, 0x02, 0x18, 0xC0, 0x30, 0x86, 0x01,
  0x84, 0x10, 0x08, 0x20, 0xC0, 0x41, 0x06, 0x02, 0x18, 0x10, 0x10, 0xC0,
  0xC1, 0x84, 0x06, 0x0C, 0x20, 0x10, 0x41, 0x00, 0x82, 0x08, 0x06, 0x10,
  0xC0, 0x10, 0x86, 0x00, 0x8C, 0x30, 0x06, 0x61, 0x00, 0x12, 0x08, 0x00,
  0x90, 0x40, 0x06, 0x86, 0x00, 0x14, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x00,
  0x00, 0x7E, 0x00, 0x30, 0x70, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80, 0x06,
  0x20, 0x00, 0xCC, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05,
  0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x68,
  0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x18, 0x40, 0x06, 0x04,
  0x01, 0x80, 0x60, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x20, 0x03,
  0x01, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20,
  0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04,
  0x30, 0x00, 0x61, 0x00, 0x06, 0x08, 0x00, 0x60, 0x7F, 0xFC, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x30, 0x70, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80, 0x06, 0x20, 0x00, 0xCC,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x09, 0x00,
  0x03, 0x30, 0x00, 0x42, 0x00, 0x18, 0x40, 0x06, 0x04, 0x01, 0x80, 0x60,
  0xE0, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x30, 0x03,
  0x0C, 0x00, 0x23, 0x00, 0x06, 0x80, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0,
  0x20, 0x03, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x04, 0x30, 0x00, 0x61, 0x00, 0x06, 0x08, 0x00, 0x60, 0x7F, 0xFC,
  0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0xC0, 0x30, 0x02, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x40,
  0x40, 0x03, 0x02, 0x00, 0x08, 0x10, 0x00, 0x61, 0x80, 0x01, 0x00, 0x00,
  0x7F, 0x80, 0x06, 0x01, 0xC0, 0x20, 0x01, 0x81, 0x00, 0x03, 0x0C, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x10, 0x00, 0x18, 0xE0, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0,
  0x70, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x11, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x23,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x20, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00,
  0x84, 0x00, 0x08, 0x40, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0x40, 0x30,
  0x18, 0x00, 0xFE, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C,
  0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x01, 0x86, 0x00, 0x10,
  0x60, 0x03, 0x06, 0x00, 0x20, 0x20, 0x06, 0x02, 0x00, 0x40, 0x20, 0x0C,
  0x02, 0x00, 0x80, 0x30, 0x18, 0x03, 0x01, 0x00, 0x30, 0x30, 0x01, 0x02,
  0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x19,
  0x80, 0x00, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00,
  0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x04,
  0x60, 0x20, 0x31, 0x81, 0xC0, 0x86, 0x07, 0x02, 0x10, 0x3C, 0x18, 0x40,
  0x90, 0x61, 0x06, 0x41, 0x04, 0x11, 0x04, 0x10, 0xC4, 0x30, 0x42, 0x10,
  0xC1, 0x08, 0x42, 0x04, 0x41, 0x88, 0x11, 0x06, 0x60, 0xCC, 0x19, 0x83,
  0x20, 0x24, 0x0D, 0x80, 0x90, 0x34, 0x02, 0xC0, 0xF0, 0x0A, 0x02, 0x80,
  0x28, 0x0A, 0x00, 0xA0, 0x38, 0x03, 0x80, 0x06, 0x00, 0x01, 0x81, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x04,
  0x00, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x40, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x68, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x04, 0x00, 0x10, 0x03, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x66, 0x00, 0x03, 0x08, 0x00, 0x18, 0x30, 0x00,
  0x40, 0xC0, 0x03, 0x01, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x08, 0x02, 0x00,
  0x30, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x86, 0x00, 0x02, 0x30, 0x00, 0x0C,
  0x80, 0x00, 0x16, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00,
  0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xB0,
  0x00, 0x22, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0xC0, 0xC0, 0x10, 0x08,
  0x04, 0x01, 0x01, 0x80, 0x30, 0x60, 0x02, 0x08, 0x00, 0x62, 0x00, 0x04,
  0xC0, 0x00, 0xB0, 0x00, 0x08, 0xFF, 0xFF, 0xE0, 0x8C, 0x44, 0x22, 0x10,
  0x03, 0xF0, 0x41, 0x83, 0x31, 0x80, 0x2C, 0xC0, 0x06, 0x20, 0x01, 0x98,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x02, 0x86, 0x01, 0x20, 0xC1, 0x98, 0x0F, 0x83, 0xC0,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x1F, 0x01, 0x98,
  0x30, 0x48, 0x06, 0x14, 0x00, 0x86, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01,
  0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x98, 0x00, 0x46, 0x00,
  0x23, 0x40, 0x18, 0xC8, 0x18, 0x21, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0x03,
  0x03, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x09, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x02, 0x40, 0x03, 0x30, 0x03, 0x0C, 0x03,
  0x03, 0x07, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x1F, 0x04, 0x06, 0x0C, 0xC1, 0x80, 0x2C, 0x10,
  0x01, 0x82, 0x00, 0x18, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x60, 0x40, 0x0A,
  0x06, 0x01, 0x20, 0x30, 0x66, 0x00, 0xF8, 0x60, 0x00, 0xFC, 0x01, 0x81,
  0x83, 0x00, 0x63, 0x00, 0x11, 0x00, 0x09, 0x00, 0x05, 0x80, 0x02, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x07, 0x30, 0x3E, 0x1F, 0xE0, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x03, 0x40, 0x01, 0x30, 0x01, 0x0C, 0x01,
  0x03, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00,
  0x08, 0x20, 0x00, 0x02, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x20, 0x60, 0x4C, 0x30, 0x05, 0x84,
  0x00, 0x61, 0x00, 0x0C, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x60,
  0x00, 0xC8, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x03, 0x10, 0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0xA0, 0xC0,
  0x24, 0x0C, 0x19, 0x80, 0x7E, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x83, 0x00, 0x60, 0x30, 0x18, 0x01, 0xFC,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x3E, 0x06, 0x60,
  0xC3, 0x40, 0x21, 0xC0, 0x18, 0xC0, 0x04, 0x60, 0x02, 0x20, 0x01, 0x30,
  0x00, 0x98, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x32, 0x00, 0x11, 0x00, 0x09,
  0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00,
  0x4C, 0x00, 0x26, 0x00, 0x30, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x06, 0x0C, 0x0C, 0x04, 0x0C, 0x02, 0x08,
  0x03, 0x18, 0x01, 0x98, 0x00, 0xD0, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x03, 0x00, 0x80, 0xC0, 0x40, 0x30, 0x20, 0x0C, 0x30, 0x03, 0x18, 0x00,
  0xC8, 0x00, 0x34, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x87, 0xE0, 0x19, 0x83, 0x01, 0x20, 0x18,
  0x14, 0x00, 0x81, 0x80, 0x08, 0x38, 0x00, 0x83, 0x00, 0x08, 0x30, 0x01,
  0x02, 0x00, 0x30, 0x20, 0x0C, 0x02, 0x03, 0x00, 0x61, 0xC0, 0x06, 0x30,
  0x00, 0x61, 0x80, 0x04, 0x08, 0x01, 0x40, 0xC0, 0x64, 0x04, 0x0C, 0x40,
  0x61, 0x8C, 0x02, 0x30, 0xC0, 0x16, 0x08, 0x01, 0x80, 0xFF, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x01, 0x84, 0x06, 0x18, 0x10, 0x30, 0xC0, 0x43, 0x00,
  0x98, 0x01, 0x60, 0x03, 0x00, 0x00, 0x08, 0xF0, 0xF0, 0x2C, 0x44, 0x61,
  0xC0, 0xA0, 0x86, 0x03, 0x03, 0x18, 0x08, 0x0C, 0x40, 0x20, 0x31, 0x01,
  0x80, 0x84, 0x06, 0x02, 0x30, 0x10, 0x08, 0xC0, 0x40, 0x62, 0x01, 0x01,
  0x88, 0x04, 0x06, 0x20, 0x30, 0x10, 0x80, 0xC0, 0x46, 0x02, 0x01, 0x18,
  0x08, 0x0C, 0x40, 0x20, 0x31, 0x00, 0x80, 0xC4, 0x06, 0x02, 0x10, 0x18,
  0x08, 0xC0, 0x40, 0x20, 0x08, 0x7C, 0x0C, 0xC1, 0x86, 0x80, 0x43, 0x80,
  0x31, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0x30, 0x01, 0x98,
  0x00, 0xC8, 0x00, 0x64, 0x00, 0x22, 0x00, 0x13, 0x00, 0x09, 0x80, 0x0C,
  0xC0, 0x06, 0x40, 0x03, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0x4C, 0x00,
  0x60, 0x01, 0xF8, 0x01, 0x81, 0x80, 0xC0, 0x10, 0x40, 0x06, 0x30, 0x00,
  0x88, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xA0, 0x00, 0x2C, 0x00, 0x1B, 0x00,
  0x04, 0x40, 0x03, 0x18, 0x01, 0x82, 0x00, 0xC0, 0x60, 0x60, 0x07, 0xE0,
  0x00, 0x0C, 0x3E, 0x01, 0x98, 0x30, 0x24, 0x03, 0x05, 0x00, 0x20, 0xC0,
  0x06, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x06, 0x30, 0x00, 0x86, 0x00, 0x21, 0xA0, 0x0C, 0x32, 0x06,
  0x04, 0x3F, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0,
  0x41, 0x83, 0x31, 0x80, 0x2C, 0x40, 0x06, 0x20, 0x01, 0x98, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x68, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0C, 0xC0, 0x06,
  0x10, 0x02, 0x86, 0x01, 0x20, 0xC1, 0x98, 0x0F, 0xC6, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0xFF, 0x1F, 0xE0, 0x64, 0x00, 0x0D, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xE0, 0x30, 0x30,
  0x01, 0x84, 0x00, 0x11, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x40, 0x00, 0xD8, 0x00,
  0x10, 0x80, 0x04, 0x0E, 0x03, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x07, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x08, 0x0C, 0x03,
  0x81, 0x81, 0x80, 0x20, 0x60, 0x04, 0x30, 0x00, 0x88, 0x00, 0x36, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x26,
  0x00, 0x13, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x02, 0x20, 0x01,
  0x30, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x32, 0x00, 0x11, 0x00,
  0x18, 0x80, 0x14, 0x60, 0x0E, 0x10, 0x0B, 0x0C, 0x19, 0x81, 0xF0, 0x80,
  0xFE, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x43,
  0x00, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80,
  0x08, 0x20, 0x02, 0x18, 0x01, 0x86, 0x00, 0x41, 0x80, 0x20, 0x40, 0x18,
  0x10, 0x0C, 0x04, 0x06, 0x01, 0x03, 0x00, 0x47, 0x00, 0x1F, 0x00, 0x00,
  0x30, 0x10, 0x62, 0x03, 0x02, 0x20, 0x30, 0x22, 0x02, 0x02, 0x20, 0x20,
  0x36, 0x02, 0x03, 0x60, 0x20, 0x34, 0x06, 0x03, 0x40, 0x60, 0x34, 0x04,
  0x03, 0x40, 0x40, 0x2C, 0x04, 0x02, 0xC0, 0x40, 0x28, 0x0C, 0x02, 0x80,
  0xC0, 0x68, 0x0C, 0x04, 0x80, 0x80, 0xC8, 0x18, 0x08, 0x82, 0x41, 0x8C,
  0x44, 0x30, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF8, 0x19, 0x84, 0x31, 0x82,
  0x20, 0x58, 0x09, 0x01, 0x00, 0x24, 0x04, 0x00, 0xE0, 0x10, 0x01, 0x80,
  0x40, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x07, 0x00, 0x20, 0x14,
  0x00, 0x80, 0x90, 0x0A, 0x02, 0x40, 0xEC, 0x11, 0x86, 0x30, 0x82, 0x60,
  0x3C, 0x0E, 0x00, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x04, 0x00,
  0x20, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00,
  0x82, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x03,
  0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x05, 0x06, 0x00, 0xE0, 0x40, 0x2C,
  0x0C, 0x19, 0x80, 0x7C, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x82, 0x00, 0x60, 0x70, 0x38, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x30, 0xC1, 0xE3, 0x10, 0x03, 0xE1, 0x00, 0x06, 0x10, 0x00,
  0xC3, 0x00, 0x18, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x18, 0x0C,
  0x00, 0x81, 0x80, 0x08, 0x30, 0x00, 0x87, 0x80, 0x08, 0xFF, 0x80, 0xCC,
  0x1F, 0xCC, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xC0, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xF0, 0x07, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x18, 0xC4, 0x00,
  0x8C, 0x10, 0x0C, 0xC0, 0x40, 0x44, 0x03, 0x04, 0x20, 0x0C, 0x62, 0x00,
  0x3C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 7, 28, 24, 9, -28 },
  { 26, 9, 10, 24, 10, -30 },
  { 38, 24, 28, 24, 1, -28 },
  { 122, 22, 36, 24, 1, -32 },
  { 221, 27, 28, 24, -1, -28 },
  { 316, 24, 28, 24, 0, -28 },
  { 400, 3, 10, 24, 13, -30 },
  { 404, 13, 36, 24, 9, -30 },
  { 463, 13, 36, 24, 3, -30 },
  { 522, 21, 20, 24, 2, -22 },
  { 575, 19, 19, 24, 3, -22 },
  { 621, 6, 11, 24, 6, -4 },
  { 630, 11, 1, 24, 7, -13 },
  { 632, 3, 3, 24, 9, -3 },
  { 634, 22, 36, 24, 1, -30 },
  { 733, 19, 28, 24, 3, -28 },
  { 800, 18, 28, 24, 2, -28 },
  { 863, 19, 28, 24, 2, -28 },
  { 930, 19, 28, 24, 2, -28 },
  { 997, 21, 28, 24, 1, -28 },
  { 1071, 20, 28, 24, 2, -28 },
  { 1141, 18, 28, 24, 3, -28 },
  { 1204, 19, 28, 24, 5, -28 },
  { 1271, 20, 28, 24, 2, -28 },
  { 1341, 18, 28, 24, 4, -28 },
  { 1404, 6, 21, 24, 9, -21 },
  { 1420, 9, 28, 24, 6, -21 },
  { 1452, 19, 22, 24, 4, -23 },
  { 1505, 21, 8, 24, 2, -16 },
  { 1526, 19, 22, 24, 2, -23 },
  { 1579, 16, 28, 24, 6, -28 },
  { 1635, 19, 32, 24, 3, -28 },
  { 1711, 20, 28, 24, 0, -28 },
  { 1781, 20, 28, 24, 2, -28 },
  { 1851, 20, 28, 24, 3, -28 },
  { 1921, 19, 28, 24, 3, -28 },
  { 1988, 22, 28, 24, 2, -28 },
  { 2065, 22, 28, 24, 2, -28 },
  { 2142, 19, 28, 24, 3, -28 },
  { 2209, 21, 28, 24, 2, -28 },
  { 2283, 21, 28, 24, 2, -28 },
  { 2357, 19, 28, 24, 3, -28 },
  { 2424, 23, 28, 24, 2, -28 },
  { 2505, 16, 28, 24, 4, -28 },
  { 2561, 22, 28, 24, 2, -28 },
  { 2638, 21, 28, 24, 2, -28 },
  { 2712, 19, 28, 24, 3, -28 },
  { 2779, 21, 28, 24, 2, -28 },
  { 2853, 19, 35, 24, 3, -28 },
  { 2937, 21, 28, 24, 2, -28 },
  { 3011, 22, 28, 24, 1, -28 },
  { 3088, 21, 28, 24, 4, -28 },
  { 3162, 20, 28, 24, 3, -28 },
  { 3232, 20, 28, 24, 5, -28 },
  { 3302, 22, 28, 24, 3, -28 },
  { 3379, 25, 28, 24, 0, -28 },
  { 3467, 22, 28, 24, 4, -28 },
  { 3544, 24, 28, 24, 0, -28 },
  { 3628, 15, 36, 24, 8, -30 },
  { 3696, 9, 36, 24, 8, -30 },
  { 3737, 16, 36, 24, 1, -30 },
  { 3809, 19, 15, 24, 3, -28 },
  { 3845, 19, 1, 24, 0, 5 },
  { 3848, 4, 7, 24, 10, -31 },
  { 3852, 18, 21, 24, 3, -21 },
  { 3900, 18, 30, 24, 3, -30 },
  { 3968, 17, 21, 24, 3, -21 },
  { 4013, 20, 30, 24, 3, -30 },
  { 4088, 17, 21, 24, 3, -21 },
  { 4133, 25, 38, 24, 0, -30 },
  { 4252, 19, 29, 24, 2, -21 },
  { 4321, 17, 30, 24, 3, -30 },
  { 4385, 17, 30, 24, 4, -30 },
  { 4449, 17, 38, 24, 4, -30 },
  { 4530, 20, 30, 24, 3, -30 },
  { 4605, 15, 30, 24, 5, -30 },
  { 4662, 22, 21, 24, 1, -21 },
  { 4720, 17, 21, 24, 3, -21 },
  { 4765, 18, 21, 24, 3, -21 },
  { 4813, 19, 29, 24, 2, -21 },
  { 4882, 18, 29, 24, 3, -21 },
  { 4948, 19, 21, 24, 5, -21 },
  { 4998, 19, 21, 24, 2, -21 },
  { 5048, 19, 28, 24, 3, -28 },
  { 5115, 17, 21, 24, 4, -21 },
  { 5160, 18, 21, 24, 3, -21 },
  { 5208, 20, 21, 24, 3, -21 },
  { 5261, 22, 21, 24, 1, -21 },
  { 5319, 19, 29, 24, 2, -21 },
  { 5388, 20, 21, 24, 2, -21 },
  { 5441, 18, 36, 24, 5, -30 },
  { 5522, 7, 36, 24, 9, -30 },
  { 5554, 18, 36, 24, 2, -30 },
  { 5635, 21, 7, 24, 2, -16 },
};

const GFXfont IBMPlexMono_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC40PT7B_H_
