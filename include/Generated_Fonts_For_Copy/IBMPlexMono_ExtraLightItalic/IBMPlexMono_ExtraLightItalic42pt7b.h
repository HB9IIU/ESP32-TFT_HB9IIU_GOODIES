#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC42PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x40,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x8E, 0x00, 0x30, 0xCC, 0x32, 0x08, 0x82, 0x21, 0x98, 0x66, 0x19,
  0x86, 0x41, 0x10, 0x4C, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x04, 0x00,
  0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x20, 0x60, 0x00, 0x10, 0x20,
  0x07, 0xF8, 0x1F, 0xE0, 0x08, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x04,
  0x00, 0x02, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x81,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x10, 0x30, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x04,
  0x0C, 0x00, 0x02, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFC, 0x00, 0x38, 0x47, 0x00, 0xC1, 0x83, 0x03, 0x03, 0x03, 0x04,
  0x04, 0x04, 0x18, 0x08, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x03, 0x04, 0x00, 0x03, 0x08,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x8E, 0x00, 0x01, 0x06,
  0x00, 0x02, 0x06, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x01, 0x8C, 0x02, 0x03, 0x0C,
  0x04, 0x0C, 0x0C, 0x18, 0x30, 0x0E, 0x21, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x30, 0x18, 0x60, 0x02, 0x02, 0x03, 0x00, 0x40, 0x60, 0x10,
  0x0C, 0x04, 0x01, 0x01, 0x80, 0x40, 0x10, 0x10, 0x0C, 0x01, 0x02, 0x00,
  0xC0, 0x10, 0x60, 0x08, 0x03, 0x0C, 0x00, 0x80, 0x20, 0x80, 0x0C, 0x02,
  0x10, 0x00, 0x40, 0x43, 0x00, 0x06, 0x18, 0x60, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x21, 0x86, 0x00, 0x04,
  0x30, 0x30, 0x00, 0xC6, 0x01, 0x00, 0x18, 0x40, 0x10, 0x01, 0x04, 0x01,
  0x00, 0x20, 0xC0, 0x10, 0x06, 0x0C, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x08,
  0x0C, 0x03, 0x01, 0x00, 0xC0, 0x20, 0x30, 0x04, 0x04, 0x06, 0x00, 0x20,
  0xC0, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x20, 0x18, 0x00, 0x20, 0x04, 0x00, 0x10, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00, 0x80, 0x10,
  0x00, 0x60, 0x18, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x0F, 0x08,
  0x00, 0x38, 0xB8, 0x00, 0x20, 0x60, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x10, 0x03, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x06, 0x80, 0x0B, 0x02, 0x40, 0x04, 0x82, 0x30,
  0x02, 0x23, 0x08, 0x02, 0x19, 0x03, 0x06, 0x05, 0x80, 0xFC, 0x01, 0x80,
  0x33, 0x22, 0x66, 0x66, 0x44, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x10, 0x04, 0x01, 0xF0, 0x20, 0xF8, 0xF3, 0x3C,
  0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x60, 0x00, 0xC1, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x80,
  0xC0, 0x04, 0x04, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0E,
  0x18, 0x30, 0xC1, 0x86, 0x0C, 0x10, 0x60, 0x83, 0x00, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x18, 0x02, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x31, 0x80,
  0x03, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x60,
  0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x14, 0x07, 0x03, 0xC0, 0x70, 0x3C,
  0x06, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x40, 0x01,
  0x06, 0x00, 0x30, 0x30, 0x06, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x40, 0x01, 0xD8, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0E,
  0x0C, 0x03, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x0E,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x40, 0x03, 0x0C,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x80, 0x00, 0x8C, 0x00, 0x18, 0x60, 0x03, 0x03, 0x80, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x00, 0x00,
  0x2C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x08,
  0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x60, 0x06, 0x01, 0x00, 0x30, 0x04, 0x01, 0x80, 0x10, 0x04, 0x00,
  0xC0, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x83,
  0x00, 0x02, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xF8, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x8F, 0xE0, 0x0D, 0x81, 0xC0, 0x70,
  0x03, 0x03, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x40, 0x00, 0xC7, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x38, 0x1C, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x7E, 0x03, 0x70, 0x30, 0x50, 0x03,
  0x1C, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0x40, 0x01, 0x8C, 0x00, 0x20, 0xC0, 0x18, 0x0C, 0x0E, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xF4, 0x00, 0x02, 0x40, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0E, 0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x30,
  0x40, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x18, 0x40, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x38, 0x18, 0x00,
  0x7F, 0x00, 0x1C, 0x0E, 0x03, 0x00, 0x18, 0x30, 0x00, 0x61, 0x00, 0x01,
  0x18, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x04, 0x40, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00, 0x60,
  0x38, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x60, 0x30,
  0x06, 0x08, 0x00, 0x63, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x1A, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00,
  0x0C, 0x80, 0x01, 0x98, 0x00, 0xB1, 0x80, 0x34, 0x18, 0x19, 0x80, 0xFC,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x1C, 0x00, 0x01,
  0xC0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xFD, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x06,
  0x07, 0x0C, 0x00, 0xC4, 0x00, 0x26, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x1C, 0x1C, 0x03, 0x00, 0x40, 0x60, 0x02, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x31, 0x01, 0xF3,
  0x30, 0x60, 0xA2, 0x04, 0x06, 0x20, 0x80, 0x62, 0x08, 0x06, 0x61, 0x80,
  0x66, 0x10, 0x06, 0x41, 0x00, 0x44, 0x10, 0x04, 0x43, 0x00, 0x44, 0x30,
  0x0C, 0xC3, 0x00, 0xCC, 0x30, 0x0C, 0xC1, 0x01, 0x8C, 0x18, 0x28, 0xC0,
  0xFC, 0x8C, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00,
  0xC8, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30, 0x40,
  0x01, 0x02, 0x00, 0x18, 0x10, 0x00, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40,
  0x30, 0x06, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x81,
  0xFF, 0xFC, 0x08, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00,
  0x42, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x80, 0x20, 0x03, 0x01, 0x00,
  0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x41, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0x7F, 0xF8, 0x02, 0x00, 0x38, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00, 0x03,
  0x10, 0x00, 0x19, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00,
  0x02, 0x10, 0x00, 0x20, 0x80, 0x06, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x18, 0x18, 0x02, 0x00, 0xC0, 0x40, 0x06, 0x08, 0x00, 0x21, 0x00,
  0x03, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x03,
  0x06, 0x00, 0x20, 0x20, 0x06, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0xC0, 0x38, 0x0C, 0x00, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x20,
  0x80, 0x03, 0x18, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x30, 0x00,
  0x32, 0x00, 0x03, 0x20, 0x00, 0x32, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00,
  0x06, 0x60, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x08, 0xC0,
  0x01, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x01, 0x80, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x18, 0x06, 0x00, 0xC0,
  0xC0, 0x06, 0x18, 0x00, 0x21, 0x00, 0x03, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x7F, 0xC8, 0x00,
  0x0C, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x01, 0x88, 0x00, 0x18, 0xC0, 0x03, 0x84, 0x00, 0x50, 0x60, 0x0D, 0x03,
  0x81, 0x10, 0x0F, 0xE3, 0x00, 0x06, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x41, 0xFF, 0xFF, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x40,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x08, 0x00, 0x20, 0xC0, 0x06, 0x0C,
  0x00, 0x40, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80, 0x0C,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x20, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x3C, 0x00, 0x0C, 0xC8, 0x00, 0x13, 0x18, 0x00, 0x2C, 0x10, 0x00, 0xF0,
  0x30, 0x01, 0x80, 0x20, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00,
  0xC0, 0x10, 0x00, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03,
  0x02, 0x00, 0x06, 0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF8,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x28, 0x00, 0x70, 0x50, 0x00, 0xA0,
  0xB0, 0x02, 0x41, 0x20, 0x0C, 0x86, 0x40, 0x13, 0x0C, 0xC0, 0x66, 0x11,
  0x81, 0x88, 0x21, 0x02, 0x10, 0x42, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x04,
  0x61, 0x86, 0x09, 0x83, 0x08, 0x1A, 0x04, 0x10, 0x3C, 0x08, 0x20, 0x30,
  0x10, 0x40, 0x40, 0x61, 0x80, 0x80, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x04, 0x1C, 0x00, 0x10, 0x50, 0x00, 0xC3, 0x40, 0x03, 0x0D,
  0x80, 0x0C, 0x32, 0x00, 0x20, 0x88, 0x00, 0x82, 0x30, 0x02, 0x08, 0xC0,
  0x18, 0x61, 0x00, 0x61, 0x86, 0x01, 0x86, 0x18, 0x04, 0x10, 0x20, 0x10,
  0x40, 0xC0, 0x41, 0x03, 0x03, 0x0C, 0x04, 0x0C, 0x30, 0x18, 0x30, 0xC0,
  0x60, 0x82, 0x00, 0x82, 0x08, 0x03, 0x08, 0x20, 0x0C, 0x61, 0x80, 0x11,
  0x86, 0x00, 0x66, 0x18, 0x01, 0x90, 0x40, 0x02, 0x41, 0x00, 0x0D, 0x04,
  0x00, 0x3C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x18,
  0x18, 0x02, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x10,
  0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x16,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00,
  0x4C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x40, 0x01, 0x06, 0x00,
  0x30, 0x30, 0x06, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x60, 0x03, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00,
  0x04, 0x60, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0x80, 0x00, 0xC4,
  0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x07,
  0x07, 0xFF, 0xE0, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x02, 0x00, 0x40, 0x40, 0x02,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00,
  0x12, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0xCC,
  0x00, 0x08, 0x40, 0x01, 0x06, 0x00, 0x30, 0x30, 0x06, 0x01, 0x81, 0x80,
  0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x20,
  0xC0, 0x03, 0x10, 0x00, 0x1A, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x80, 0x60,
  0x03, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00, 0x04,
  0x60, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0x80, 0x00, 0xC4, 0x00,
  0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x07, 0x07,
  0xFF, 0xE0, 0x20, 0x20, 0x03, 0x01, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x20, 0x06, 0x01, 0x00, 0x10, 0x18, 0x00, 0xC0, 0xC0,
  0x02, 0x06, 0x00, 0x18, 0x30, 0x00, 0x41, 0x00, 0x03, 0x08, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x40, 0x00, 0x41, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0xF0, 0x1C, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x18, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x30, 0x80, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0x80, 0x1F,
  0xE0, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00,
  0x44, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x20,
  0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x04, 0x03, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x02, 0x01, 0x80, 0x10, 0x18, 0x00, 0x80,
  0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00,
  0x23, 0x00, 0x01, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x02, 0x60, 0x00,
  0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x30, 0x18, 0x40, 0x60, 0x31,
  0x81, 0xC0, 0x43, 0x02, 0x80, 0x86, 0x0D, 0x83, 0x0C, 0x13, 0x06, 0x18,
  0x26, 0x08, 0x20, 0xC4, 0x10, 0x41, 0x08, 0x60, 0x86, 0x10, 0x81, 0x08,
  0x21, 0x02, 0x30, 0x42, 0x04, 0x40, 0x8C, 0x09, 0x81, 0x90, 0x12, 0x03,
  0x20, 0x64, 0x06, 0xC0, 0xD8, 0x05, 0x81, 0xA0, 0x0A, 0x03, 0xC0, 0x14,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x10, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x03, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x04, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x61, 0x00, 0x01, 0x83, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x30, 0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x08, 0x04, 0x00, 0x18,
  0x18, 0x00, 0x10, 0x60, 0x00, 0x31, 0x80, 0x00, 0x26, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x03, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x40,
  0x00, 0x36, 0x00, 0x06, 0x20, 0x00, 0xC2, 0x00, 0x08, 0x30, 0x01, 0x81,
  0x00, 0x30, 0x18, 0x06, 0x00, 0x80, 0x40, 0x0C, 0x0C, 0x00, 0x41, 0x80,
  0x04, 0x30, 0x00, 0x62, 0x00, 0x02, 0x60, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0xC2, 0x18, 0x43, 0x08, 0x60, 0x01, 0xF8, 0x60, 0xC0, 0xCC,
  0x30, 0x05, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x32,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0x48,
  0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x64, 0x00, 0x0C, 0x80, 0x03, 0x18,
  0x00, 0xA1, 0x00, 0x1C, 0x30, 0x05, 0x83, 0x83, 0x30, 0x1F, 0x87, 0xC0,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x0F, 0xC0,
  0x26, 0x0E, 0x0D, 0x80, 0x61, 0xC0, 0x04, 0x28, 0x00, 0xC6, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0x85, 0x00, 0x61, 0x98, 0x18, 0x30,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0xC0, 0x18, 0x60, 0x03, 0x10,
  0x00, 0x4C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x02, 0x40, 0x01, 0x98, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x18, 0x1C,
  0x18, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x0F, 0xC1, 0x01, 0xC1, 0x98, 0x18, 0x02, 0xC1,
  0x80, 0x0E, 0x18, 0x00, 0x60, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01, 0x86, 0x00, 0x18,
  0x30, 0x01, 0x40, 0x80, 0x0A, 0x06, 0x00, 0xB0, 0x1C, 0x19, 0x80, 0x3F,
  0x0C, 0x00, 0x00, 0xFE, 0x00, 0xE0, 0x60, 0x40, 0x0C, 0x20, 0x01, 0x10,
  0x00, 0x4C, 0x00, 0x12, 0x00, 0x05, 0x80, 0x03, 0x40, 0x01, 0x90, 0x01,
  0xC4, 0x07, 0x83, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x02, 0x40, 0x00, 0xD8, 0x00, 0x62, 0x00, 0x30, 0xC0, 0x18, 0x1C,
  0x1C, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x40, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x60, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFC, 0x10, 0x38, 0x33, 0x06, 0x00, 0xB0, 0xC0, 0x07, 0x18, 0x00, 0x61,
  0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x04,
  0x60, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00,
  0xC4, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x28, 0x20, 0x02, 0x83, 0x00,
  0x58, 0x1C, 0x19, 0x80, 0x7E, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0x70, 0x38, 0x01,
  0xFC, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x0F,
  0x80, 0x8C, 0x38, 0x24, 0x02, 0x1A, 0x00, 0xC7, 0x00, 0x11, 0x80, 0x04,
  0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xCC, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x02, 0x02, 0x01, 0xC1, 0x80, 0xC0, 0x60,
  0x40, 0x18, 0x60, 0x04, 0x20, 0x01, 0x30, 0x00, 0x58, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0xC0, 0x10, 0x08, 0x0C, 0x01, 0x03, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00,
  0x88, 0x00, 0x1A, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x41, 0xF8, 0x02, 0x30, 0x60, 0x36,
  0x01, 0x81, 0xA0, 0x04, 0x0E, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x18,
  0x10, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x03,
  0x00, 0x10, 0xE0, 0x00, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x60, 0xC0, 0x1B,
  0x03, 0x01, 0x90, 0x08, 0x18, 0x80, 0x61, 0x84, 0x01, 0x10, 0x60, 0x0D,
  0x03, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x03, 0x08, 0x04, 0x08, 0x18, 0x08, 0x20, 0x18, 0xC0,
  0x19, 0x80, 0x12, 0x00, 0x1C, 0x00, 0x08, 0xF0, 0x78, 0x12, 0x33, 0x18,
  0x28, 0x34, 0x18, 0xE0, 0x70, 0x31, 0x80, 0xC0, 0x63, 0x01, 0x80, 0xC4,
  0x02, 0x01, 0x88, 0x04, 0x02, 0x10, 0x08, 0x04, 0x20, 0x10, 0x08, 0xC0,
  0x60, 0x31, 0x80, 0xC0, 0x62, 0x01, 0x00, 0xC4, 0x02, 0x01, 0x08, 0x04,
  0x02, 0x10, 0x08, 0x04, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x31, 0x00, 0x80,
  0x62, 0x01, 0x00, 0x84, 0x02, 0x01, 0x18, 0x0C, 0x02, 0x00, 0x08, 0x3E,
  0x02, 0x30, 0xE0, 0x90, 0x08, 0x68, 0x03, 0x1C, 0x00, 0x46, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x30, 0x00, 0xC0,
  0x00, 0xFC, 0x00, 0x60, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x61, 0x00, 0x04,
  0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0D,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x36,
  0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x31, 0x80, 0x0C, 0x18, 0x03, 0x01,
  0x81, 0xC0, 0x0F, 0xC0, 0x00, 0x04, 0x3F, 0x00, 0xCC, 0x1C, 0x0D, 0x80,
  0x60, 0xE0, 0x02, 0x0A, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x18, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x0C, 0x30, 0x00, 0x86, 0x80, 0x30, 0x66, 0x06, 0x06, 0x1F, 0x80,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x20, 0xE0,
  0xCC, 0x30, 0x05, 0x8C, 0x00, 0x73, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00,
  0x12, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x03,
  0x18, 0x00, 0xA1, 0x00, 0x14, 0x30, 0x05, 0x83, 0x83, 0x30, 0x1F, 0x86,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0xFF, 0x8F, 0xF0, 0x13,
  0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x1C, 0x04, 0x00, 0x20, 0xC0,
  0x01, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x64, 0x00, 0x06,
  0xE0, 0x00, 0x43, 0x00, 0x08, 0x1C, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x06, 0x02, 0x01, 0x80, 0x60, 0x30, 0x06, 0x0C,
  0x00, 0x61, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x8C, 0x01, 0x61, 0x80, 0x98, 0x30, 0x44, 0x07, 0xE1,
  0x00, 0xFE, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00,
  0x60, 0xC0, 0x08, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x18,
  0x01, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x18, 0x31, 0x80, 0x80, 0x8C,
  0x04, 0x04, 0x40, 0x20, 0x22, 0x01, 0x01, 0x90, 0x18, 0x0D, 0x80, 0xC0,
  0x6C, 0x06, 0x03, 0x60, 0x20, 0x1A, 0x01, 0x00, 0xD0, 0x08, 0x06, 0x80,
  0xC0, 0x2C, 0x06, 0x01, 0x60, 0x30, 0x0B, 0x01, 0x00, 0xD0, 0x08, 0x06,
  0x80, 0xC0, 0x24, 0x06, 0x03, 0x20, 0x50, 0x11, 0x02, 0x81, 0x8C, 0x22,
  0x18, 0x3E, 0x0F, 0x00, 0x01, 0xC0, 0x7C, 0x07, 0x60, 0x86, 0x1C, 0x31,
  0x02, 0x70, 0x32, 0x02, 0x40, 0x12, 0x03, 0x00, 0x14, 0x03, 0x00, 0x14,
  0x02, 0x00, 0x18, 0x02, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0x80, 0x30, 0x00, 0x80, 0x50, 0x00, 0x80, 0x58, 0x04, 0x80, 0x88,
  0x18, 0xC1, 0x88, 0x70, 0x43, 0x0C, 0xC0, 0x3C, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x04, 0x10,
  0x00, 0x41, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x83,
  0x00, 0x18, 0x30, 0x02, 0x83, 0x00, 0x38, 0x30, 0x05, 0x81, 0x80, 0x98,
  0x0C, 0x11, 0x00, 0x7E, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x80, 0x04, 0x0C, 0x00, 0x80, 0x60, 0x30, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x18, 0x60, 0x78, 0xC6, 0x00, 0x76, 0x20, 0x00, 0xE1,
  0x00, 0x06, 0x08, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x40, 0x18, 0x03, 0x01, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x02,
  0x1F, 0x00, 0x10, 0xBF, 0x80, 0xCC, 0x1F, 0xE6, 0x60, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x0C, 0x63, 0x00, 0x23, 0x06, 0x01, 0x88,
  0x0C, 0x04, 0x40, 0x10, 0x31, 0x00, 0x31, 0x8C, 0x00, 0x78, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 10, 11, 25, 10, -31 },
  { 41, 25, 29, 25, 1, -29 },
  { 132, 23, 37, 25, 1, -33 },
  { 239, 28, 29, 25, -1, -29 },
  { 341, 25, 29, 25, 0, -29 },
  { 432, 4, 11, 25, 13, -31 },
  { 438, 13, 38, 25, 10, -32 },
  { 500, 13, 38, 25, 3, -32 },
  { 562, 21, 21, 25, 3, -23 },
  { 618, 20, 21, 25, 3, -23 },
  { 671, 7, 11, 25, 6, -4 },
  { 681, 12, 1, 25, 7, -13 },
  { 683, 4, 3, 25, 9, -3 },
  { 685, 22, 38, 25, 2, -32 },
  { 790, 20, 29, 25, 3, -29 },
  { 863, 19, 29, 25, 2, -29 },
  { 932, 21, 29, 25, 2, -29 },
  { 1009, 20, 29, 25, 2, -29 },
  { 1082, 22, 29, 25, 1, -29 },
  { 1162, 21, 29, 25, 2, -29 },
  { 1239, 19, 29, 25, 3, -29 },
  { 1308, 20, 29, 25, 5, -29 },
  { 1381, 21, 29, 25, 2, -29 },
  { 1458, 19, 29, 25, 4, -29 },
  { 1527, 7, 22, 25, 9, -22 },
  { 1547, 10, 29, 25, 6, -22 },
  { 1584, 20, 23, 25, 4, -24 },
  { 1642, 22, 9, 25, 2, -17 },
  { 1667, 20, 23, 25, 2, -24 },
  { 1725, 17, 29, 25, 6, -29 },
  { 1787, 20, 34, 25, 3, -29 },
  { 1872, 21, 29, 25, 0, -29 },
  { 1949, 21, 29, 25, 2, -29 },
  { 2026, 20, 29, 25, 4, -29 },
  { 2099, 20, 29, 25, 3, -29 },
  { 2172, 22, 29, 25, 3, -29 },
  { 2252, 22, 29, 25, 3, -29 },
  { 2332, 20, 29, 25, 4, -29 },
  { 2405, 22, 29, 25, 2, -29 },
  { 2485, 22, 29, 25, 2, -29 },
  { 2565, 20, 29, 25, 3, -29 },
  { 2638, 23, 29, 25, 3, -29 },
  { 2722, 17, 29, 25, 4, -29 },
  { 2784, 23, 29, 25, 2, -29 },
  { 2868, 22, 29, 25, 2, -29 },
  { 2948, 20, 29, 25, 3, -29 },
  { 3021, 21, 29, 25, 3, -29 },
  { 3098, 20, 36, 25, 3, -29 },
  { 3188, 21, 29, 25, 3, -29 },
  { 3265, 23, 29, 25, 1, -29 },
  { 3349, 23, 29, 25, 4, -29 },
  { 3433, 20, 29, 25, 4, -29 },
  { 3506, 21, 29, 25, 5, -29 },
  { 3583, 23, 29, 25, 3, -29 },
  { 3667, 26, 29, 25, 0, -29 },
  { 3762, 23, 29, 25, 4, -29 },
  { 3846, 25, 29, 25, 0, -29 },
  { 3937, 17, 38, 25, 8, -32 },
  { 4018, 10, 38, 25, 8, -32 },
  { 4066, 17, 38, 25, 1, -32 },
  { 4147, 20, 16, 25, 3, -29 },
  { 4187, 20, 1, 25, 0, 5 },
  { 4190, 5, 7, 25, 10, -32 },
  { 4195, 19, 22, 25, 3, -22 },
  { 4248, 19, 31, 25, 3, -31 },
  { 4322, 18, 22, 25, 3, -22 },
  { 4372, 21, 31, 25, 3, -31 },
  { 4454, 18, 22, 25, 3, -22 },
  { 4504, 26, 39, 25, 0, -31 },
  { 4631, 20, 30, 25, 2, -22 },
  { 4706, 18, 31, 25, 3, -31 },
  { 4776, 18, 32, 25, 4, -32 },
  { 4848, 18, 40, 25, 4, -32 },
  { 4938, 21, 31, 25, 3, -31 },
  { 5020, 16, 31, 25, 5, -31 },
  { 5082, 23, 22, 25, 1, -22 },
  { 5146, 18, 22, 25, 3, -22 },
  { 5196, 19, 22, 25, 3, -22 },
  { 5249, 20, 30, 25, 2, -22 },
  { 5324, 19, 30, 25, 3, -22 },
  { 5396, 20, 22, 25, 5, -22 },
  { 5451, 20, 22, 25, 2, -22 },
  { 5506, 20, 29, 25, 3, -29 },
  { 5579, 18, 22, 25, 4, -22 },
  { 5629, 19, 22, 25, 3, -22 },
  { 5682, 21, 22, 25, 3, -22 },
  { 5740, 24, 22, 25, 1, -22 },
  { 5806, 20, 30, 25, 2, -22 },
  { 5881, 21, 22, 25, 2, -22 },
  { 5939, 19, 38, 25, 5, -32 },
  { 6030, 8, 38, 25, 9, -32 },
  { 6068, 19, 38, 25, 2, -32 },
  { 6159, 22, 7, 25, 2, -16 },
};

const GFXfont IBMPlexMono_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC42PT7B_H_
