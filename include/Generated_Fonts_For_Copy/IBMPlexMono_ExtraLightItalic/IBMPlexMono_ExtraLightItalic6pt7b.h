#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC6PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x67, 0xAC, 0x5F, 0x3E, 0x80, 0xFA, 0xEE, 0xEA, 0xCF,
  0x80, 0x6A, 0xA0, 0x55, 0x60, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x25, 0x29, 0x00, 0xF6, 0xF0, 0x49, 0x70, 0xE5, 0x70, 0xE5, 0xF0, 0x6E,
  0xA0, 0xF8, 0xF0, 0x7A, 0xF0, 0xEA, 0x40, 0xF7, 0xF0, 0xF6, 0x20, 0x30,
  0xE4, 0xE0, 0x47, 0x00, 0xDA, 0xFD, 0xC6, 0x3D, 0xD0, 0xF7, 0xF0, 0xEB,
  0xF6, 0xF0, 0xF8, 0xEE, 0xF8, 0xE8, 0xF2, 0xF0, 0xB7, 0xD0, 0x74, 0x4E,
  0x64, 0xF0, 0xBC, 0xCA, 0xAB, 0xB6, 0xEA, 0x7F, 0xD0, 0xF6, 0xF0, 0xF7,
  0x40, 0xF6, 0xD6, 0xF7, 0x50, 0xF1, 0xF0, 0xF2, 0x40, 0xB6, 0xF0, 0xFA,
  0x40, 0x9E, 0xEE, 0xB4, 0x4A, 0xFA, 0x40, 0x74, 0x8E, 0x72, 0x49, 0x80,
  0xAA, 0x90, 0x69, 0x25, 0x80, 0x3C, 0xE0, 0x80, 0xF7, 0x80, 0x9E, 0xF0,
  0xF3, 0x80, 0x3E, 0xF0, 0xFB, 0x80, 0x77, 0x44, 0xC0, 0xF7, 0xF0, 0x9E,
  0xD0, 0x2B, 0x36, 0x80, 0x9F, 0x70, 0xAB, 0xFF, 0x80, 0xF6, 0x80, 0xF7,
  0x80, 0xF6, 0xE0, 0xF7, 0x90, 0xF2, 0x00, 0xEF, 0x80, 0x5D, 0x70, 0xFC,
  0xB7, 0x00, 0xFF, 0x80, 0xF4, 0xE0, 0xB6, 0xE0, 0xEB, 0x80, 0x6A, 0xB0,
  0xFC, 0x4D, 0x35, 0x80, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 0, -5 },
  { 17, 3, 3, 4, 0, -3 },
  { 19, 3, 3, 4, 0, -3 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 3, 6, 4, 0, -5 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 1, 4, 4, 1, -3 },
  { 48, 2, 3, 4, 1, -3 },
  { 49, 3, 1, 4, 0, -2 },
  { 50, 3, 3, 4, 0, -3 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 2, 4, 4, 1, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 5, 4, 0, -4 },
  { 87, 3, 4, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 1, -4 },
  { 93, 3, 4, 4, 0, -4 },
  { 95, 3, 4, 4, 1, -4 },
  { 97, 4, 4, 4, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 3, 4, 4, 1, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 3, 6, 4, 1, -5 },
  { 108, 2, 6, 4, 1, -5 },
  { 110, 3, 6, 4, 0, -5 },
  { 113, 3, 2, 4, 0, -4 },
  { 114, 3, 1, 4, 0, 0 },
  { 115, 1, 1, 4, 1, -5 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 4, 4, 0, -4 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 4, 4, 0, -4 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 4, 5, 4, 0, -4 },
  { 129, 3, 4, 4, 0, -3 },
  { 131, 3, 4, 4, 0, -4 },
  { 133, 2, 4, 4, 1, -4 },
  { 134, 2, 5, 4, 1, -4 },
  { 136, 3, 4, 4, 0, -4 },
  { 138, 2, 4, 4, 1, -4 },
  { 139, 3, 3, 4, 0, -3 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 4, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -3 },
  { 149, 3, 3, 4, 1, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 4, 4, 0, -4 },
  { 155, 2, 3, 4, 1, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 4, 3, 4, 0, -3 },
  { 162, 3, 4, 4, 0, -3 },
  { 164, 3, 3, 4, 0, -3 },
  { 166, 2, 6, 4, 1, -5 },
  { 168, 1, 6, 4, 1, -5 },
  { 169, 3, 6, 4, 0, -5 },
  { 172, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_ExtraLightItalic6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC6PT7B_H_
