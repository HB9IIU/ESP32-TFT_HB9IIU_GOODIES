#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC23PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x40, 0x00, 0xCC, 0xCC, 0x65, 0x29,
  0x48, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0xF0, 0xF0,
  0x44, 0x01, 0x10, 0x08, 0x80, 0x22, 0x0F, 0x8F, 0x84, 0x20, 0x11, 0x00,
  0x44, 0x02, 0x20, 0x08, 0x80, 0x01, 0x00, 0x10, 0x0F, 0xC1, 0x12, 0x22,
  0x12, 0x20, 0x22, 0x02, 0x20, 0x32, 0x01, 0xE0, 0x05, 0xC0, 0x44, 0x04,
  0x20, 0x42, 0x04, 0x28, 0x84, 0x48, 0xC3, 0xF0, 0x08, 0x00, 0x80, 0x0E,
  0x02, 0x22, 0x08, 0x84, 0x21, 0x08, 0x84, 0x11, 0x08, 0x24, 0x08, 0x90,
  0x0E, 0x00, 0x00, 0xF0, 0x1A, 0x20, 0x48, 0x20, 0x90, 0x42, 0x20, 0x88,
  0x42, 0x10, 0x84, 0x40, 0xF0, 0x07, 0x80, 0x21, 0x00, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x20, 0x80, 0x84, 0x07, 0x60, 0x66, 0x01, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x86, 0x05, 0x24, 0x25, 0x0F, 0x0C, 0x55, 0xA0, 0x03,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x20, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2, 0x33, 0xDC,
  0x06, 0x00, 0xA0, 0x11, 0x02, 0x10, 0x60, 0x80, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x41, 0xFF, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x29, 0x49, 0x00, 0xFC, 0xF0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x82, 0x18, 0x81, 0x20, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x21, 0x8C, 0x50,
  0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0xC1, 0xE0, 0x01, 0x80, 0xE0,
  0x34, 0x08, 0x82, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x07, 0xFF, 0x07, 0x83, 0x0C, 0x40, 0x90,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x07, 0xFE, 0x07, 0x83, 0x0C, 0x80, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x7C, 0x01, 0x80, 0x08, 0x01, 0x00, 0x20, 0x05, 0x00,
  0x90, 0x61, 0xF0, 0x00, 0x60, 0x14, 0x05, 0x01, 0x20, 0x24, 0x08, 0x82,
  0x10, 0x84, 0x20, 0x88, 0x12, 0x02, 0x7F, 0xF0, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x2F, 0x83,
  0x0C, 0x20, 0x40, 0x02, 0x00, 0x20, 0x04, 0x00, 0x48, 0x04, 0x61, 0x81,
  0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x08, 0x05, 0xF2, 0x82, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x24, 0x30, 0xF8, 0xFF, 0xF0, 0x0A,
  0x02, 0x40, 0x48, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x07, 0xC1, 0x82, 0x10, 0x12,
  0x01, 0x20, 0x12, 0x02, 0x10, 0x40, 0xF8, 0x38, 0xC4, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x2C, 0x04, 0x60, 0xC3, 0xF0, 0x0F, 0x0C, 0x34, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x05, 0x03, 0x61, 0x4F, 0xA0, 0x10, 0x04, 0x02, 0x01,
  0x01, 0x81, 0x80, 0x33, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x84, 0x42, 0x10, 0x00, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x00, 0x1F, 0x08, 0x24, 0x0A, 0x01, 0x00, 0x80, 0x20, 0x10, 0x38,
  0x10, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x80, 0x0F, 0x84,
  0x12, 0x04, 0x81, 0x40, 0x51, 0xF8, 0x86, 0x21, 0x90, 0x64, 0x19, 0x0A,
  0x42, 0x91, 0xA3, 0xA8, 0x02, 0x00, 0x40, 0x0F, 0xC0, 0x00, 0x80, 0x18,
  0x01, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x21, 0x02,
  0x1F, 0xE2, 0x02, 0x20, 0x24, 0x02, 0x40, 0x28, 0x01, 0x1F, 0xC2, 0x04,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0xFC, 0x40, 0x48, 0x05, 0x00,
  0xA0, 0x14, 0x03, 0x00, 0xA0, 0x37, 0xF8, 0x0F, 0x83, 0x08, 0x80, 0x90,
  0x14, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x0D, 0x01, 0x10, 0x41, 0xF0, 0x1F, 0x81, 0x06, 0x10, 0x22, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x44, 0x04, 0x81, 0x8F, 0xE0, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x07, 0xFC, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xFC, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x0F, 0x82, 0x08,
  0x80, 0xA0, 0x14, 0x00, 0x80, 0x20, 0x04, 0x00, 0x87, 0xD0, 0x0A, 0x01,
  0x40, 0x28, 0x09, 0x01, 0x10, 0x61, 0xF4, 0x10, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x02, 0x20, 0x23, 0xFE, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x1F, 0xF0, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFC, 0x1F, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x81, 0x20,
  0x48, 0x21, 0xF0, 0x10, 0x08, 0x80, 0x88, 0x08, 0x40, 0x82, 0x08, 0x11,
  0x80, 0x98, 0x05, 0x40, 0x52, 0x03, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x20, 0x42, 0x01, 0x10, 0x0C, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0xFF, 0x30,
  0x19, 0x81, 0x8C, 0x0C, 0x50, 0xA2, 0x89, 0x24, 0x49, 0x24, 0x48, 0xA4,
  0x46, 0x22, 0x21, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10,
  0x08, 0x10, 0x12, 0x81, 0x28, 0x12, 0x81, 0x24, 0x12, 0x42, 0x24, 0x24,
  0x22, 0x42, 0x24, 0x22, 0x42, 0x24, 0x14, 0x41, 0x48, 0x14, 0x80, 0xC8,
  0x0C, 0x0F, 0x82, 0x18, 0x81, 0x20, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0xC1, 0xE0, 0x1F,
  0xE1, 0x03, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x3F,
  0xC4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x82, 0x18, 0x81, 0x20, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0xC1, 0xE0, 0x08, 0x00, 0x88,
  0x16, 0x01, 0x80, 0x1F, 0xE1, 0x03, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x02, 0x3F, 0xC4, 0x20, 0x42, 0x04, 0x10, 0x41, 0x04, 0x08,
  0x80, 0x88, 0x04, 0x0F, 0xC1, 0x02, 0x20, 0x12, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x28, 0x04,
  0x60, 0xC3, 0xF0, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01,
  0x30, 0xC3, 0xF0, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10,
  0x42, 0x08, 0x42, 0x08, 0x41, 0x10, 0x22, 0x02, 0x80, 0x50, 0x0C, 0x01,
  0x80, 0x40, 0x14, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x42, 0x8C, 0x28,
  0xA4, 0x92, 0x49, 0x24, 0xA2, 0x4A, 0x28, 0xA2, 0x8C, 0x28, 0xC3, 0x08,
  0x10, 0x10, 0x04, 0x20, 0x20, 0x81, 0x01, 0x08, 0x04, 0x20, 0x09, 0x00,
  0x28, 0x00, 0x40, 0x03, 0x00, 0x12, 0x00, 0x48, 0x02, 0x10, 0x10, 0x40,
  0x80, 0x84, 0x02, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x90, 0x08, 0x40, 0x82,
  0x08, 0x08, 0x40, 0x44, 0x02, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFC, 0x0F,
  0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x1F, 0x80, 0x82, 0x04,
  0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20,
  0x41, 0x1F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x1F, 0x00,
  0x02, 0x00, 0xA0, 0x24, 0x08, 0x41, 0x08, 0x41, 0x10, 0x14, 0x02, 0x80,
  0x20, 0xFF, 0xE0, 0x89, 0x10, 0x1E, 0x48, 0x54, 0x0E, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x80, 0xA0, 0xCC, 0x31, 0xF7, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x13, 0xC5, 0x09, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80,
  0x60, 0x28, 0x0B, 0x04, 0xBE, 0x00, 0x1F, 0x08, 0x24, 0x0A, 0x01, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0xA0, 0x44, 0x20, 0xF0, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x3C, 0x88, 0x52, 0x06, 0x80, 0x50, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0xE6, 0x18, 0x7D, 0x00, 0x0F, 0x0C, 0x24,
  0x05, 0x01, 0x80, 0xA0, 0xCF, 0xC2, 0x00, 0x80, 0xA0, 0x24, 0x10, 0xF8,
  0x00, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x7F, 0xE0, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x02, 0x10, 0x04, 0x40, 0x09, 0x00, 0x14,
  0x00, 0x30, 0x00, 0x0F, 0x22, 0x14, 0x81, 0xA0, 0x14, 0x04, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0x48, 0x39, 0x86, 0x1F, 0x40, 0x08, 0x01, 0x00, 0x46,
  0x18, 0x3C, 0x00, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xC3, 0x89,
  0x81, 0x40, 0x50, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x11, 0x18, 0x48, 0x1C, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x88, 0x21,
  0x08, 0x34, 0x07, 0x00, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x9F, 0x14, 0x23, 0x02, 0x40, 0x48, 0x11, 0x04, 0x4F, 0x08, 0x81, 0x10,
  0x61, 0x14, 0x2C, 0x83, 0x00, 0xF8, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x11, 0x1D, 0x10, 0xB0, 0x60,
  0x00, 0x6C, 0x67, 0x39, 0x63, 0x14, 0x21, 0x42, 0x14, 0x21, 0x44, 0x28,
  0x42, 0x84, 0x28, 0x42, 0x84, 0x28, 0x42, 0x27, 0x16, 0x26, 0x05, 0x01,
  0x40, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x1F, 0x08,
  0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x24, 0x30,
  0xF0, 0x27, 0x85, 0x08, 0xC0, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01,
  0x40, 0x48, 0x09, 0x82, 0x2F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x00, 0x1E, 0x48, 0x54, 0x0E, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80,
  0xA0, 0xEC, 0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0xFB,
  0xE2, 0x80, 0x60, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x0F, 0x82, 0x0C, 0x80, 0x10, 0x02, 0x00, 0x3E,
  0x00, 0x30, 0x02, 0x00, 0x50, 0x09, 0x83, 0x0F, 0x80, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x21, 0x18, 0x46, 0x0B, 0x01, 0x80, 0x40, 0x50, 0x14, 0x05, 0x02,
  0x40, 0xA0, 0x28, 0x0A, 0x02, 0x83, 0xA0, 0x44, 0x71, 0xE4, 0xF0, 0x48,
  0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05, 0x02, 0x41, 0x10, 0xC4, 0x61,
  0xE0, 0x42, 0x28, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x41,
  0x88, 0x53, 0x0A, 0x52, 0x73, 0x80, 0x0C, 0x38, 0x92, 0x58, 0xA2, 0x06,
  0x10, 0x10, 0x81, 0x00, 0x08, 0x10, 0x40, 0x86, 0x04, 0x28, 0xD2, 0x58,
  0xE1, 0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x41, 0xC8, 0x10, 0x8E, 0x1E, 0x40, 0x08, 0x01, 0x00, 0x44, 0x18,
  0x7C, 0x00, 0x1F, 0x32, 0x1E, 0x40, 0x24, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x84, 0x20, 0x44, 0x04, 0xFE, 0x48, 0x3C, 0x07, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x3E, 0x01, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00, 0xF8, 0x11, 0x11, 0x22,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x1F, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x04, 0x00, 0xF0, 0xE0, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xE0, 0x38, 0x12, 0x41, 0x42,
  0x28, 0x22, 0x81, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 5, 6, 14, 6, -17 },
  { 13, 14, 16, 14, 0, -16 },
  { 41, 12, 20, 14, 1, -18 },
  { 71, 15, 16, 14, 0, -16 },
  { 101, 14, 16, 14, 0, -16 },
  { 129, 2, 6, 14, 7, -17 },
  { 131, 8, 20, 14, 5, -17 },
  { 151, 8, 20, 14, 1, -17 },
  { 171, 12, 11, 14, 1, -13 },
  { 188, 11, 11, 14, 2, -13 },
  { 204, 3, 6, 14, 4, -2 },
  { 207, 6, 1, 14, 4, -8 },
  { 208, 2, 2, 14, 5, -2 },
  { 209, 12, 20, 14, 1, -17 },
  { 239, 11, 16, 14, 2, -16 },
  { 261, 11, 16, 14, 1, -16 },
  { 283, 11, 16, 14, 1, -16 },
  { 305, 11, 16, 14, 1, -16 },
  { 327, 11, 16, 14, 1, -16 },
  { 349, 12, 16, 14, 1, -16 },
  { 373, 10, 16, 14, 2, -16 },
  { 393, 11, 16, 14, 3, -16 },
  { 415, 12, 16, 14, 1, -16 },
  { 439, 10, 16, 14, 2, -16 },
  { 459, 4, 12, 14, 5, -12 },
  { 465, 5, 16, 14, 4, -12 },
  { 475, 11, 12, 14, 2, -13 },
  { 492, 12, 6, 14, 1, -10 },
  { 501, 11, 12, 14, 1, -13 },
  { 518, 10, 16, 14, 3, -16 },
  { 538, 10, 18, 14, 2, -16 },
  { 561, 12, 16, 14, 0, -16 },
  { 585, 11, 16, 14, 1, -16 },
  { 607, 11, 16, 14, 2, -16 },
  { 629, 12, 16, 14, 1, -16 },
  { 653, 13, 16, 14, 1, -16 },
  { 679, 13, 16, 14, 1, -16 },
  { 705, 11, 16, 14, 2, -16 },
  { 727, 12, 16, 14, 1, -16 },
  { 751, 12, 16, 14, 1, -16 },
  { 775, 10, 16, 14, 2, -16 },
  { 795, 13, 16, 14, 1, -16 },
  { 821, 9, 16, 14, 2, -16 },
  { 839, 13, 16, 14, 1, -16 },
  { 865, 12, 16, 14, 1, -16 },
  { 889, 11, 16, 14, 2, -16 },
  { 911, 12, 16, 14, 1, -16 },
  { 935, 11, 20, 14, 2, -16 },
  { 963, 12, 16, 14, 1, -16 },
  { 987, 12, 16, 14, 1, -16 },
  { 1011, 13, 16, 14, 2, -16 },
  { 1037, 11, 16, 14, 2, -16 },
  { 1059, 11, 16, 14, 3, -16 },
  { 1081, 12, 16, 14, 2, -16 },
  { 1105, 14, 16, 14, 0, -16 },
  { 1133, 13, 16, 14, 2, -16 },
  { 1159, 14, 16, 14, 0, -16 },
  { 1187, 9, 20, 14, 4, -17 },
  { 1210, 6, 20, 14, 4, -17 },
  { 1225, 9, 20, 14, 1, -17 },
  { 1248, 11, 9, 14, 2, -16 },
  { 1261, 11, 1, 14, 0, 3 },
  { 1263, 3, 4, 14, 5, -18 },
  { 1265, 10, 12, 14, 2, -12 },
  { 1280, 10, 17, 14, 2, -17 },
  { 1302, 10, 12, 14, 2, -12 },
  { 1317, 11, 17, 14, 2, -17 },
  { 1341, 10, 12, 14, 2, -12 },
  { 1356, 14, 22, 14, 0, -17 },
  { 1395, 11, 17, 14, 1, -12 },
  { 1419, 10, 17, 14, 2, -17 },
  { 1441, 10, 18, 14, 2, -18 },
  { 1464, 10, 23, 14, 2, -18 },
  { 1493, 11, 17, 14, 2, -17 },
  { 1517, 9, 17, 14, 3, -17 },
  { 1537, 12, 12, 14, 1, -12 },
  { 1555, 10, 12, 14, 2, -12 },
  { 1570, 10, 12, 14, 2, -12 },
  { 1585, 11, 17, 14, 1, -12 },
  { 1609, 10, 17, 14, 2, -12 },
  { 1631, 11, 12, 14, 3, -12 },
  { 1648, 11, 12, 14, 1, -12 },
  { 1665, 11, 16, 14, 2, -16 },
  { 1687, 10, 12, 14, 2, -12 },
  { 1702, 10, 12, 14, 2, -12 },
  { 1717, 11, 12, 14, 2, -12 },
  { 1734, 13, 12, 14, 0, -12 },
  { 1754, 11, 17, 14, 1, -12 },
  { 1778, 12, 12, 14, 1, -12 },
  { 1796, 10, 20, 14, 3, -17 },
  { 1821, 4, 20, 14, 5, -17 },
  { 1831, 10, 20, 14, 1, -17 },
  { 1856, 12, 5, 14, 1, -9 },
};

const GFXfont IBMPlexMono_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC23PT7B_H_
