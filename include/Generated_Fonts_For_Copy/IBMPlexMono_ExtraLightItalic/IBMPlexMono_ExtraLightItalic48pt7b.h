#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC48PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0xF0, 0xE0, 0x30,
  0x66, 0x08, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x23, 0x04, 0x41, 0x98,
  0x33, 0x06, 0x60, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x08, 0x01, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x80, 0x18, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xC2, 0x3C, 0x03, 0x81, 0x07, 0x03, 0x01, 0x80, 0xC3, 0x00,
  0xC0, 0x61, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20,
  0x08, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03,
  0x81, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x3E, 0x40, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x17, 0xE0, 0x00, 0x08, 0x38, 0x00, 0x04, 0x0E,
  0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80,
  0x30, 0x00, 0x40, 0x18, 0x00, 0x20, 0x08, 0x00, 0x30, 0x0C, 0x40, 0x18,
  0x06, 0x30, 0x0C, 0x07, 0x0C, 0x04, 0x03, 0x03, 0x02, 0x07, 0x00, 0xF1,
  0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x06, 0x01, 0xC1, 0x80, 0x04,
  0x03, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x40, 0x30,
  0x06, 0x00, 0x40, 0x20, 0x04, 0x00, 0x40, 0x40, 0x04, 0x00, 0x40, 0xC0,
  0x04, 0x00, 0xC1, 0x80, 0x04, 0x00, 0xC1, 0x00, 0x04, 0x01, 0x82, 0x00,
  0x06, 0x01, 0x86, 0x00, 0x03, 0x07, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0xE0, 0xE0,
  0x00, 0x20, 0xC0, 0x60, 0x00, 0x41, 0x80, 0x20, 0x00, 0xC1, 0x00, 0x30,
  0x01, 0x83, 0x00, 0x30, 0x01, 0x03, 0x00, 0x30, 0x02, 0x03, 0x00, 0x30,
  0x06, 0x02, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x20, 0x08, 0x02, 0x00, 0x60,
  0x10, 0x03, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x60, 0x01, 0xC3, 0x80,
  0x40, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x08, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x07, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x24, 0x00, 0x0E, 0x03, 0x40, 0x00,
  0xF0, 0x36, 0x00, 0x13, 0x06, 0x60, 0x03, 0x18, 0xC3, 0x00, 0x61, 0x8C,
  0x3C, 0x0E, 0x0D, 0x81, 0xFF, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0x00, 0x33,
  0x33, 0x26, 0x66, 0x66, 0x4C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x80, 0x08, 0x01,
  0xF0, 0x18, 0x0F, 0x1E, 0x18, 0xFC, 0x03, 0xDF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x01, 0x00, 0x0C, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0xFE,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18,
  0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x1C, 0x02, 0x60,
  0x3C, 0x06, 0x60, 0x18, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40,
  0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xEC, 0x00, 0x07, 0x20, 0x00, 0x78, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x18,
  0x00, 0xE0, 0x60, 0x0F, 0x01, 0x80, 0x38, 0x04, 0x00, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x3C,
  0x01, 0xC0, 0x0E, 0x03, 0x00, 0x06, 0x06, 0x00, 0x02, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x3C, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x02,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x80, 0x01, 0x00, 0x80, 0x01,
  0x00, 0x40, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x80, 0x02, 0x00, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x7F, 0x00, 0x09,
  0xFF, 0xC0, 0x1B, 0x81, 0xE0, 0x1E, 0x00, 0x70, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC1, 0xF8, 0x06, 0x7F, 0xF0, 0x67, 0x01, 0xE3, 0x60,
  0x03, 0x1C, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0D, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x31, 0x80, 0x03, 0x0E,
  0x00, 0x30, 0x38, 0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF4, 0x00, 0x00, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x13,
  0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x06, 0x0E,
  0x00, 0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x03, 0x80, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x08, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x30, 0x70, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xC0,
  0x78, 0x38, 0x00, 0xC3, 0x80, 0x03, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0x60,
  0x00, 0xF3, 0x80, 0x0D, 0x0F, 0x01, 0xD8, 0x3F, 0xF8, 0xC0, 0x7F, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0xF1, 0xC0, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x38, 0x0E, 0x0C, 0x00, 0x63,
  0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x07, 0x00, 0xE0, 0x06, 0x07, 0x00,
  0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x31, 0x00, 0xF8, 0xCC, 0x07, 0xF3, 0x30, 0x38, 0x6C, 0x81,
  0x80, 0x66, 0x0C, 0x01, 0x98, 0x30, 0x06, 0x60, 0x80, 0x19, 0x86, 0x00,
  0x64, 0x18, 0x01, 0x90, 0x60, 0x04, 0xC1, 0x80, 0x13, 0x04, 0x00, 0x4C,
  0x10, 0x03, 0x30, 0x40, 0x0C, 0x81, 0x00, 0x72, 0x06, 0x01, 0x88, 0x18,
  0x0A, 0x20, 0x30, 0xD8, 0x80, 0xFE, 0x62, 0x00, 0xF1, 0x88, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x08, 0x00, 0x20, 0x08, 0x00, 0x60, 0x0C, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x04, 0x01,
  0x00, 0x04, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x18,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0E,
  0x08, 0x00, 0x30, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xC0, 0x01, 0xC1,
  0x80, 0x01, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x62, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0x81, 0xC0, 0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0x83, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x42, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x1C, 0x00, 0xC0, 0x1E, 0x07, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x06, 0x00, 0x70, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x40, 0x00, 0xE0, 0x40, 0x01, 0xC0, 0xC0, 0x07, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81,
  0xC0, 0x1C, 0x00, 0xC0, 0x70, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0xFF, 0xCC, 0x01, 0xFF, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x84, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x28, 0x18, 0x00, 0xB0,
  0x1C, 0x0E, 0x60, 0x1F, 0xF8, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x04,
  0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x18, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x08, 0x00, 0x38, 0x18, 0x00, 0x60, 0x38, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00,
  0xC0, 0x08, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3,
  0xC0, 0x00, 0x18, 0xD8, 0x00, 0x02, 0x31, 0x80, 0x00, 0xCC, 0x30, 0x00,
  0x1B, 0x02, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x16, 0x00,
  0x0F, 0x05, 0x80, 0x06, 0xC3, 0x20, 0x01, 0xB0, 0xC8, 0x00, 0xC8, 0x33,
  0x00, 0x22, 0x0C, 0xC0, 0x19, 0x82, 0x10, 0x0C, 0x60, 0x86, 0x03, 0x18,
  0x61, 0x81, 0x86, 0x18, 0x60, 0x41, 0x06, 0x08, 0x30, 0x41, 0x83, 0x18,
  0x30, 0x40, 0xC6, 0x0C, 0x10, 0x13, 0x03, 0x04, 0x04, 0x80, 0xC3, 0x01,
  0xE0, 0x20, 0xC0, 0x70, 0x08, 0x30, 0x0C, 0x06, 0x0C, 0x02, 0x01, 0x82,
  0x01, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x10, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x28, 0x00,
  0x08, 0x1B, 0x00, 0x02, 0x06, 0xC0, 0x01, 0x81, 0x90, 0x00, 0x60, 0x66,
  0x00, 0x18, 0x11, 0x80, 0x06, 0x04, 0x20, 0x01, 0x03, 0x0C, 0x00, 0x40,
  0xC3, 0x00, 0x30, 0x30, 0xC0, 0x0C, 0x0C, 0x18, 0x03, 0x02, 0x06, 0x00,
  0xC0, 0x81, 0x80, 0x20, 0x60, 0x30, 0x08, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x81, 0x80, 0x40, 0x60, 0x40, 0x18, 0x18, 0x10, 0x06, 0x04, 0x0C,
  0x00, 0x81, 0x03, 0x00, 0x30, 0xC0, 0xC0, 0x0C, 0x30, 0x30, 0x01, 0x0C,
  0x08, 0x00, 0x63, 0x02, 0x00, 0x18, 0x81, 0x80, 0x02, 0x20, 0x60, 0x00,
  0xD8, 0x18, 0x00, 0x36, 0x06, 0x00, 0x05, 0x81, 0x00, 0x01, 0xE0, 0x40,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xE0, 0x38, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x03,
  0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x3C, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x38, 0x01,
  0x80, 0x1C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x38,
  0x01, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x06, 0x01,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x18, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08,
  0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x60, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x05, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x86, 0x01, 0x80, 0x61, 0x80, 0x60, 0x18, 0x60, 0x3C, 0x06,
  0x18, 0x0B, 0x01, 0x06, 0x06, 0xC0, 0xC1, 0x01, 0xB0, 0x30, 0x40, 0xCC,
  0x0C, 0x10, 0x31, 0x02, 0x04, 0x08, 0x41, 0x81, 0x06, 0x10, 0x60, 0x41,
  0x04, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x33, 0x01, 0x88, 0x0C, 0xC0, 0x26, 0x03, 0x20, 0x09,
  0x80, 0xD8, 0x02, 0x60, 0x24, 0x00, 0x90, 0x0B, 0x00, 0x2C, 0x02, 0x80,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xB0, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x80, 0x01, 0x82, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x02, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x98, 0x00, 0x02, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC1, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x00, 0x7E, 0x0C,
  0x07, 0xFE, 0x30, 0x78, 0x1C, 0xC3, 0x80, 0x1B, 0x1C, 0x00, 0x28, 0x60,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x66, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x10, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x05, 0x83, 0x00, 0x64,
  0x0F, 0x03, 0x1F, 0x1F, 0xF8, 0x7C, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x0F, 0xC0, 0x18, 0xFF, 0xC0, 0x67, 0x03, 0x81,
  0xB0, 0x03, 0x06, 0x80, 0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80,
  0x00, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x38, 0x00,
  0x18, 0xE0, 0x00, 0xC3, 0x40, 0x07, 0x08, 0xC0, 0x70, 0x21, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x81, 0xC0, 0xE0,
  0x06, 0x18, 0x00, 0x23, 0x00, 0x03, 0x30, 0x00, 0x26, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x04,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x30, 0x03,
  0x03, 0xC0, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x7E, 0x04, 0x01, 0xFF, 0x8C, 0x07,
  0x81, 0xCC, 0x0E, 0x00, 0x6C, 0x0C, 0x00, 0x2C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x01, 0x60, 0x30,
  0x02, 0x60, 0x3C, 0x0C, 0x40, 0x1F, 0xF8, 0x40, 0x07, 0xE0, 0x80, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x38, 0x1C, 0x00, 0x61, 0x80, 0x03,
  0x08, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00, 0x06, 0x60, 0x00, 0x32, 0x00,
  0x03, 0x30, 0x00, 0xF1, 0x80, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x02, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE0, 0xC0, 0x0E, 0x07,
  0x81, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x0E,
  0x10, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x02, 0x01, 0xFF,
  0x8C, 0x0F, 0x03, 0x98, 0x38, 0x01, 0xB0, 0xE0, 0x01, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0B, 0x03, 0x00, 0x26, 0x07, 0x81,
  0xC8, 0x07, 0xFE, 0x10, 0x03, 0xF8, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x60,
  0x70, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC1, 0xF0, 0x0C, 0x7F, 0xC0, 0x8C, 0x0E, 0x19,
  0x00, 0x71, 0xA0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x02,
  0x30, 0x00, 0x22, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x04, 0x03, 0x00, 0x60, 0x18, 0x07, 0x80, 0x80,
  0xE0, 0x04, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x1C, 0x00, 0x19, 0xC0, 0x00,
  0xBC, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x08, 0x0E, 0x01, 0x80, 0x70, 0x18, 0x03, 0x81, 0x80,
  0x1C, 0x18, 0x00, 0xE1, 0x80, 0x03, 0x10, 0x00, 0x1B, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x1F, 0x80, 0x18, 0x7F, 0xE0, 0x19, 0xC0, 0xF0, 0x1B, 0x00, 0x30,
  0x1A, 0x00, 0x30, 0x1C, 0x00, 0x10, 0x18, 0x00, 0x10, 0x38, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x01, 0x80,
  0x20, 0x0F, 0x00, 0x60, 0x7C, 0x00, 0x61, 0xE0, 0x00, 0x60, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x40, 0x02, 0x40, 0x60, 0x07, 0xC0, 0x30, 0x0C,
  0xC0, 0x30, 0x38, 0xC0, 0x18, 0x70, 0xC0, 0x18, 0xE0, 0xC0, 0x0D, 0xC0,
  0x80, 0x07, 0x80, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x08, 0x10, 0x03, 0x0C, 0x03, 0x83,
  0x01, 0xC0, 0xC0, 0xE0, 0x20, 0xE0, 0x08, 0x70, 0x06, 0x70, 0x01, 0xB8,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x78, 0x1E, 0x04, 0xFE, 0x3F,
  0x86, 0xC3, 0x30, 0xE3, 0x40, 0xD0, 0x31, 0xC0, 0x70, 0x18, 0xC0, 0x38,
  0x04, 0x60, 0x18, 0x06, 0x20, 0x0C, 0x03, 0x30, 0x04, 0x01, 0x98, 0x02,
  0x00, 0xCC, 0x01, 0x00, 0x46, 0x01, 0x80, 0x22, 0x00, 0xC0, 0x31, 0x00,
  0x60, 0x19, 0x80, 0x20, 0x0C, 0xC0, 0x10, 0x06, 0x60, 0x18, 0x02, 0x30,
  0x0C, 0x01, 0x10, 0x06, 0x01, 0x88, 0x03, 0x00, 0xCC, 0x01, 0x00, 0x66,
  0x00, 0x80, 0x33, 0x00, 0xC0, 0x11, 0x80, 0x60, 0x08, 0x80, 0x30, 0x0C,
  0x00, 0x0C, 0x1F, 0x00, 0x87, 0xFC, 0x08, 0xC0, 0xE1, 0x90, 0x07, 0x1A,
  0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33,
  0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x02,
  0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x44, 0x00, 0x04, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x78,
  0x1C, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00,
  0x34, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x30,
  0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x81, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x02, 0x0F, 0xC0, 0x06, 0x3F, 0xF0, 0x06, 0x70, 0x38, 0x06, 0xC0,
  0x0C, 0x06, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00,
  0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x30, 0x34, 0x00, 0x70, 0x23, 0x01,
  0xC0, 0x21, 0xFF, 0x80, 0x20, 0x7E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x04, 0x07, 0xFE, 0x30, 0x78, 0x1C, 0xC3, 0x80, 0x1B, 0x0C, 0x00, 0x2C,
  0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x10, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x05, 0x83, 0x00,
  0x26, 0x0F, 0x03, 0x10, 0x1F, 0xF8, 0x40, 0x1F, 0xC3, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xF8, 0x02, 0x70, 0x00, 0x05, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x80, 0x78, 0x07, 0x83, 0x80, 0x07, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0xC7,
  0x00, 0x06, 0x0F, 0x00, 0x70, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x20, 0x0C, 0x01, 0xE0, 0x18, 0x07, 0x00, 0x20, 0x3C, 0x00, 0x40,
  0xE0, 0x01, 0x87, 0x00, 0x03, 0x3C, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33,
  0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00,
  0x18, 0x80, 0x03, 0x88, 0x00, 0x38, 0xC0, 0x05, 0x8C, 0x00, 0xD0, 0xE0,
  0x19, 0x07, 0x07, 0x30, 0x3F, 0xE3, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1B,
  0xF8, 0x00, 0x60, 0x20, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0,
  0x80, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0x40, 0x70, 0x01, 0x0F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x06, 0x06, 0x18, 0x06, 0x02,
  0x18, 0x06, 0x02, 0x10, 0x04, 0x03, 0x10, 0x04, 0x03, 0x30, 0x04, 0x03,
  0x30, 0x0C, 0x01, 0x30, 0x0C, 0x01, 0x30, 0x0C, 0x01, 0x20, 0x08, 0x01,
  0x20, 0x08, 0x01, 0x20, 0x08, 0x03, 0x60, 0x18, 0x03, 0x60, 0x18, 0x03,
  0x60, 0x18, 0x03, 0x40, 0x10, 0x03, 0x40, 0x10, 0x02, 0x40, 0x30, 0x06,
  0xC0, 0x30, 0x06, 0xC0, 0x30, 0x04, 0xC0, 0x50, 0x0C, 0xC0, 0x50, 0x18,
  0xC0, 0x90, 0x38, 0x61, 0x98, 0x70, 0x7F, 0x0F, 0xE0, 0x3E, 0x07, 0x80,
  0x00, 0x70, 0x0F, 0x00, 0x1F, 0x03, 0xF8, 0x0E, 0x61, 0xC3, 0x07, 0x06,
  0x30, 0x33, 0x80, 0xCC, 0x06, 0xC0, 0x19, 0x00, 0xC0, 0x01, 0x60, 0x18,
  0x00, 0x28, 0x03, 0x00, 0x05, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x02, 0x80,
  0x03, 0x00, 0x50, 0x00, 0x60, 0x1A, 0x00, 0x0C, 0x02, 0x60, 0x1D, 0x80,
  0xCC, 0x0E, 0x30, 0x30, 0x83, 0x03, 0x0E, 0x19, 0xC0, 0x7F, 0x83, 0xE0,
  0x07, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x20, 0x00, 0x60,
  0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0x40, 0x01, 0xC0, 0xC0,
  0x05, 0x81, 0x80, 0x0B, 0x03, 0x80, 0x64, 0x03, 0x81, 0x98, 0x03, 0xFE,
  0x30, 0x03, 0xF0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x20, 0x00, 0xE0, 0x60, 0x03, 0x80,
  0x70, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x03,
  0x07, 0xFF, 0xC3, 0x06, 0x07, 0xFB, 0x0C, 0x00, 0x7F, 0x08, 0x00, 0x1F,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x08,
  0x7F, 0x00, 0x08, 0x67, 0xF8, 0x0C, 0x40, 0x3F, 0xCC, 0x40, 0x03, 0xFC,
  0x80, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x87,
  0xF0, 0x00, 0xC7, 0x0C, 0x00, 0x43, 0x03, 0x00, 0x63, 0x00, 0xC0, 0x21,
  0x00, 0x70, 0x31, 0x80, 0x1C, 0x70, 0x80, 0x07, 0xF0, 0xC0, 0x01, 0xF0,
  0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 34, 29, 11, -34 },
  { 35, 11, 12, 29, 12, -36 },
  { 52, 28, 34, 29, 1, -34 },
  { 171, 25, 45, 29, 2, -39 },
  { 312, 32, 35, 29, -1, -34 },
  { 452, 28, 35, 29, 0, -34 },
  { 575, 4, 12, 29, 15, -36 },
  { 581, 16, 43, 29, 11, -36 },
  { 667, 16, 43, 29, 3, -36 },
  { 753, 24, 24, 29, 3, -26 },
  { 825, 23, 24, 29, 3, -27 },
  { 894, 8, 12, 29, 7, -4 },
  { 906, 13, 2, 29, 8, -16 },
  { 910, 4, 4, 29, 11, -4 },
  { 912, 26, 43, 29, 2, -36 },
  { 1052, 24, 35, 29, 3, -34 },
  { 1157, 22, 34, 29, 2, -34 },
  { 1251, 24, 34, 29, 2, -34 },
  { 1353, 24, 35, 29, 2, -34 },
  { 1458, 25, 34, 29, 1, -34 },
  { 1565, 24, 35, 29, 3, -34 },
  { 1670, 21, 35, 29, 4, -34 },
  { 1762, 22, 34, 29, 6, -34 },
  { 1856, 24, 35, 29, 3, -34 },
  { 1961, 21, 34, 29, 5, -34 },
  { 2051, 7, 26, 29, 11, -26 },
  { 2074, 11, 34, 29, 7, -26 },
  { 2121, 23, 26, 29, 4, -28 },
  { 2196, 25, 11, 29, 2, -20 },
  { 2231, 23, 26, 29, 2, -28 },
  { 2306, 19, 34, 29, 7, -34 },
  { 2387, 22, 39, 29, 4, -34 },
  { 2495, 24, 34, 29, 0, -34 },
  { 2597, 23, 34, 29, 3, -34 },
  { 2695, 23, 35, 29, 4, -34 },
  { 2796, 24, 34, 29, 3, -34 },
  { 2898, 25, 34, 29, 3, -34 },
  { 3005, 25, 34, 29, 3, -34 },
  { 3112, 23, 35, 29, 4, -34 },
  { 3213, 26, 34, 29, 2, -34 },
  { 3324, 26, 34, 29, 2, -34 },
  { 3435, 23, 35, 29, 3, -34 },
  { 3536, 27, 34, 29, 3, -34 },
  { 3651, 19, 34, 29, 5, -34 },
  { 3732, 26, 34, 29, 2, -34 },
  { 3843, 26, 34, 29, 2, -34 },
  { 3954, 24, 35, 29, 3, -34 },
  { 4059, 25, 34, 29, 3, -34 },
  { 4166, 24, 43, 29, 3, -34 },
  { 4295, 25, 34, 29, 3, -34 },
  { 4402, 25, 35, 29, 2, -34 },
  { 4512, 26, 34, 29, 5, -34 },
  { 4623, 24, 35, 29, 4, -34 },
  { 4728, 24, 34, 29, 6, -34 },
  { 4830, 26, 34, 29, 4, -34 },
  { 4941, 30, 34, 29, 0, -34 },
  { 5069, 26, 34, 29, 5, -34 },
  { 5180, 29, 34, 29, 0, -34 },
  { 5304, 19, 43, 29, 9, -36 },
  { 5407, 12, 43, 29, 9, -36 },
  { 5472, 19, 43, 29, 1, -36 },
  { 5575, 22, 18, 29, 4, -34 },
  { 5625, 23, 2, 29, 0, 5 },
  { 5631, 6, 8, 29, 11, -37 },
  { 5637, 22, 26, 29, 3, -25 },
  { 5709, 22, 37, 29, 4, -36 },
  { 5811, 20, 26, 29, 4, -25 },
  { 5876, 24, 37, 29, 3, -36 },
  { 5987, 21, 26, 29, 4, -25 },
  { 6056, 31, 46, 29, -1, -36 },
  { 6235, 23, 35, 29, 2, -25 },
  { 6336, 20, 36, 29, 4, -36 },
  { 6426, 21, 37, 29, 4, -36 },
  { 6524, 20, 46, 29, 5, -36 },
  { 6639, 24, 37, 29, 4, -36 },
  { 6750, 18, 37, 29, 6, -36 },
  { 6834, 25, 25, 29, 2, -25 },
  { 6913, 20, 25, 29, 4, -25 },
  { 6976, 21, 26, 29, 4, -25 },
  { 7045, 24, 35, 29, 2, -25 },
  { 7150, 22, 35, 29, 3, -25 },
  { 7247, 23, 25, 29, 6, -25 },
  { 7319, 22, 26, 29, 3, -25 },
  { 7391, 23, 35, 29, 4, -34 },
  { 7492, 20, 26, 29, 5, -25 },
  { 7557, 22, 25, 29, 4, -25 },
  { 7626, 24, 26, 29, 3, -25 },
  { 7704, 27, 26, 29, 1, -25 },
  { 7792, 23, 35, 29, 2, -25 },
  { 7893, 24, 26, 29, 2, -25 },
  { 7971, 21, 43, 29, 6, -36 },
  { 8084, 9, 43, 29, 10, -36 },
  { 8133, 22, 43, 29, 2, -36 },
  { 8252, 25, 9, 29, 2, -19 },
};

const GFXfont IBMPlexMono_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC48PT7B_H_
