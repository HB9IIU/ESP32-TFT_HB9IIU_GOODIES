#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC14PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x68, 0x20, 0x5A, 0xAA, 0x0B, 0x05, 0x04, 0x8E, 0x71, 0x41,
  0x23, 0x9C, 0x50, 0x48, 0x28, 0x00, 0x0C, 0x1E, 0x29, 0x48, 0x48, 0x38,
  0x0E, 0x12, 0x12, 0xD2, 0x3C, 0x10, 0x38, 0xA4, 0x92, 0x89, 0x83, 0x00,
  0x30, 0xA4, 0xA2, 0x92, 0x47, 0x00, 0x1C, 0x22, 0x22, 0x24, 0x34, 0x58,
  0x88, 0x89, 0x8D, 0x72, 0x6A, 0x19, 0x10, 0x88, 0x42, 0x10, 0x84, 0x20,
  0x86, 0x00, 0x21, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x10, 0x22, 0x4B,
  0xE3, 0x09, 0x22, 0x00, 0x10, 0x20, 0x47, 0xF2, 0x04, 0x08, 0x00, 0x68,
  0xF0, 0x80, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x3C, 0x85, 0x0C, 0x18, 0x32, 0x61, 0x42, 0x88, 0xE0,
  0x18, 0xE5, 0x24, 0x10, 0x41, 0x04, 0x23, 0xF0, 0x3C, 0x8A, 0x08, 0x20,
  0x41, 0x04, 0x30, 0x81, 0xF8, 0x3D, 0x10, 0x41, 0x38, 0x30, 0x41, 0x89,
  0xC0, 0x02, 0x06, 0x0A, 0x12, 0x24, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x3E,
  0x81, 0x05, 0xC4, 0x40, 0x81, 0x02, 0x88, 0xE0, 0x0C, 0x42, 0x10, 0xBB,
  0x18, 0x61, 0x85, 0xE0, 0xFE, 0x18, 0x84, 0x10, 0x82, 0x10, 0x82, 0x00,
  0x3C, 0x86, 0x0A, 0x23, 0x98, 0xA1, 0x42, 0x84, 0xF0, 0x3C, 0x8A, 0x0C,
  0x18, 0x4F, 0x82, 0x04, 0x10, 0xC0, 0x40, 0x08, 0x20, 0x00, 0x14, 0x80,
  0x02, 0x18, 0xC2, 0x08, 0x0C, 0x04, 0x06, 0xFE, 0x00, 0x07, 0xE0, 0x40,
  0x81, 0x81, 0x04, 0x66, 0x20, 0x3B, 0x18, 0x41, 0x08, 0x46, 0x10, 0x01,
  0x00, 0x3C, 0x49, 0x0C, 0xEA, 0x54, 0xA9, 0x52, 0x9D, 0x02, 0x03, 0xC0,
  0x04, 0x18, 0x50, 0xA2, 0x44, 0x8F, 0xA1, 0x83, 0x04, 0x7C, 0x89, 0x1C,
  0x27, 0x90, 0xA1, 0x42, 0x85, 0xF0, 0x1C, 0x49, 0x0C, 0x08, 0x10, 0x20,
  0x42, 0x88, 0xE0, 0x7C, 0x89, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x89, 0xE0,
  0x7E, 0x81, 0x04, 0x07, 0xD0, 0x20, 0x40, 0x81, 0xF8, 0x7E, 0x81, 0x04,
  0x07, 0xD0, 0x20, 0x40, 0x81, 0x00, 0x1C, 0x49, 0x0C, 0x08, 0x13, 0xA1,
  0x42, 0x84, 0xF8, 0x42, 0x86, 0x0C, 0x17, 0xD0, 0xA1, 0x42, 0x85, 0x08,
  0x7E, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x21, 0xF8, 0x3E, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x44, 0x88, 0xE0, 0x43, 0x44, 0x48, 0x90, 0xB0, 0x50,
  0x90, 0x88, 0x88, 0x84, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x83, 0xF0,
  0x43, 0x8F, 0x1D, 0x5A, 0xB2, 0xA9, 0x42, 0x85, 0x08, 0x42, 0xC6, 0x8D,
  0x19, 0x52, 0xA5, 0x4A, 0x8D, 0x08, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x61,
  0x42, 0x88, 0xE0, 0x7C, 0x85, 0x0C, 0x18, 0x2F, 0xA0, 0x40, 0x81, 0x00,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x80, 0xA0, 0x80,
  0x7C, 0x85, 0x0C, 0x18, 0x2F, 0xA4, 0x48, 0x89, 0x08, 0x1E, 0x21, 0x40,
  0x40, 0x38, 0x06, 0x02, 0x02, 0xC2, 0x3C, 0x7F, 0x90, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x42, 0x86, 0x0C, 0x18, 0x50, 0xA1, 0x42,
  0x88, 0xF0, 0x87, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0x60, 0x80, 0x81,
  0x82, 0x82, 0x92, 0xB2, 0xB4, 0xD4, 0xCC, 0xCC, 0x88, 0x21, 0x90, 0x84,
  0x82, 0x80, 0x80, 0xC0, 0x90, 0x48, 0x44, 0x41, 0x00, 0x81, 0x42, 0x44,
  0x28, 0x30, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x01, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0xFE, 0x3A, 0x10, 0x88, 0x42, 0x10, 0x84, 0x21,
  0x0E, 0x00, 0x92, 0x49, 0x12, 0x49, 0x12, 0x3C, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x04, 0xF0, 0x08, 0x70, 0x92, 0x28, 0x60, 0xFE, 0x90,
  0x3D, 0x18, 0x61, 0x8A, 0x27, 0x40, 0x41, 0x04, 0x17, 0x66, 0x18, 0x61,
  0x87, 0xE0, 0x39, 0x18, 0x20, 0x86, 0x27, 0x00, 0x02, 0x04, 0x11, 0xE4,
  0x50, 0xA1, 0x42, 0x88, 0xF0, 0x3D, 0x18, 0x7E, 0x82, 0x17, 0x80, 0x07,
  0x84, 0x02, 0x07, 0xE0, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x24, 0x0A,
  0x02, 0x00, 0x3D, 0x18, 0x61, 0x86, 0x27, 0x82, 0x89, 0xC0, 0x41, 0x04,
  0x17, 0x65, 0x18, 0x61, 0x8A, 0x20, 0x10, 0x00, 0x3C, 0x20, 0x82, 0x09,
  0x58, 0x80, 0x04, 0x00, 0x1F, 0x08, 0x20, 0x82, 0x08, 0x4D, 0x1C, 0x10,
  0x40, 0x81, 0x02, 0xE6, 0x48, 0xAE, 0x51, 0x95, 0x10, 0xE1, 0x08, 0x84,
  0x21, 0x11, 0xB2, 0x00, 0x5B, 0x6D, 0x49, 0x49, 0x92, 0x92, 0x92, 0x5D,
  0x94, 0x61, 0x86, 0x28, 0x80, 0x39, 0x18, 0x61, 0x86, 0x17, 0x80, 0x5D,
  0x98, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x00, 0x3D, 0x18, 0x61, 0x86, 0x27,
  0x82, 0x08, 0x20, 0xFD, 0x84, 0x10, 0x41, 0x08, 0x00, 0x3D, 0x14, 0x0F,
  0x06, 0x17, 0x80, 0x10, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x22, 0x58, 0x40,
  0x46, 0x18, 0x61, 0x8A, 0x67, 0x80, 0xC5, 0x14, 0x51, 0x46, 0x27, 0x00,
  0x93, 0x26, 0x4C, 0x9A, 0x34, 0xB7, 0x00, 0x13, 0x75, 0x09, 0x10, 0x90,
  0x9B, 0x6C, 0x46, 0x18, 0x61, 0x86, 0x67, 0x82, 0x9B, 0xC0, 0x7B, 0x08,
  0x20, 0x86, 0x58, 0xAF, 0x00, 0x1C, 0x82, 0x08, 0x20, 0x4E, 0x08, 0x21,
  0x08, 0x20, 0x70, 0x29, 0x24, 0x94, 0x92, 0x48, 0x38, 0x21, 0x04, 0x20,
  0x81, 0xCC, 0x40, 0x82, 0x08, 0xE0, 0x63, 0x2A, 0x30,
};

const GFXglyph IBMPlexMono_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 3, -10 },
  { 6, 9, 10, 8, 0, -10 },
  { 18, 8, 12, 8, 0, -11 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 8, 4, -10 },
  { 53, 5, 13, 8, 3, -11 },
  { 62, 4, 13, 8, 1, -11 },
  { 69, 7, 7, 8, 1, -8 },
  { 76, 7, 7, 8, 1, -8 },
  { 83, 2, 3, 8, 2, -1 },
  { 84, 4, 1, 8, 2, -5 },
  { 85, 1, 1, 8, 3, -1 },
  { 86, 8, 13, 8, 0, -11 },
  { 99, 7, 10, 8, 1, -10 },
  { 108, 6, 10, 8, 1, -10 },
  { 116, 7, 10, 8, 1, -10 },
  { 125, 6, 10, 8, 1, -10 },
  { 133, 8, 10, 8, 0, -10 },
  { 143, 7, 10, 8, 1, -10 },
  { 152, 6, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 2, -10 },
  { 168, 7, 10, 8, 1, -10 },
  { 177, 7, 10, 8, 1, -10 },
  { 186, 2, 7, 8, 3, -7 },
  { 188, 3, 9, 8, 2, -7 },
  { 192, 7, 8, 8, 1, -8 },
  { 199, 7, 4, 8, 1, -6 },
  { 203, 6, 8, 8, 1, -8 },
  { 209, 6, 10, 8, 2, -10 },
  { 217, 7, 12, 8, 1, -10 },
  { 228, 7, 10, 8, 0, -10 },
  { 237, 7, 10, 8, 1, -10 },
  { 246, 7, 10, 8, 1, -10 },
  { 255, 7, 10, 8, 1, -10 },
  { 264, 7, 10, 8, 1, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 7, 10, 8, 1, -10 },
  { 309, 7, 10, 8, 1, -10 },
  { 318, 8, 10, 8, 1, -10 },
  { 328, 6, 10, 8, 1, -10 },
  { 336, 7, 10, 8, 1, -10 },
  { 345, 7, 10, 8, 1, -10 },
  { 354, 7, 10, 8, 1, -10 },
  { 363, 7, 10, 8, 1, -10 },
  { 372, 7, 13, 8, 1, -10 },
  { 384, 7, 10, 8, 1, -10 },
  { 393, 8, 10, 8, 0, -10 },
  { 403, 8, 10, 8, 1, -10 },
  { 413, 7, 10, 8, 1, -10 },
  { 422, 7, 10, 8, 2, -10 },
  { 431, 8, 10, 8, 1, -10 },
  { 441, 9, 10, 8, 0, -10 },
  { 453, 8, 10, 8, 1, -10 },
  { 463, 8, 10, 8, 0, -10 },
  { 473, 5, 13, 8, 3, -11 },
  { 482, 3, 13, 8, 3, -11 },
  { 487, 6, 13, 8, 0, -11 },
  { 497, 7, 5, 8, 1, -10 },
  { 502, 7, 1, 8, 0, 1 },
  { 503, 2, 2, 8, 3, -11 },
  { 504, 6, 7, 8, 1, -7 },
  { 510, 6, 10, 8, 1, -10 },
  { 518, 6, 7, 8, 1, -7 },
  { 524, 7, 10, 8, 1, -10 },
  { 533, 6, 7, 8, 1, -7 },
  { 539, 9, 13, 8, 0, -10 },
  { 554, 6, 10, 8, 1, -7 },
  { 562, 6, 10, 8, 1, -10 },
  { 570, 6, 10, 8, 1, -10 },
  { 578, 6, 13, 8, 1, -10 },
  { 588, 7, 10, 8, 1, -10 },
  { 597, 5, 10, 8, 2, -10 },
  { 604, 8, 7, 8, 0, -7 },
  { 611, 6, 7, 8, 1, -7 },
  { 617, 6, 7, 8, 1, -7 },
  { 623, 6, 10, 8, 1, -7 },
  { 631, 6, 10, 8, 1, -7 },
  { 639, 6, 7, 8, 2, -7 },
  { 645, 6, 7, 8, 1, -7 },
  { 651, 7, 10, 8, 1, -10 },
  { 660, 6, 7, 8, 1, -7 },
  { 666, 6, 7, 8, 1, -7 },
  { 672, 7, 7, 8, 1, -7 },
  { 679, 8, 7, 8, 0, -7 },
  { 686, 6, 10, 8, 1, -7 },
  { 694, 7, 7, 8, 1, -7 },
  { 701, 6, 13, 8, 2, -11 },
  { 711, 3, 13, 8, 3, -11 },
  { 716, 6, 13, 8, 1, -11 },
  { 726, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC14PT7B_H_
