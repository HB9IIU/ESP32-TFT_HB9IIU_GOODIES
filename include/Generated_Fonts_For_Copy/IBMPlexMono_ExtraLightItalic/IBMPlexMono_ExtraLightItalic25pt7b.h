#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC25PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x40, 0x00, 0x0C, 0xC0,
  0x45, 0x14, 0x92, 0x8A, 0x20, 0x00, 0x8C, 0x01, 0x10, 0x04, 0x20, 0x08,
  0x80, 0x31, 0x07, 0xC3, 0xC0, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80,
  0x21, 0x07, 0xC3, 0xE0, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x21,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x0F, 0xC1, 0x91, 0x18, 0x84, 0x84,
  0x04, 0x20, 0x21, 0x01, 0x90, 0x07, 0x80, 0x0F, 0x80, 0x26, 0x01, 0x18,
  0x08, 0x40, 0x82, 0x84, 0x14, 0x21, 0x19, 0x10, 0x3F, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x00, 0x0F, 0x01, 0x10, 0x82, 0x20, 0x84, 0x20, 0x84, 0x20,
  0x88, 0x20, 0x90, 0x21, 0x20, 0x1E, 0x20, 0x00, 0x00, 0x04, 0x78, 0x08,
  0x8C, 0x09, 0x04, 0x11, 0x04, 0x21, 0x04, 0x41, 0x08, 0x41, 0x08, 0x80,
  0xF0, 0x03, 0xC0, 0x18, 0x40, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02,
  0x02, 0x08, 0x02, 0x20, 0x3B, 0x80, 0x84, 0x01, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x18, 0x70, 0x49, 0x20, 0x94, 0x3E, 0x18, 0x56, 0xA0, 0x03,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x40, 0x80, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x84, 0x17, 0x4E, 0x0F, 0x00, 0xA0, 0x12, 0x03, 0x10, 0x21, 0x0C,
  0x08, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x32, 0x44, 0x88,
  0xFE, 0x78, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x00, 0x07, 0xC1, 0x86, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x80,
  0x18, 0x61, 0x86, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x84, 0x18, 0x3E, 0x00, 0x01, 0x80, 0x38, 0x04, 0x81, 0x88, 0x30, 0x82,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x07, 0xC0, 0x83, 0x10, 0x12, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x83, 0x10,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x60, 0xF8, 0x00, 0xC0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x80, 0x46, 0x0C, 0x1F, 0x00, 0x00, 0x30,
  0x02, 0x80, 0x28, 0x02, 0x40, 0x12, 0x01, 0x10, 0x10, 0x81, 0x08, 0x10,
  0x41, 0x02, 0x10, 0x11, 0x00, 0x8F, 0xFF, 0x80, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x9E, 0x07, 0x0C, 0x20, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x13, 0x01, 0x8C, 0x18, 0x1F, 0x00, 0x00, 0xC0, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x7C, 0x70, 0xD8, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xA0, 0x12, 0x0C, 0x3E, 0x00, 0x7F, 0xF8, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x60, 0x84,
  0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x40, 0x43, 0x04, 0x07, 0xC1, 0xC3,
  0x10, 0x04, 0x80, 0x28, 0x01, 0x40, 0x09, 0x00, 0x8C, 0x08, 0x1F, 0x80,
  0x1F, 0x0C, 0x19, 0x01, 0x40, 0x28, 0x03, 0x00, 0xE0, 0x14, 0x06, 0xC1,
  0x47, 0xD0, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xE0, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x21, 0x04, 0x20, 0x80, 0x00, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08,
  0x00, 0x1F, 0x18, 0x6C, 0x0A, 0x01, 0x00, 0x40, 0x20, 0x08, 0x0C, 0x1C,
  0x04, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07,
  0xC1, 0x86, 0x10, 0x22, 0x01, 0x20, 0x14, 0x3A, 0x44, 0x64, 0x82, 0x88,
  0x28, 0x82, 0x98, 0x29, 0x04, 0x90, 0x48, 0x8C, 0x87, 0x48, 0x00, 0x80,
  0x08, 0x00, 0x60, 0x03, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x40, 0x84, 0x04, 0x3F,
  0xE3, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x08, 0x1F, 0xE1, 0x03,
  0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x3F, 0xC2, 0x06,
  0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x06, 0xFF, 0x80, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x48, 0x06, 0x40, 0xC6, 0x18, 0x1E,
  0x00, 0x3F, 0x82, 0x04, 0x20, 0x22, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0xC8,
  0x18, 0xFE, 0x00, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x7F, 0xE2, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x3F, 0xF9, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xE2, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07,
  0xC1, 0x86, 0x10, 0x32, 0x01, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x3E, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x40, 0x46, 0x1C, 0x3E,
  0x40, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80,
  0x44, 0x02, 0x3F, 0xF1, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11,
  0x00, 0x90, 0x04, 0x80, 0x20, 0x1F, 0xFC, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0xFF, 0xE0, 0x0F,
  0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x09, 0x01, 0x20, 0x66, 0x18, 0x3C, 0x00, 0x10,
  0x06, 0x20, 0x10, 0x40, 0x40, 0x81, 0x01, 0x04, 0x04, 0x30, 0x08, 0xC0,
  0x13, 0x00, 0x2A, 0x00, 0x62, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x10, 0xC0, 0x30, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xFF, 0xC0, 0x10, 0x0C, 0xC0, 0x52, 0x81, 0x8A, 0x0A,
  0x28, 0x28, 0x91, 0x22, 0x48, 0x91, 0x22, 0x45, 0x11, 0x08, 0x44, 0x21,
  0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x20, 0x18,
  0x08, 0xC0, 0x46, 0x02, 0x48, 0x12, 0x40, 0x92, 0x04, 0x88, 0x44, 0x42,
  0x22, 0x12, 0x08, 0x90, 0x44, 0x82, 0x24, 0x0A, 0x20, 0x51, 0x02, 0x90,
  0x0C, 0x80, 0x60, 0x07, 0xC1, 0x86, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x84, 0x18, 0x3E, 0x00, 0x3F, 0xE2, 0x03, 0x20, 0x12, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x67, 0xFC, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xC1, 0x86, 0x20, 0x22,
  0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x84, 0x18, 0x3E, 0x00, 0x40, 0x04, 0x60,
  0x2C, 0x01, 0x00, 0x3F, 0xE2, 0x03, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x67, 0xFC, 0x42, 0x08, 0x20, 0x81, 0x08, 0x10,
  0x80, 0x88, 0x08, 0x80, 0x40, 0x07, 0xE0, 0xC0, 0x8C, 0x02, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x40, 0x0A, 0x00, 0x8C, 0x08, 0x1F, 0x80, 0xFF, 0xF8, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x84,
  0x18, 0x3E, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x08, 0x80, 0x44, 0x04, 0x20,
  0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x08, 0x80, 0x44, 0x02, 0x40,
  0x12, 0x00, 0xA0, 0x05, 0x00, 0x10, 0x00, 0x40, 0x0D, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x11, 0x08, 0x48, 0x61, 0x22, 0x84, 0x8A, 0x22, 0x24,
  0x89, 0x12, 0x24, 0x50, 0xA1, 0x42, 0x85, 0x0C, 0x14, 0x30, 0x60, 0xC1,
  0x80, 0x10, 0x03, 0x08, 0x04, 0x08, 0x08, 0x04, 0x08, 0x04, 0x10, 0x02,
  0x20, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04,
  0x40, 0x08, 0x20, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x08, 0xC0,
  0x05, 0x00, 0x22, 0x01, 0x08, 0x08, 0x10, 0x60, 0x41, 0x01, 0x08, 0x02,
  0x40, 0x0A, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x20, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0xF8, 0x1F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x3F, 0x00, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x20,
  0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x10, 0x1F, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x3F, 0x00, 0x03, 0x00, 0x30, 0x04, 0x80, 0x88, 0x10, 0x41, 0x04, 0x20,
  0x24, 0x02, 0x80, 0x28, 0x03, 0xFF, 0xF0, 0x89, 0x10, 0x1F, 0x26, 0x15,
  0x01, 0xA0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x1A, 0x06,
  0x21, 0x43, 0xCE, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x09,
  0xE1, 0x42, 0x30, 0x2C, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C,
  0x02, 0xC0, 0x54, 0x32, 0x78, 0x00, 0x0F, 0x86, 0x19, 0x81, 0x20, 0x18,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x09, 0x02, 0x30, 0x83, 0xE0,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x1F, 0x23, 0x0A,
  0x40, 0x64, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C,
  0x81, 0x84, 0x28, 0x3C, 0x80, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x18, 0x05,
  0x07, 0x3F, 0x04, 0x00, 0x80, 0x10, 0x09, 0x02, 0x30, 0xC3, 0xE0, 0x00,
  0x7F, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1F,
  0xFE, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x82, 0x00, 0x42, 0x00, 0x24, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0F,
  0x91, 0x85, 0x20, 0x32, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x06, 0x40, 0xC2, 0x14, 0x1E, 0x40, 0x04, 0x00, 0x48, 0x08, 0x41,
  0x03, 0xE0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x09, 0xE1,
  0x42, 0x30, 0x44, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02,
  0x80, 0x50, 0x12, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x18, 0x84, 0x13, 0x02, 0x80, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x60, 0x82,
  0x20, 0x24, 0x02, 0x80, 0x30, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x27, 0x82, 0x84, 0x30, 0x26, 0x02, 0x40, 0x44, 0x08, 0x43,
  0x04, 0xC0, 0x48, 0x18, 0x41, 0x82, 0x68, 0x2C, 0x81, 0x80, 0xFC, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x0C, 0x8C, 0x26, 0x0A, 0x03, 0x00, 0x2E, 0x71,
  0x8C, 0x48, 0x42, 0xC2, 0x14, 0x10, 0xA1, 0x05, 0x08, 0x28, 0x42, 0x82,
  0x14, 0x10, 0xA0, 0x85, 0x08, 0x28, 0x41, 0x00, 0x27, 0x85, 0x08, 0xC1,
  0x10, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40,
  0x48, 0x08, 0x0F, 0x86, 0x19, 0x80, 0xA0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x50, 0x0A, 0x03, 0x30, 0xC3, 0xE0, 0x13, 0xC1, 0x42, 0x28,
  0x13, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x02, 0x60,
  0x25, 0x0C, 0x4F, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x1F,
  0x26, 0x15, 0x01, 0xA0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50,
  0x1A, 0x06, 0x21, 0x43, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0xF9, 0xF0, 0xA0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xC1, 0x83, 0x20,
  0x12, 0x00, 0x20, 0x01, 0x80, 0x07, 0xC0, 0x02, 0x00, 0x20, 0x02, 0xC0,
  0x26, 0x04, 0x1F, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x21,
  0x0C, 0x13, 0x01, 0x40, 0x18, 0x00, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x24,
  0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0xD0, 0x13, 0x06, 0x21, 0x43, 0xC8,
  0xF0, 0x22, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20,
  0x44, 0x11, 0x04, 0x23, 0x03, 0x80, 0x42, 0x14, 0x21, 0x42, 0x14, 0x21,
  0x82, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x42, 0x8C, 0x29, 0x44,
  0xE3, 0x80, 0x06, 0x1C, 0x34, 0xC9, 0x85, 0x08, 0x0C, 0x10, 0x18, 0x20,
  0x20, 0x00, 0x40, 0x00, 0x80, 0xC1, 0x01, 0x06, 0x02, 0x14, 0x32, 0x25,
  0x87, 0x8C, 0x00, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x22, 0x02, 0x40, 0x24, 0x04, 0x60, 0xC2, 0x14, 0x1E, 0x40, 0x04,
  0x00, 0x88, 0x08, 0xC3, 0x03, 0xE0, 0x1F, 0x89, 0x07, 0x88, 0x04, 0x80,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x21, 0x01, 0x18, 0x09,
  0x7E, 0x48, 0x3E, 0x00, 0x03, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x83, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7E, 0x00, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84,
  0x40, 0x0F, 0x80, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x40, 0x07, 0x83, 0x80, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x41, 0xF8, 0x00, 0x1C, 0x09, 0x30, 0x50,
  0x84, 0x82, 0x68, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 17, 15, 5, -17 },
  { 12, 6, 6, 15, 6, -19 },
  { 17, 15, 17, 15, 0, -17 },
  { 49, 13, 23, 15, 1, -20 },
  { 87, 16, 17, 15, 0, -17 },
  { 121, 15, 17, 15, 0, -17 },
  { 153, 2, 6, 15, 8, -19 },
  { 155, 8, 22, 15, 6, -19 },
  { 177, 8, 22, 15, 2, -19 },
  { 199, 12, 12, 15, 2, -14 },
  { 217, 12, 13, 15, 2, -14 },
  { 237, 4, 6, 15, 4, -2 },
  { 240, 7, 1, 15, 4, -8 },
  { 241, 3, 2, 15, 5, -2 },
  { 242, 13, 22, 15, 1, -19 },
  { 278, 12, 17, 15, 2, -17 },
  { 304, 12, 17, 15, 1, -17 },
  { 330, 12, 17, 15, 1, -17 },
  { 356, 12, 17, 15, 1, -17 },
  { 382, 13, 17, 15, 1, -17 },
  { 410, 13, 17, 15, 1, -17 },
  { 438, 11, 17, 15, 2, -17 },
  { 462, 12, 17, 15, 3, -17 },
  { 488, 13, 17, 15, 1, -17 },
  { 516, 11, 17, 15, 3, -17 },
  { 540, 5, 13, 15, 5, -13 },
  { 549, 6, 17, 15, 4, -13 },
  { 562, 12, 14, 15, 2, -15 },
  { 583, 13, 5, 15, 1, -10 },
  { 592, 12, 14, 15, 1, -15 },
  { 613, 10, 17, 15, 4, -17 },
  { 635, 12, 20, 15, 2, -17 },
  { 665, 13, 17, 15, 0, -17 },
  { 693, 12, 17, 15, 1, -17 },
  { 719, 12, 17, 15, 2, -17 },
  { 745, 12, 17, 15, 2, -17 },
  { 771, 13, 17, 15, 2, -17 },
  { 799, 13, 17, 15, 2, -17 },
  { 827, 12, 17, 15, 2, -17 },
  { 853, 13, 17, 15, 1, -17 },
  { 881, 14, 17, 15, 1, -17 },
  { 911, 11, 17, 15, 2, -17 },
  { 935, 15, 17, 15, 1, -17 },
  { 967, 10, 17, 15, 2, -17 },
  { 989, 14, 17, 15, 1, -17 },
  { 1019, 13, 17, 15, 1, -17 },
  { 1047, 12, 17, 15, 2, -17 },
  { 1073, 12, 17, 15, 2, -17 },
  { 1099, 12, 21, 15, 2, -17 },
  { 1131, 12, 17, 15, 2, -17 },
  { 1157, 13, 17, 15, 1, -17 },
  { 1185, 13, 17, 15, 3, -17 },
  { 1213, 12, 17, 15, 2, -17 },
  { 1239, 13, 17, 15, 3, -17 },
  { 1267, 14, 17, 15, 2, -17 },
  { 1297, 16, 17, 15, 0, -17 },
  { 1331, 14, 17, 15, 2, -17 },
  { 1361, 15, 17, 15, 0, -17 },
  { 1393, 10, 22, 15, 5, -19 },
  { 1421, 6, 22, 15, 5, -19 },
  { 1438, 10, 22, 15, 1, -19 },
  { 1466, 12, 10, 15, 2, -17 },
  { 1481, 12, 1, 15, 0, 3 },
  { 1483, 3, 4, 15, 6, -19 },
  { 1485, 11, 13, 15, 2, -13 },
  { 1503, 11, 19, 15, 2, -19 },
  { 1530, 11, 13, 15, 2, -13 },
  { 1548, 12, 19, 15, 2, -19 },
  { 1577, 11, 13, 15, 2, -13 },
  { 1595, 16, 24, 15, 0, -19 },
  { 1643, 12, 18, 15, 1, -13 },
  { 1670, 11, 19, 15, 2, -19 },
  { 1697, 11, 19, 15, 2, -19 },
  { 1724, 11, 24, 15, 2, -19 },
  { 1757, 12, 19, 15, 2, -19 },
  { 1786, 10, 19, 15, 3, -19 },
  { 1810, 13, 13, 15, 1, -13 },
  { 1832, 11, 13, 15, 2, -13 },
  { 1850, 11, 13, 15, 2, -13 },
  { 1868, 12, 18, 15, 1, -13 },
  { 1895, 11, 18, 15, 2, -13 },
  { 1920, 12, 13, 15, 3, -13 },
  { 1940, 12, 13, 15, 1, -13 },
  { 1960, 12, 17, 15, 2, -17 },
  { 1986, 11, 13, 15, 2, -13 },
  { 2004, 11, 13, 15, 2, -13 },
  { 2022, 12, 13, 15, 2, -13 },
  { 2042, 15, 13, 15, 0, -13 },
  { 2067, 12, 18, 15, 1, -13 },
  { 2094, 13, 13, 15, 1, -13 },
  { 2116, 11, 22, 15, 3, -19 },
  { 2147, 5, 22, 15, 5, -19 },
  { 2161, 11, 22, 15, 1, -19 },
  { 2192, 13, 5, 15, 1, -10 },
};

const GFXfont IBMPlexMono_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC25PT7B_H_
