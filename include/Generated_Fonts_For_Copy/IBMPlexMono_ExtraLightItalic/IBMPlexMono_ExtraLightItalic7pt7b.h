#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC7PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0x76, 0x7B, 0xC0, 0x2F, 0xC2, 0x5E, 0x40, 0xDF, 0x81,
  0xEF, 0x00, 0x6A, 0xEC, 0xF0, 0xC0, 0xEA, 0xA0, 0x44, 0x95, 0x00, 0x2D,
  0x2E, 0x24, 0xF4, 0xC0, 0xC0, 0x80, 0x12, 0x44, 0x88, 0xF6, 0xDC, 0x6A,
  0x24, 0xF0, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x16, 0x6A, 0x70, 0x78,
  0xE1, 0xE0, 0x53, 0x5C, 0xE9, 0x48, 0x79, 0x69, 0xE0, 0xF6, 0xA8, 0x90,
  0x42, 0x80, 0x72, 0x20, 0x7F, 0x42, 0x3C, 0xE5, 0x48, 0xFE, 0xE9, 0x80,
  0x26, 0x6A, 0xB0, 0xF9, 0x69, 0xE0, 0xF2, 0x4E, 0xE9, 0x99, 0xE0, 0xF8,
  0x78, 0xE0, 0xF8, 0x78, 0x80, 0xF2, 0x7C, 0x99, 0x7A, 0xA0, 0x72, 0x44,
  0xE0, 0x31, 0x22, 0xE0, 0x9A, 0xCA, 0xB0, 0xAA, 0xC0, 0x5F, 0xB9, 0xA0,
  0x5D, 0xDA, 0xA0, 0xF6, 0xDC, 0xF9, 0xAC, 0x80, 0xF6, 0xDD, 0xC0, 0xF9,
  0xAE, 0xA0, 0xF8, 0x61, 0xE0, 0xEA, 0x48, 0xB6, 0xEC, 0xB7, 0x68, 0xB7,
  0xEC, 0x96, 0x46, 0xB0, 0xBC, 0x48, 0x80, 0x72, 0x48, 0xF0, 0xF2, 0x49,
  0x80, 0xAA, 0x50, 0x65, 0x25, 0x80, 0xDA, 0x80, 0xE0, 0x80, 0x7A, 0xAF,
  0x9A, 0xDC, 0x56, 0x60, 0x17, 0xAA, 0xE0, 0x57, 0x60, 0x37, 0x44, 0x4C,
  0x79, 0xAA, 0xE0, 0x9A, 0xEC, 0x52, 0x4E, 0x39, 0x25, 0x80, 0x9B, 0xCE,
  0xD2, 0x4E, 0x5F, 0xDD, 0xD7, 0x60, 0x56, 0xE0, 0xAD, 0x9A, 0xC0, 0x79,
  0xAA, 0x60, 0xBA, 0x40, 0x69, 0x6F, 0x9E, 0x4E, 0xBB, 0x60, 0xB7, 0x60,
  0xBD, 0xDF, 0x5F, 0x4F, 0x9A, 0xAA, 0xE0, 0x7A, 0x4E, 0xE9, 0x69, 0x80,
  0xFC, 0x69, 0x35, 0x80, 0xD2,
};

const GFXglyph IBMPlexMono_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 1, 2, 4, 2, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 5, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 2, 6, 4, 2, -5 },
  { 20, 3, 6, 4, 0, -5 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 1, 2, 4, 1, -1 },
  { 28, 2, 1, 4, 1, -3 },
  { 29, 1, 1, 4, 1, -1 },
  { 30, 4, 6, 4, 0, -5 },
  { 33, 3, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 3, 5, 4, 1, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 3, 5, 4, 1, -5 },
  { 59, 1, 4, 4, 2, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 3, 4, 4, 1, -4 },
  { 64, 4, 2, 4, 0, -3 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 3, 6, 4, 1, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 4, 1, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 2, 5, 4, 1, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 3, 6, 4, 1, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 3, 5, 4, 1, -5 },
  { 129, 3, 5, 4, 1, -5 },
  { 131, 3, 5, 4, 1, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 1, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 3, 6, 4, 1, -5 },
  { 145, 2, 6, 4, 1, -5 },
  { 147, 3, 6, 4, 0, -5 },
  { 150, 3, 3, 4, 1, -5 },
  { 152, 3, 1, 4, 0, 0 },
  { 153, 1, 1, 4, 2, -5 },
  { 154, 4, 4, 4, 0, -4 },
  { 156, 3, 5, 4, 1, -5 },
  { 158, 3, 4, 4, 1, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 3, 4, 4, 1, -4 },
  { 165, 4, 6, 4, 0, -5 },
  { 168, 4, 5, 4, 0, -4 },
  { 171, 3, 5, 4, 1, -5 },
  { 173, 3, 5, 4, 1, -5 },
  { 175, 3, 6, 4, 1, -5 },
  { 178, 3, 5, 4, 1, -5 },
  { 180, 3, 5, 4, 1, -5 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 3, 4, 4, 1, -4 },
  { 186, 3, 4, 4, 1, -4 },
  { 188, 4, 5, 4, 0, -4 },
  { 191, 4, 5, 4, 0, -4 },
  { 194, 3, 4, 4, 1, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 3, 5, 4, 1, -5 },
  { 200, 3, 4, 4, 1, -4 },
  { 202, 3, 4, 4, 1, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 5, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 3, 6, 4, 1, -5 },
  { 216, 1, 6, 4, 2, -5 },
  { 217, 3, 6, 4, 0, -5 },
  { 220, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC7PT7B_H_
