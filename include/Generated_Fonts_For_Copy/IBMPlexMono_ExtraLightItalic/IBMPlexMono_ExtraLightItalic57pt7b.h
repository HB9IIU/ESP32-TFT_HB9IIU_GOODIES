#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC57PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E,
  0x0F, 0x81, 0xC0, 0x18, 0x19, 0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xCE, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x70, 0x73, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7C, 0x33, 0xE0, 0x03, 0x80, 0x81, 0xE0, 0x1C, 0x02, 0x01, 0x80,
  0xE0, 0x18, 0x03, 0x03, 0x00, 0x60, 0x0C, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x38, 0x08, 0x00, 0x00, 0x78, 0x60, 0x00,
  0x00, 0xFD, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x4F, 0x80, 0x00, 0x01, 0x07, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x10, 0x01, 0x00, 0x30,
  0xE0, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x06, 0x03, 0x80, 0xC0, 0x38, 0x07,
  0x03, 0x03, 0xC0, 0x0F, 0x88, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x07,
  0x07, 0x00, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x03, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0xC0, 0x00, 0x03, 0xFE,
  0x04, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0x83, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x03, 0x00,
  0x00, 0x60, 0xC0, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x10, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x00, 0x60, 0x60, 0x01, 0x80, 0x03, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x03, 0x83, 0x80, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x7F,
  0x8F, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x70, 0x02, 0xC0, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x36, 0x03,
  0xB0, 0x00, 0x13, 0x81, 0x9C, 0x00, 0x18, 0xC1, 0x86, 0x00, 0x08, 0x30,
  0xC3, 0x80, 0x1C, 0x1C, 0xC0, 0xF0, 0x3C, 0x06, 0xC0, 0x3F, 0xFC, 0x03,
  0xE0, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0x63,
  0x18, 0xC6, 0x73, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0x80, 0x60, 0x3F, 0x1F, 0x06, 0x1F, 0x80, 0x3E,
  0x6F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x0C, 0x0C, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xDF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60,
  0x07, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x60, 0x0F, 0x00, 0x66, 0x00, 0xE0,
  0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x1E, 0x30,
  0x00, 0x0F, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x03, 0xC0,
  0x60, 0x01, 0xE0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x38, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x1F, 0xE0, 0x00, 0x33, 0xFF,
  0xE0, 0x03, 0x38, 0x0F, 0x80, 0x1B, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x0C, 0x3F, 0xFC, 0x06, 0x78, 0x0F,
  0x06, 0x60, 0x01, 0xC3, 0x60, 0x00, 0x71, 0xE0, 0x00, 0x1D, 0xA0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x8E, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x01, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x05, 0x98, 0x00, 0x03, 0xCE, 0x00, 0x02, 0xC3, 0x80, 0x06, 0x60,
  0xF0, 0x0E, 0x70, 0x3F, 0xFE, 0x30, 0x07, 0xF8, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x07, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x00, 0xC7, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xE0, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x00, 0xC0, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x1F, 0x86, 0x30, 0x07, 0xF8, 0xC6, 0x03, 0xC1, 0x90, 0xC0,
  0x60, 0x0E, 0x18, 0x18, 0x01, 0xC6, 0x03, 0x00, 0x18, 0xC0, 0xC0, 0x03,
  0x18, 0x18, 0x00, 0x63, 0x03, 0x00, 0x08, 0x60, 0xC0, 0x03, 0x18, 0x18,
  0x00, 0x63, 0x03, 0x00, 0x0C, 0x60, 0x60, 0x01, 0x8C, 0x0C, 0x00, 0x31,
  0x81, 0x80, 0x0C, 0x30, 0x30, 0x01, 0x84, 0x06, 0x00, 0x31, 0x80, 0xC0,
  0x0E, 0x30, 0x18, 0x02, 0xC6, 0x03, 0x80, 0xD8, 0xC0, 0x38, 0x32, 0x18,
  0x03, 0xFC, 0xC3, 0x00, 0x3F, 0x18, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x04, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0xF0, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x30,
  0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xE6,
  0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0B, 0x03, 0x00, 0x02, 0x60, 0x70,
  0x01, 0xD8, 0x07, 0x80, 0xF3, 0x00, 0x7F, 0xF8, 0x60, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x07,
  0xC0, 0x00, 0x01, 0x8E, 0x60, 0x00, 0x00, 0xCE, 0x38, 0x00, 0x00, 0xEE,
  0x0C, 0x00, 0x00, 0x6E, 0x07, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x40, 0x00, 0x1E, 0x03,
  0x60, 0x00, 0x36, 0x03, 0x60, 0x00, 0x36, 0x03, 0x60, 0x00, 0x66, 0x02,
  0x30, 0x00, 0xC6, 0x06, 0x30, 0x00, 0xCC, 0x06, 0x30, 0x01, 0x8C, 0x06,
  0x10, 0x03, 0x8C, 0x06, 0x18, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x0C, 0x04,
  0x18, 0x06, 0x0C, 0x0C, 0x08, 0x0C, 0x18, 0x0C, 0x0C, 0x18, 0x18, 0x0C,
  0x0C, 0x18, 0x18, 0x0C, 0x0C, 0x30, 0x18, 0x0C, 0x06, 0x30, 0x18, 0x0C,
  0x06, 0x60, 0x18, 0x18, 0x06, 0xC0, 0x30, 0x18, 0x02, 0xC0, 0x30, 0x18,
  0x03, 0x80, 0x30, 0x18, 0x03, 0x80, 0x30, 0x18, 0x03, 0x00, 0x30, 0x18,
  0x02, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xC0, 0xD8,
  0x00, 0x06, 0x03, 0x60, 0x00, 0x18, 0x0D, 0x80, 0x00, 0x60, 0x63, 0x00,
  0x01, 0x81, 0x8C, 0x00, 0x06, 0x06, 0x30, 0x00, 0x18, 0x18, 0x60, 0x00,
  0xC0, 0x61, 0x80, 0x03, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0xC0, 0x03, 0x03, 0x03, 0x80, 0x18, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x18, 0x01, 0x81, 0x80, 0x70, 0x06, 0x06, 0x00,
  0xC0, 0x18, 0x18, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x18,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x30, 0x01, 0x80, 0xC0, 0xC0, 0x03, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x30, 0x00, 0x61, 0x80,
  0xC0, 0x01, 0x86, 0x06, 0x00, 0x06, 0x18, 0x18, 0x00, 0x0C, 0x60, 0x60,
  0x00, 0x31, 0x81, 0x80, 0x00, 0xC4, 0x06, 0x00, 0x01, 0xB0, 0x18, 0x00,
  0x06, 0xC0, 0xC0, 0x00, 0x1B, 0x03, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x70, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x30, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x38, 0x03, 0x06, 0x00, 0xF0, 0x06, 0x0C, 0x01, 0xE0, 0x0C, 0x18, 0x06,
  0xC0, 0x30, 0x30, 0x0D, 0x80, 0x60, 0x60, 0x13, 0x00, 0xC0, 0xC0, 0x66,
  0x01, 0x81, 0x80, 0xC4, 0x06, 0x03, 0x03, 0x08, 0x0C, 0x04, 0x06, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0xC0, 0x60, 0xC0, 0xC1,
  0x80, 0xC1, 0x81, 0x83, 0x01, 0x83, 0x03, 0x06, 0x03, 0x0C, 0x06, 0x18,
  0x06, 0x18, 0x04, 0x30, 0x0C, 0x60, 0x08, 0x60, 0x18, 0xC0, 0x18, 0x80,
  0x33, 0x00, 0x33, 0x00, 0x66, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xCC, 0x01,
  0x30, 0x01, 0x90, 0x02, 0x60, 0x03, 0x60, 0x0D, 0x80, 0x06, 0xC0, 0x1B,
  0x00, 0x0D, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x43, 0x0E, 0x18, 0x70, 0xC1, 0x86, 0x0C, 0x30,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x30, 0x3E, 0x07, 0x8C, 0x1C, 0x00,
  0x32, 0x0E, 0x00, 0x05, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x2C, 0x18, 0x00, 0x1B,
  0x07, 0x00, 0x0C, 0xC0, 0xE0, 0x06, 0x60, 0x1E, 0x07, 0x1F, 0xC3, 0xFF,
  0x83, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x07, 0xF0, 0x01,
  0x87, 0xFF, 0x00, 0x63, 0x81, 0xE0, 0x19, 0x80, 0x1C, 0x0C, 0xC0, 0x03,
  0x83, 0x60, 0x00, 0x60, 0xD0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x06, 0x1E, 0x00, 0x03, 0x86, 0x80, 0x01, 0xC1,
  0x90, 0x00, 0xE0, 0xC7, 0x80, 0xF0, 0x30, 0x7F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x78, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x38, 0x00,
  0xC0, 0x1E, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0xC0, 0x0F, 0xFE, 0x0C, 0x03,
  0xE0, 0x38, 0xC0, 0x78, 0x00, 0xCC, 0x0E, 0x00, 0x05, 0x80, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x2C, 0x06, 0x00, 0x06, 0xC0, 0x70,
  0x00, 0xCC, 0x03, 0x80, 0x18, 0xC0, 0x1E, 0x07, 0x18, 0x00, 0xFF, 0xE1,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x0E, 0xC0, 0x00, 0x3C, 0xC0, 0x01, 0xF0, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x08, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x0C,
  0x07, 0xC0, 0x71, 0x81, 0xE0, 0x03, 0x30, 0x70, 0x00, 0x2C, 0x0C, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xF0, 0x30, 0x00, 0x16, 0x07, 0x00, 0x04, 0xC0, 0x70, 0x03, 0x18,
  0x07, 0x81, 0xC6, 0x00, 0x7F, 0xF0, 0xC0, 0x03, 0xF8, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x0F, 0xE0, 0x0C, 0x3F, 0xF8, 0x0C, 0x70, 0x3C,
  0x0C, 0xC0, 0x0E, 0x0C, 0x80, 0x06, 0x0D, 0x00, 0x06, 0x0E, 0x00, 0x07,
  0x1A, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x07,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x01, 0x81, 0xE0,
  0x01, 0x83, 0x80, 0x01, 0x87, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x03, 0x00, 0x38, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x86, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x03,
  0x0F, 0xFF, 0x00, 0x18, 0xE0, 0x3C, 0x00, 0xCC, 0x00, 0x60, 0x0E, 0xC0,
  0x03, 0x80, 0x6C, 0x00, 0x0C, 0x03, 0x40, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x07, 0x80, 0x03, 0x81, 0xF0, 0x00, 0x18, 0x3C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x11,
  0x80, 0xE0, 0x01, 0xD8, 0x03, 0x00, 0x1C, 0xC0, 0x0C, 0x01, 0xC6, 0x00,
  0x60, 0x1C, 0x30, 0x01, 0x81, 0xC1, 0x80, 0x0C, 0x1C, 0x0C, 0x00, 0x31,
  0x80, 0xC0, 0x01, 0x98, 0x06, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x02, 0x06, 0x00, 0x3C, 0x18, 0x01, 0xC0, 0x60, 0x0E,
  0x01, 0x80, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x70, 0x00, 0xC3, 0x80, 0x03,
  0x3C, 0x00, 0x0D, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x19, 0xFE, 0x1F, 0xE0, 0x6C, 0x18, 0xC1, 0xC3, 0x20,
  0x36, 0x03, 0x0D, 0x00, 0xD0, 0x0C, 0x38, 0x03, 0x80, 0x30, 0xE0, 0x0E,
  0x00, 0xC3, 0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x60, 0x03, 0x00,
  0x31, 0x80, 0x08, 0x00, 0xC6, 0x00, 0x60, 0x02, 0x18, 0x01, 0x80, 0x18,
  0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01, 0x8C, 0x00, 0x60, 0x06, 0x30,
  0x01, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x43, 0x00, 0x30, 0x03, 0x0C, 0x00,
  0xC0, 0x0C, 0x20, 0x03, 0x00, 0x31, 0x80, 0x0C, 0x00, 0xC6, 0x00, 0x20,
  0x03, 0x18, 0x01, 0x80, 0x08, 0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01,
  0x84, 0x00, 0x60, 0x06, 0x30, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0x63,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x0C, 0x3F, 0xF8, 0x0C, 0x70,
  0x3C, 0x0C, 0xC0, 0x0E, 0x0C, 0x80, 0x06, 0x0D, 0x00, 0x06, 0x0E, 0x00,
  0x07, 0x1A, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x18, 0x7F, 0xF0, 0x01, 0x8E,
  0x07, 0x80, 0x19, 0x80, 0x1C, 0x01, 0x30, 0x00, 0xE0, 0x36, 0x00, 0x06,
  0x03, 0x40, 0x00, 0x70, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x38, 0x1A, 0x00,
  0x07, 0x01, 0x90, 0x00, 0xE0, 0x31, 0xE0, 0x3C, 0x03, 0x07, 0xFF, 0x00,
  0x30, 0x1F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x30, 0x3E, 0x03,
  0x8C, 0x1E, 0x00, 0x33, 0x0E, 0x00, 0x05, 0x83, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0x60, 0x00, 0x2C,
  0x18, 0x00, 0x1B, 0x07, 0x00, 0x0C, 0xC0, 0xE0, 0x06, 0x30, 0x1E, 0x07,
  0x18, 0x03, 0xFF, 0x86, 0x00, 0x3F, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC,
  0x01, 0x9E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x78, 0x00, 0xC0, 0x0E, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0x80, 0xF0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x87,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x82, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x01, 0x60, 0xC0, 0x00, 0xB0, 0x60, 0x00, 0xB0, 0x30, 0x00,
  0xD8, 0x0C, 0x00, 0xCC, 0x07, 0x81, 0xC6, 0x01, 0xFF, 0xC3, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x30,
  0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06,
  0x03, 0xC0, 0x03, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x18, 0x06, 0x18, 0x01, 0x80, 0x61, 0x80,
  0x18, 0x03, 0x18, 0x01, 0x80, 0x31, 0x80, 0x18, 0x03, 0x18, 0x01, 0x00,
  0x33, 0x00, 0x30, 0x03, 0x30, 0x03, 0x00, 0x33, 0x00, 0x30, 0x03, 0x30,
  0x03, 0x00, 0x33, 0x00, 0x30, 0x03, 0x30, 0x02, 0x00, 0x36, 0x00, 0x60,
  0x03, 0x60, 0x06, 0x00, 0x36, 0x00, 0x60, 0x03, 0x60, 0x06, 0x00, 0x36,
  0x00, 0x60, 0x03, 0x60, 0x04, 0x00, 0x3C, 0x00, 0xC0, 0x06, 0xC0, 0x0C,
  0x00, 0x6C, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0xCC, 0x01, 0xC0, 0x0C,
  0xC0, 0x1C, 0x01, 0xCC, 0x02, 0xC0, 0x18, 0xC0, 0x2C, 0x03, 0x8C, 0x04,
  0x40, 0x70, 0xE1, 0xC6, 0x0E, 0x07, 0xF8, 0x3F, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xFE, 0x01, 0xE7, 0x07,
  0x0E, 0x07, 0x83, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x38, 0x01, 0x98,
  0x03, 0x20, 0x01, 0x90, 0x03, 0x00, 0x01, 0xB0, 0x03, 0x00, 0x01, 0xA0,
  0x03, 0x00, 0x01, 0xA0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0xC0, 0x07, 0x80, 0x00, 0xC0, 0x05, 0x80, 0x00, 0xC0, 0x04, 0x80,
  0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x1E, 0xC0, 0x18, 0xC0,
  0x70, 0x60, 0x30, 0x61, 0xC0, 0x70, 0xE0, 0x67, 0x80, 0x3F, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xB0, 0x0C, 0x00,
  0x0B, 0x00, 0xC0, 0x01, 0x70, 0x0C, 0x00, 0x36, 0x00, 0xE0, 0x06, 0x60,
  0x07, 0x81, 0xC6, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0xFE, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x40,
  0x00, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x03,
  0x07, 0x01, 0xF0, 0x30, 0xE0, 0x03, 0xE3, 0x0C, 0x00, 0x07, 0xE0, 0x80,
  0x00, 0x1E, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x01, 0x07, 0xE0, 0x00, 0x18,
  0x7F, 0xE0, 0x01, 0x8C, 0x0F, 0xF0, 0x18, 0xC0, 0x0F, 0xF9, 0x8C, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x18, 0x3F, 0x80, 0x00, 0xC3, 0x8E, 0x00, 0x04,
  0x30, 0x18, 0x00, 0x61, 0x80, 0x60, 0x03, 0x18, 0x03, 0x80, 0x31, 0x80,
  0x0C, 0x03, 0x8C, 0x00, 0x30, 0x18, 0x40, 0x00, 0xE3, 0x86, 0x00, 0x03,
  0xF8, 0x30, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 40, 34, 12, -40 },
  { 51, 13, 15, 34, 14, -42 },
  { 76, 34, 40, 34, 1, -40 },
  { 246, 30, 53, 34, 2, -46 },
  { 445, 38, 41, 34, -1, -40 },
  { 640, 33, 41, 34, 1, -40 },
  { 810, 5, 15, 34, 18, -42 },
  { 820, 19, 51, 34, 13, -43 },
  { 942, 18, 51, 34, 4, -43 },
  { 1057, 28, 28, 34, 4, -31 },
  { 1155, 27, 28, 34, 4, -31 },
  { 1250, 9, 14, 34, 9, -5 },
  { 1266, 15, 2, 34, 10, -18 },
  { 1270, 5, 5, 34, 12, -5 },
  { 1274, 31, 51, 34, 2, -43 },
  { 1472, 28, 41, 34, 4, -40 },
  { 1616, 26, 40, 34, 3, -40 },
  { 1746, 29, 40, 34, 2, -40 },
  { 1891, 28, 41, 34, 2, -40 },
  { 2035, 29, 40, 34, 2, -40 },
  { 2180, 29, 41, 34, 3, -40 },
  { 2329, 25, 41, 34, 4, -40 },
  { 2458, 27, 40, 34, 7, -40 },
  { 2593, 29, 41, 34, 3, -40 },
  { 2742, 25, 40, 34, 6, -40 },
  { 2867, 10, 31, 34, 12, -31 },
  { 2906, 13, 40, 34, 9, -31 },
  { 2971, 27, 31, 34, 5, -33 },
  { 3076, 29, 13, 34, 3, -24 },
  { 3124, 27, 31, 34, 3, -33 },
  { 3229, 23, 40, 34, 8, -40 },
  { 3344, 27, 46, 34, 4, -40 },
  { 3500, 29, 40, 34, 0, -40 },
  { 3645, 28, 40, 34, 3, -40 },
  { 3785, 27, 41, 34, 5, -40 },
  { 3924, 28, 40, 34, 4, -40 },
  { 4064, 31, 40, 34, 3, -40 },
  { 4219, 31, 40, 34, 3, -40 },
  { 4374, 27, 41, 34, 5, -40 },
  { 4513, 30, 40, 34, 3, -40 },
  { 4663, 30, 40, 34, 3, -40 },
  { 4813, 27, 41, 34, 4, -40 },
  { 4952, 33, 40, 34, 3, -40 },
  { 5117, 22, 40, 34, 6, -40 },
  { 5227, 32, 40, 34, 2, -40 },
  { 5387, 30, 40, 34, 3, -40 },
  { 5537, 28, 41, 34, 4, -40 },
  { 5681, 30, 40, 34, 3, -40 },
  { 5831, 28, 50, 34, 4, -40 },
  { 6006, 30, 40, 34, 3, -40 },
  { 6156, 30, 41, 34, 2, -40 },
  { 6310, 30, 40, 34, 6, -40 },
  { 6460, 28, 41, 34, 5, -40 },
  { 6604, 28, 40, 34, 7, -40 },
  { 6744, 31, 40, 34, 4, -40 },
  { 6899, 36, 40, 34, 0, -40 },
  { 7079, 31, 40, 34, 6, -40 },
  { 7234, 34, 40, 34, 0, -40 },
  { 7404, 22, 51, 34, 11, -43 },
  { 7545, 14, 51, 34, 11, -43 },
  { 7635, 23, 51, 34, 1, -43 },
  { 7782, 27, 22, 34, 4, -40 },
  { 7857, 27, 2, 34, 0, 6 },
  { 7864, 6, 10, 34, 14, -44 },
  { 7872, 26, 31, 34, 4, -30 },
  { 7973, 26, 43, 34, 4, -42 },
  { 8113, 24, 31, 34, 5, -30 },
  { 8206, 28, 43, 34, 4, -42 },
  { 8357, 24, 31, 34, 5, -30 },
  { 8450, 36, 54, 34, -1, -42 },
  { 8693, 27, 42, 34, 3, -30 },
  { 8835, 24, 42, 34, 5, -42 },
  { 8961, 24, 43, 34, 5, -42 },
  { 9090, 24, 54, 34, 6, -42 },
  { 9252, 29, 43, 34, 4, -42 },
  { 9408, 22, 43, 34, 7, -42 },
  { 9527, 30, 30, 34, 2, -30 },
  { 9640, 24, 30, 34, 5, -30 },
  { 9730, 26, 31, 34, 4, -30 },
  { 9831, 28, 41, 34, 2, -30 },
  { 9975, 26, 41, 34, 4, -30 },
  { 10109, 27, 29, 34, 7, -29 },
  { 10207, 27, 31, 34, 3, -30 },
  { 10312, 28, 41, 34, 4, -40 },
  { 10456, 25, 30, 34, 5, -29 },
  { 10550, 25, 30, 34, 5, -30 },
  { 10644, 28, 31, 34, 4, -30 },
  { 10753, 32, 31, 34, 1, -30 },
  { 10877, 28, 41, 34, 2, -29 },
  { 11021, 28, 31, 34, 3, -30 },
  { 11130, 25, 51, 34, 7, -43 },
  { 11290, 11, 51, 34, 12, -43 },
  { 11361, 25, 51, 34, 3, -43 },
  { 11521, 29, 11, 34, 3, -23 },
};

const GFXfont IBMPlexMono_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC57PT7B_H_
