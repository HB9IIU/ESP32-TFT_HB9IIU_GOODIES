#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC11PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xFC, 0x14, 0x31, 0x99, 0x43, 0x19, 0x94, 0x28, 0x10,
  0xE5, 0x54, 0x30, 0x62, 0x6A, 0x78, 0x80, 0x73, 0x2A, 0x63, 0x00, 0xCE,
  0xA9, 0x4C, 0x39, 0x24, 0x9A, 0xB2, 0x49, 0xD9, 0xE0, 0x72, 0x49, 0x24,
  0x90, 0x44, 0x92, 0x4A, 0x50, 0x21, 0x3E, 0x4F, 0x00, 0x21, 0x09, 0xF4,
  0x21, 0x00, 0xE0, 0xE0, 0x80, 0x04, 0x10, 0x84, 0x10, 0x82, 0x10, 0x42,
  0x00, 0x32, 0x63, 0x1A, 0xC6, 0x5C, 0x33, 0x28, 0x42, 0x11, 0x1F, 0x19,
  0x90, 0x41, 0x08, 0x46, 0x3E, 0x19, 0x90, 0x4E, 0x08, 0x28, 0x9C, 0x04,
  0x62, 0x92, 0x8B, 0xF0, 0x84, 0x7C, 0x20, 0xE8, 0x86, 0x4E, 0x13, 0x21,
  0xE8, 0xC6, 0x5E, 0x7C, 0x64, 0x22, 0x21, 0x10, 0x7C, 0x62, 0xEC, 0xC6,
  0x3E, 0x74, 0x63, 0x17, 0x08, 0x88, 0x40, 0x20, 0x40, 0x2A, 0x09, 0xB1,
  0x06, 0x08, 0xF8, 0x3E, 0x83, 0x04, 0x36, 0x40, 0x69, 0x12, 0xC8, 0x08,
  0x32, 0x6F, 0x9C, 0xEA, 0xD0, 0xF0, 0x10, 0x62, 0x8A, 0x49, 0xE8, 0xA1,
  0x7C, 0x63, 0xE8, 0xC6, 0x5E, 0x32, 0x61, 0x08, 0x4A, 0x6C, 0x74, 0x63,
  0x18, 0xC6, 0x5C, 0x7C, 0x21, 0xF8, 0x42, 0x1E, 0x7E, 0x08, 0x3E, 0x82,
  0x08, 0x20, 0x32, 0x61, 0x0B, 0xC6, 0x4E, 0x8C, 0x63, 0xF8, 0xCA, 0x52,
  0x79, 0x08, 0x42, 0x21, 0x1E, 0x78, 0x42, 0x21, 0x0A, 0x5C, 0x8E, 0x4A,
  0x30, 0xA2, 0x89, 0x26, 0x48, 0x88, 0x88, 0x8F, 0x46, 0xC9, 0xB3, 0xA9,
  0x50, 0xA2, 0x44, 0x4A, 0x73, 0x5A, 0xDA, 0xD2, 0x32, 0x63, 0x18, 0xC6,
  0x5C, 0x7C, 0x63, 0x1F, 0x42, 0x10, 0x32, 0x63, 0x18, 0xC6, 0x5C, 0x28,
  0x80, 0x7C, 0x63, 0x1F, 0x52, 0x52, 0x39, 0x14, 0x0C, 0x08, 0x18, 0x9E,
  0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x8C, 0x63, 0x18, 0xCA, 0x5E, 0x86,
  0x28, 0xA4, 0x91, 0x86, 0x10, 0x86, 0x28, 0xBA, 0xEB, 0xCB, 0x24, 0x46,
  0x48, 0xA0, 0x83, 0x0A, 0x12, 0x46, 0x86, 0x25, 0x18, 0x21, 0x04, 0x10,
  0x3E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7E, 0x34, 0x44, 0x88, 0x88, 0x8E,
  0x92, 0x48, 0x92, 0x44, 0x38, 0x84, 0x21, 0x08, 0x44, 0x27, 0x00, 0x13,
  0xA5, 0x10, 0xF8, 0xC0, 0x7C, 0xA5, 0x2B, 0x74, 0xC4, 0x2D, 0x98, 0xC6,
  0x5E, 0x74, 0xA3, 0x29, 0x30, 0x08, 0x5F, 0x19, 0x4A, 0xDE, 0x74, 0x7D,
  0x09, 0x30, 0x0E, 0x21, 0xF0, 0x81, 0x04, 0x08, 0x50, 0xE0, 0xC0, 0x3D,
  0x18, 0xA2, 0x89, 0xE8, 0x9C, 0x44, 0x2C, 0x99, 0x4A, 0x52, 0x20, 0x38,
  0x84, 0x25, 0xCC, 0x08, 0x1C, 0x21, 0x08, 0x94, 0x61, 0x00, 0xC4, 0x2C,
  0x99, 0x56, 0xB2, 0xE1, 0x10, 0x84, 0x29, 0xE8, 0x7D, 0x59, 0x65, 0xA6,
  0x90, 0xB2, 0x65, 0x29, 0x48, 0x74, 0x63, 0x19, 0x30, 0x59, 0x94, 0x51,
  0x4A, 0xE8, 0x20, 0x7C, 0x65, 0x29, 0x78, 0x42, 0xFD, 0x84, 0x10, 0x41,
  0x00, 0x74, 0x58, 0x29, 0x78, 0x22, 0x3E, 0x84, 0x25, 0xC8, 0x8C, 0xA5,
  0x2B, 0x78, 0xCC, 0x63, 0x29, 0x30, 0xAD, 0x6B, 0x9C, 0xF8, 0x2D, 0xD1,
  0x68, 0xB5, 0x60, 0x45, 0x24, 0xA2, 0x59, 0xE8, 0x9C, 0x7C, 0x4C, 0x89,
  0x78, 0x19, 0x08, 0x4C, 0x11, 0x08, 0x43, 0x80, 0x55, 0x6A, 0xA0, 0x72,
  0x24, 0x34, 0x44, 0x4C, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 2, 3, 7, 3, -8 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 0, -9 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 6, 8, 7, 0, -8 },
  { 32, 1, 3, 7, 3, -8 },
  { 33, 3, 10, 7, 3, -8 },
  { 37, 3, 10, 7, 1, -8 },
  { 41, 5, 5, 7, 1, -6 },
  { 45, 5, 7, 7, 1, -7 },
  { 50, 1, 3, 7, 2, -1 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 1, 1, 7, 2, -1 },
  { 53, 6, 10, 7, 0, -8 },
  { 61, 5, 8, 7, 1, -8 },
  { 66, 5, 8, 7, 1, -8 },
  { 71, 6, 8, 7, 0, -8 },
  { 77, 6, 8, 7, 0, -8 },
  { 83, 6, 8, 7, 0, -8 },
  { 89, 5, 8, 7, 1, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 5, 8, 7, 1, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 5, 8, 7, 1, -8 },
  { 114, 2, 6, 7, 2, -6 },
  { 116, 2, 8, 7, 2, -6 },
  { 118, 5, 6, 7, 1, -6 },
  { 122, 5, 3, 7, 1, -5 },
  { 124, 5, 6, 7, 1, -6 },
  { 128, 4, 8, 7, 2, -8 },
  { 132, 5, 9, 7, 1, -8 },
  { 138, 6, 8, 7, 0, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 6, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 6, 8, 7, 1, -8 },
  { 196, 4, 8, 7, 1, -8 },
  { 200, 7, 8, 7, 0, -8 },
  { 207, 5, 8, 7, 1, -8 },
  { 212, 5, 8, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 5, 10, 7, 1, -8 },
  { 229, 5, 8, 7, 1, -8 },
  { 234, 6, 8, 7, 0, -8 },
  { 240, 6, 8, 7, 1, -8 },
  { 246, 5, 8, 7, 1, -8 },
  { 251, 6, 8, 7, 1, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 7, 8, 7, 0, -8 },
  { 270, 6, 8, 7, 1, -8 },
  { 276, 7, 8, 7, 0, -8 },
  { 283, 4, 10, 7, 2, -8 },
  { 288, 3, 10, 7, 2, -8 },
  { 292, 5, 10, 7, 0, -8 },
  { 299, 5, 4, 7, 1, -8 },
  { 302, 5, 1, 7, 0, 1 },
  { 303, 1, 2, 7, 3, -10 },
  { 304, 5, 6, 7, 1, -6 },
  { 308, 5, 8, 7, 1, -8 },
  { 313, 5, 6, 7, 1, -6 },
  { 317, 5, 8, 7, 1, -8 },
  { 322, 5, 6, 7, 1, -6 },
  { 326, 7, 10, 7, 0, -8 },
  { 335, 6, 8, 7, 0, -6 },
  { 341, 5, 8, 7, 1, -8 },
  { 346, 5, 8, 7, 1, -8 },
  { 351, 5, 10, 7, 1, -8 },
  { 358, 5, 8, 7, 1, -8 },
  { 363, 5, 8, 7, 1, -8 },
  { 368, 6, 6, 7, 0, -6 },
  { 373, 5, 6, 7, 1, -6 },
  { 377, 5, 6, 7, 1, -6 },
  { 381, 6, 8, 7, 0, -6 },
  { 387, 5, 8, 7, 1, -6 },
  { 392, 6, 6, 7, 1, -6 },
  { 397, 5, 6, 7, 1, -6 },
  { 401, 5, 8, 7, 1, -8 },
  { 406, 5, 6, 7, 1, -6 },
  { 410, 5, 6, 7, 1, -6 },
  { 414, 5, 6, 7, 1, -6 },
  { 418, 6, 6, 7, 0, -6 },
  { 423, 6, 8, 7, 0, -6 },
  { 429, 5, 6, 7, 1, -6 },
  { 433, 5, 10, 7, 1, -8 },
  { 440, 2, 10, 7, 2, -8 },
  { 443, 4, 10, 7, 1, -8 },
  { 448, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC11PT7B_H_
