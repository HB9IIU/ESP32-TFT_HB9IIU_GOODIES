#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC65PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x83, 0xF0,
  0x7E, 0x07, 0x80, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x31, 0xC0, 0x63, 0x81,
  0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x31, 0xC0, 0xE3,
  0x01, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0xC7, 0xC0, 0x01,
  0xE0, 0x10, 0x1E, 0x00, 0x78, 0x06, 0x01, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x10, 0x1C, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0x00, 0x3E, 0x18, 0x00, 0x00, 0x03, 0xFB, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0x7F, 0x00, 0x00,
  0x00, 0x60, 0xF0, 0x00, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x80, 0x03, 0x00, 0x18,
  0x38, 0x00, 0x40, 0x07, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x38, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x3C, 0x0C, 0x07, 0x80, 0x03, 0xF1,
  0x87, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0x18, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x70, 0x38, 0x0C, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x70,
  0x00, 0x00, 0x60, 0x30, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x00,
  0x07, 0x03, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0x06,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0xF0, 0x78, 0x01, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x3C, 0x00, 0x00, 0xF0, 0x6F, 0x80, 0x00, 0x0E, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0x26, 0x00, 0xD8, 0x00, 0x01, 0x38, 0x0C,
  0xE0, 0x00, 0x18, 0xE0, 0x63, 0x00, 0x01, 0x83, 0x06, 0x1C, 0x00, 0x0C,
  0x1C, 0x70, 0x70, 0x01, 0xC0, 0x63, 0x01, 0xE0, 0x3C, 0x03, 0xB0, 0x07,
  0xFF, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x19, 0xCE, 0x63,
  0x19, 0xCE, 0x73, 0x18, 0xCE, 0x73, 0x98, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0xF9, 0xF8, 0x0E, 0x03, 0xF8,
  0x1F, 0x86, 0x1F, 0xC0, 0x01, 0xFB, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0D, 0xC0, 0x0F, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x79,
  0x80, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x3C, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x07, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x06, 0x3F, 0xFF,
  0x00, 0x06, 0x70, 0x0F, 0x80, 0x0D, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x03, 0xFE, 0x00, 0x38, 0x7F, 0xFC, 0x01, 0x8F, 0x00,
  0xF8, 0x1C, 0xC0, 0x01, 0xE0, 0xCC, 0x00, 0x07, 0x86, 0xC0, 0x00, 0x1C,
  0x7C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0D, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0x1F, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00,
  0x38, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x16, 0x70, 0x00, 0x03, 0xE3, 0x80, 0x00, 0xEC, 0x3C,
  0x00, 0x1C, 0xC1, 0xF0, 0x0F, 0x98, 0x07, 0xFF, 0xE1, 0x80, 0x1F, 0xF0,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x07, 0xE0,
  0xFC, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x80, 0x78, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1E, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x07, 0xE0, 0xC7, 0x00, 0x7F, 0xE3,
  0x18, 0x03, 0xC0, 0xCC, 0x60, 0x1C, 0x01, 0xB1, 0x80, 0x60, 0x03, 0x8E,
  0x03, 0x00, 0x0E, 0x30, 0x0C, 0x00, 0x18, 0xC0, 0x60, 0x00, 0x63, 0x01,
  0x80, 0x01, 0x8C, 0x06, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x31, 0xC0, 0xC0,
  0x00, 0xC6, 0x03, 0x00, 0x03, 0x18, 0x0C, 0x00, 0x0C, 0x60, 0x30, 0x00,
  0x31, 0x80, 0xC0, 0x01, 0xC6, 0x03, 0x00, 0x06, 0x38, 0x1C, 0x00, 0x18,
  0xC0, 0x30, 0x00, 0x63, 0x00, 0xC0, 0x03, 0x8C, 0x03, 0x00, 0x1E, 0x30,
  0x0C, 0x00, 0x78, 0xC0, 0x38, 0x02, 0xC3, 0x00, 0x70, 0x3B, 0x0C, 0x00,
  0xFF, 0xCC, 0x30, 0x01, 0xFC, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x18, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x03,
  0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x18, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x3C, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0x80, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8,
  0x60, 0x00, 0xFF, 0xF8, 0x60, 0x01, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x60, 0x30, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x02, 0xC0, 0x1C, 0x00, 0x0C, 0xC0, 0x0E, 0x00, 0x18, 0xC0,
  0x07, 0x80, 0x70, 0xC0, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x7F, 0x81, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0xF8, 0x00, 0x00, 0x06, 0x0E,
  0xE0, 0x00, 0x00, 0x30, 0xE7, 0x00, 0x00, 0x01, 0x8E, 0x1C, 0x00, 0x00,
  0x1C, 0xC0, 0xE0, 0x00, 0x00, 0xEC, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1B, 0x01,
  0xB0, 0x00, 0x03, 0xB0, 0x1B, 0x80, 0x00, 0x37, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x19, 0x80, 0x00, 0x66, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x38, 0xC0,
  0x01, 0xC6, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x30, 0xC0, 0x03, 0x0E, 0x03,
  0x0E, 0x00, 0x70, 0xC0, 0x30, 0x60, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC0,
  0xC0, 0x70, 0x60, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x60, 0x38, 0x60, 0x18, 0x06,
  0x01, 0x86, 0x01, 0x80, 0xE0, 0x18, 0xC0, 0x18, 0x0C, 0x01, 0x9C, 0x01,
  0x80, 0xC0, 0x0D, 0x80, 0x38, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0xC0, 0x0F,
  0x00, 0x30, 0x0C, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x07, 0x01, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x18, 0x07, 0xC0, 0x00, 0x03, 0x00, 0xDC, 0x00, 0x00, 0x60, 0x1B, 0x80,
  0x00, 0x0C, 0x03, 0x30, 0x00, 0x03, 0x80, 0x66, 0x00, 0x00, 0x70, 0x0C,
  0xE0, 0x00, 0x0C, 0x03, 0x8C, 0x00, 0x01, 0x80, 0x61, 0x80, 0x00, 0x30,
  0x0C, 0x38, 0x00, 0x06, 0x01, 0x83, 0x00, 0x01, 0xC0, 0x30, 0x60, 0x00,
  0x38, 0x06, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x30, 0x18,
  0x00, 0x18, 0x06, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18,
  0x06, 0x00, 0x1C, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x38, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x70, 0x0C, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x70, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x30,
  0x00, 0x30, 0x38, 0x06, 0x00, 0x06, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0xC0,
  0x38, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x01, 0x83, 0x00, 0xC0, 0x00, 0x38,
  0x60, 0x18, 0x00, 0x07, 0x1C, 0x03, 0x00, 0x00, 0x63, 0x80, 0x60, 0x00,
  0x0E, 0x60, 0x1C, 0x00, 0x01, 0xCC, 0x03, 0x00, 0x00, 0x19, 0x80, 0x60,
  0x00, 0x03, 0xB0, 0x0C, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x00, 0x07, 0xC0,
  0x30, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x10, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x78, 0x01, 0xC1, 0x80,
  0x1F, 0x00, 0x30, 0x30, 0x03, 0x60, 0x06, 0x06, 0x00, 0x6C, 0x00, 0xC0,
  0xC0, 0x19, 0x80, 0x30, 0x18, 0x03, 0x30, 0x06, 0x03, 0x00, 0xC6, 0x00,
  0xC0, 0x60, 0x18, 0xC0, 0x18, 0x1C, 0x07, 0x18, 0x06, 0x03, 0x80, 0xC3,
  0x80, 0xC0, 0x60, 0x38, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x01, 0x80,
  0xC0, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x18, 0x06, 0x06, 0x03, 0x03, 0x00,
  0xC1, 0x80, 0x60, 0xE0, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0E, 0x01, 0x83,
  0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x70, 0x03, 0x1C, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x0E, 0x60, 0x01, 0x8C, 0x01, 0x8C,
  0x00, 0x33, 0x80, 0x33, 0x00, 0x06, 0x60, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0xDC, 0x00, 0x19, 0x80, 0x1B, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x83, 0x83, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0xFF,
  0xF0, 0x30, 0x0F, 0x80, 0xF1, 0xC0, 0x78, 0x00, 0x67, 0x03, 0x80, 0x00,
  0xD8, 0x1C, 0x00, 0x01, 0x60, 0xE0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x3C, 0x18,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x36, 0x03, 0x80,
  0x01, 0x98, 0x07, 0x00, 0x1C, 0x60, 0x0F, 0x01, 0xE1, 0xFC, 0x1F, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x1F, 0xC0, 0x01, 0xC3, 0xFF, 0xC0, 0x06, 0x1E, 0x07, 0xC0, 0x18, 0xE0,
  0x07, 0x80, 0x66, 0x00, 0x07, 0x01, 0xB0, 0x00, 0x1C, 0x0E, 0x80, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x1A,
  0x00, 0x00, 0xE0, 0xEC, 0x00, 0x07, 0x03, 0x18, 0x00, 0x78, 0x0C, 0x3C,
  0x07, 0xC0, 0x30, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x1E, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0xC0, 0x30, 0x00, 0x7F, 0xFC, 0x18, 0x00, 0xF8, 0x0F, 0x0C, 0x00,
  0xF0, 0x00, 0xC6, 0x00, 0xE0, 0x00, 0x37, 0x00, 0xE0, 0x00, 0x0B, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0xC0, 0x30, 0x00, 0x01, 0x60, 0x1C, 0x00, 0x01, 0xF0, 0x07, 0x00,
  0x01, 0xB0, 0x03, 0x80, 0x01, 0x98, 0x00, 0xF0, 0x01, 0x8C, 0x00, 0x3E,
  0x07, 0x86, 0x00, 0x07, 0xFF, 0x87, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x3C, 0x60, 0x00, 0x0F, 0x86, 0x00, 0x07, 0xE0, 0x60, 0x1F, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x06, 0x00, 0x3F, 0xFE, 0x0C, 0x01, 0xF0, 0x1E, 0x18, 0x07, 0x80, 0x06,
  0x70, 0x1C, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x0F,
  0x03, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x07, 0x81, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x2C, 0x03, 0x80, 0x00, 0xD8, 0x07, 0x00, 0x03, 0x30, 0x07, 0x80, 0x1C,
  0x60, 0x07, 0xC0, 0xF0, 0xC0, 0x03, 0xFF, 0xC3, 0x80, 0x01, 0xFC, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x30, 0x7F, 0xF0, 0x07,
  0x0E, 0x07, 0x80, 0x71, 0x80, 0x1C, 0x07, 0x20, 0x00, 0xE0, 0x64, 0x00,
  0x06, 0x06, 0x80, 0x00, 0x60, 0x68, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x20, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x07,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x78, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x01,
  0xFE, 0x00, 0x07, 0x07, 0xFF, 0x80, 0x06, 0x1E, 0x03, 0xC0, 0x06, 0x38,
  0x00, 0xE0, 0x06, 0x60, 0x00, 0x60, 0x06, 0xC0, 0x00, 0x70, 0x0E, 0x80,
  0x00, 0x30, 0x0F, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x38, 0x07,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x02, 0x70, 0x06,
  0x00, 0x07, 0x70, 0x07, 0x00, 0x0E, 0x60, 0x03, 0x00, 0x1C, 0x60, 0x03,
  0x80, 0x38, 0x60, 0x01, 0x80, 0x70, 0x60, 0x01, 0xC0, 0xE0, 0xE0, 0x00,
  0xC1, 0xC0, 0xE0, 0x00, 0x63, 0x80, 0xC0, 0x00, 0x77, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x20, 0x38,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xC1, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x07, 0xC0, 0x3F, 0x00, 0x63, 0xFC, 0x0F,
  0xF0, 0x1C, 0xC1, 0xC3, 0x07, 0x03, 0xA0, 0x18, 0x80, 0x60, 0x6C, 0x03,
  0x20, 0x0E, 0x0D, 0x00, 0x34, 0x00, 0xC1, 0xC0, 0x07, 0x00, 0x18, 0x38,
  0x00, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x1C,
  0x30, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x00, 0x70, 0xE0, 0x03,
  0x80, 0x0E, 0x18, 0x00, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0x80, 0x06, 0x00, 0x38,
  0x70, 0x01, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x03,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x30,
  0x60, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x03, 0x01, 0xFC,
  0x00, 0x30, 0x7F, 0xF0, 0x07, 0x0E, 0x07, 0x80, 0x71, 0x80, 0x1C, 0x06,
  0x20, 0x00, 0xE0, 0x64, 0x00, 0x06, 0x06, 0x80, 0x00, 0x60, 0x68, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x38,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x7F, 0x00, 0x01, 0x83, 0xFF, 0xC0, 0x01,
  0x87, 0x81, 0xF0, 0x01, 0x8E, 0x00, 0x78, 0x01, 0x98, 0x00, 0x1C, 0x03,
  0xB0, 0x00, 0x1C, 0x03, 0xA0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x1A,
  0x00, 0x00, 0xE0, 0x3B, 0x00, 0x01, 0xC0, 0x31, 0x80, 0x07, 0x80, 0x30,
  0xF0, 0x1F, 0x00, 0x30, 0x7F, 0xFC, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x0C, 0x00, 0xFF, 0xF8, 0x30, 0x0F, 0x80, 0xF0, 0xC0, 0x78,
  0x00, 0x67, 0x03, 0x80, 0x00, 0xD8, 0x1C, 0x00, 0x01, 0x60, 0x60, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x05, 0xC0,
  0xE0, 0x00, 0x36, 0x03, 0x80, 0x01, 0x98, 0x07, 0x80, 0x0C, 0x60, 0x0F,
  0x81, 0xE1, 0x80, 0x0F, 0xFF, 0x0E, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x63, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x01, 0xE0, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x60, 0x60, 0x00, 0x36,
  0x06, 0x00, 0x02, 0x60, 0x70, 0x00, 0x4E, 0x03, 0x80, 0x18, 0xE0, 0x1E,
  0x07, 0x0C, 0x00, 0xFF, 0xE0, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x13, 0xFF, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x30,
  0x03, 0x80, 0x00, 0xC0, 0x3C, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x30, 0x06, 0x07, 0x00,
  0x18, 0x03, 0x03, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x60, 0xC0,
  0x07, 0x00, 0x30, 0x60, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x38,
  0x00, 0xC0, 0x07, 0x18, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0x00, 0x63, 0x00, 0x1C, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x19,
  0xC0, 0x06, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x06, 0x60, 0x01, 0x80, 0x03,
  0x30, 0x00, 0xC0, 0x03, 0x98, 0x00, 0xE0, 0x01, 0x8C, 0x00, 0x60, 0x00,
  0xCE, 0x00, 0x30, 0x00, 0x66, 0x00, 0x18, 0x00, 0x33, 0x00, 0x0C, 0x00,
  0x19, 0x80, 0x06, 0x00, 0x1C, 0xC0, 0x07, 0x00, 0x0C, 0x60, 0x03, 0x00,
  0x06, 0x30, 0x01, 0x80, 0x07, 0x38, 0x00, 0xC0, 0x03, 0x18, 0x00, 0xE0,
  0x01, 0x8C, 0x00, 0x70, 0x01, 0x87, 0x00, 0x48, 0x01, 0xC3, 0x80, 0x66,
  0x00, 0xC0, 0xC0, 0x63, 0x00, 0xC0, 0x70, 0x60, 0xC1, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x01, 0xFF, 0x00, 0x1E, 0x70, 0x1C, 0x3C, 0x03, 0xC1, 0x81,
  0x80, 0x60, 0x78, 0x0E, 0x18, 0x03, 0x8F, 0x00, 0x31, 0x80, 0x0C, 0xE0,
  0x01, 0x8C, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x00, 0x66, 0x00,
  0x18, 0x00, 0x01, 0xA0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x01,
  0xB0, 0x00, 0x07, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x4C, 0x00, 0x01,
  0xC0, 0x06, 0x60, 0x00, 0x8E, 0x00, 0x23, 0x00, 0x1E, 0x70, 0x03, 0x1C,
  0x01, 0xC1, 0x80, 0x30, 0x60, 0x38, 0x0E, 0x03, 0x03, 0x87, 0x80, 0x38,
  0x70, 0x0C, 0xF0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0x60, 0x06, 0x00, 0x03, 0x60, 0x06, 0x00, 0x02,
  0x60, 0x07, 0x00, 0x04, 0xE0, 0x03, 0x80, 0x18, 0xE0, 0x01, 0xE0, 0x78,
  0xC0, 0x00, 0xFF, 0xE0, 0xC0, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x40, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0xFF, 0xFE, 0x03, 0x01, 0xC0, 0x7F,
  0x83, 0x03, 0x00, 0x07, 0xF3, 0x06, 0x00, 0x01, 0xFF, 0x06, 0x00, 0x00,
  0x3F, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x20, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0x00,
  0x18, 0x63, 0xFE, 0x00, 0x18, 0x60, 0x1F, 0xF0, 0x18, 0x60, 0x01, 0xFF,
  0x18, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0x60, 0x70,
  0xF0, 0x00, 0x18, 0x38, 0x0C, 0x00, 0x0E, 0x0C, 0x01, 0x80, 0x03, 0x06,
  0x00, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x30,
  0x70, 0x00, 0x30, 0x1C, 0x18, 0x00, 0x0F, 0x0E, 0x06, 0x00, 0x00, 0xFF,
  0x03, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 11, 45, 39, 14, -45 },
  { 63, 15, 17, 39, 16, -48 },
  { 95, 39, 45, 39, 1, -45 },
  { 315, 35, 61, 39, 2, -53 },
  { 582, 43, 47, 39, -1, -46 },
  { 835, 37, 47, 39, 1, -46 },
  { 1053, 5, 17, 39, 21, -48 },
  { 1064, 21, 58, 39, 15, -49 },
  { 1217, 21, 58, 39, 4, -49 },
  { 1370, 33, 32, 39, 4, -36 },
  { 1502, 32, 32, 39, 4, -36 },
  { 1630, 10, 17, 39, 10, -6 },
  { 1652, 18, 2, 39, 11, -21 },
  { 1657, 6, 5, 39, 14, -5 },
  { 1661, 35, 58, 39, 2, -49 },
  { 1915, 31, 47, 39, 5, -46 },
  { 2098, 30, 45, 39, 3, -45 },
  { 2267, 32, 46, 39, 3, -46 },
  { 2451, 32, 47, 39, 3, -46 },
  { 2639, 33, 45, 39, 2, -45 },
  { 2825, 32, 46, 39, 4, -45 },
  { 3009, 29, 46, 39, 5, -45 },
  { 3176, 31, 45, 39, 7, -45 },
  { 3351, 32, 47, 39, 4, -46 },
  { 3539, 28, 46, 39, 7, -46 },
  { 3700, 11, 34, 39, 14, -34 },
  { 3747, 15, 45, 39, 10, -34 },
  { 3832, 31, 35, 39, 6, -37 },
  { 3968, 34, 14, 39, 3, -27 },
  { 4028, 31, 35, 39, 3, -37 },
  { 4164, 27, 46, 39, 9, -46 },
  { 4320, 30, 53, 39, 5, -46 },
  { 4519, 33, 45, 39, 0, -45 },
  { 4705, 31, 45, 39, 4, -45 },
  { 4880, 31, 47, 39, 6, -46 },
  { 5063, 32, 45, 39, 4, -45 },
  { 5243, 34, 45, 39, 4, -45 },
  { 5435, 35, 45, 39, 4, -45 },
  { 5632, 32, 47, 39, 5, -46 },
  { 5820, 35, 45, 39, 3, -45 },
  { 6017, 35, 45, 39, 3, -45 },
  { 6214, 31, 46, 39, 4, -45 },
  { 6393, 37, 45, 39, 4, -45 },
  { 6602, 26, 45, 39, 6, -45 },
  { 6749, 36, 45, 39, 2, -45 },
  { 6952, 35, 45, 39, 3, -45 },
  { 7149, 31, 47, 39, 5, -46 },
  { 7332, 33, 45, 39, 4, -45 },
  { 7518, 31, 57, 39, 5, -46 },
  { 7739, 33, 45, 39, 4, -45 },
  { 7925, 35, 47, 39, 2, -46 },
  { 8131, 34, 45, 39, 7, -45 },
  { 8323, 33, 46, 39, 5, -45 },
  { 8513, 32, 45, 39, 8, -45 },
  { 8693, 35, 45, 39, 5, -45 },
  { 8890, 41, 45, 39, 0, -45 },
  { 9121, 36, 45, 39, 6, -45 },
  { 9324, 39, 45, 39, 0, -45 },
  { 9544, 26, 58, 39, 12, -49 },
  { 9733, 15, 58, 39, 13, -49 },
  { 9842, 26, 58, 39, 2, -49 },
  { 10031, 31, 25, 39, 5, -45 },
  { 10128, 31, 2, 39, 0, 8 },
  { 10136, 7, 11, 39, 16, -50 },
  { 10146, 30, 35, 39, 4, -34 },
  { 10278, 30, 49, 39, 5, -48 },
  { 10462, 28, 35, 39, 5, -34 },
  { 10585, 33, 49, 39, 4, -48 },
  { 10788, 28, 35, 39, 5, -34 },
  { 10911, 41, 62, 39, -1, -48 },
  { 11229, 31, 48, 39, 3, -34 },
  { 11415, 28, 48, 39, 5, -48 },
  { 11583, 27, 49, 39, 6, -48 },
  { 11749, 28, 62, 39, 6, -48 },
  { 11966, 32, 49, 39, 5, -48 },
  { 12162, 25, 49, 39, 8, -48 },
  { 12316, 35, 34, 39, 2, -34 },
  { 12465, 28, 34, 39, 5, -34 },
  { 12584, 29, 35, 39, 5, -34 },
  { 12711, 32, 47, 39, 3, -34 },
  { 12899, 30, 47, 39, 4, -34 },
  { 13076, 31, 34, 39, 8, -34 },
  { 13208, 30, 35, 39, 4, -34 },
  { 13340, 31, 46, 39, 5, -45 },
  { 13519, 28, 35, 39, 6, -34 },
  { 13642, 30, 34, 39, 5, -34 },
  { 13770, 33, 35, 39, 4, -34 },
  { 13915, 37, 35, 39, 1, -34 },
  { 14077, 32, 48, 39, 2, -34 },
  { 14269, 32, 35, 39, 3, -34 },
  { 14409, 29, 58, 39, 8, -49 },
  { 14620, 12, 58, 39, 14, -49 },
  { 14707, 29, 58, 39, 3, -49 },
  { 14918, 34, 12, 39, 3, -26 },
};

const GFXfont IBMPlexMono_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC65PT7B_H_
