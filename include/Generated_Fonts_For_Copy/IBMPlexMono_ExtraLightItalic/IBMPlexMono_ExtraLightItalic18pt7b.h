#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC18PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x80, 0x0C, 0x55, 0x99, 0x90, 0x06, 0x40, 0x90,
  0x12, 0x04, 0x83, 0x8E, 0x12, 0x04, 0x40, 0x90, 0xF3, 0xC4, 0x40, 0x90,
  0x12, 0x04, 0x40, 0x04, 0x02, 0x07, 0xC4, 0x94, 0x4A, 0x41, 0x20, 0x50,
  0x1E, 0x04, 0x82, 0x42, 0x29, 0x16, 0x90, 0xF0, 0x20, 0x10, 0x00, 0x1C,
  0x32, 0x42, 0x42, 0x44, 0x48, 0x45, 0x03, 0x80, 0x00, 0x00, 0x38, 0x14,
  0x42, 0x44, 0x48, 0x48, 0x48, 0x83, 0x80, 0x0E, 0x02, 0x20, 0x84, 0x10,
  0x81, 0x10, 0x22, 0x1F, 0x82, 0x40, 0x84, 0x10, 0x42, 0x19, 0xA2, 0xA7,
  0x88, 0xF8, 0x0C, 0x42, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x10,
  0x42, 0x30, 0x04, 0x04, 0x02, 0x19, 0x13, 0xF0, 0xC0, 0x90, 0x88, 0x42,
  0x00, 0x0C, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x20, 0x10, 0x00,
  0x6A, 0x48, 0xF8, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x0F, 0x18,
  0x88, 0x28, 0x14, 0x0C, 0x06, 0x23, 0x01, 0x81, 0x40, 0xA0, 0x48, 0x43,
  0xC0, 0x04, 0x0C, 0x34, 0x64, 0x44, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x1E, 0x10, 0x90, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x0F, 0xF0, 0x1E, 0x10, 0x90, 0x20, 0x20, 0x10, 0xF0,
  0x08, 0x02, 0x01, 0x00, 0xA0, 0x90, 0x47, 0xC0, 0x00, 0x80, 0x60, 0x28,
  0x12, 0x09, 0x04, 0x42, 0x10, 0x84, 0x41, 0x1F, 0xF8, 0x10, 0x08, 0x02,
  0x00, 0x1F, 0x90, 0x08, 0x04, 0x04, 0x02, 0xF1, 0x84, 0x02, 0x01, 0x00,
  0xA0, 0x48, 0x43, 0xC0, 0x03, 0x0C, 0x10, 0x20, 0x20, 0x5E, 0x61, 0x41,
  0x81, 0x81, 0x81, 0x42, 0x3C, 0x7F, 0xC0, 0xA0, 0x90, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x00, 0x1F, 0x10, 0x50, 0x28,
  0x14, 0x09, 0x08, 0x78, 0xC6, 0x81, 0x40, 0xA0, 0x58, 0x67, 0xC0, 0x3C,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x86, 0x7A, 0x04, 0x04, 0x08, 0x10, 0xE0,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x48, 0x88, 0x01, 0x02,
  0x0C, 0x30, 0xC0, 0x80, 0x40, 0x30, 0x08, 0x06, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x40, 0x30, 0x08, 0x06, 0x01, 0x01, 0x06, 0x18, 0x60, 0x80,
  0x38, 0x8A, 0x08, 0x10, 0x20, 0x81, 0x0C, 0x60, 0x81, 0x00, 0x04, 0x00,
  0x0F, 0x08, 0x88, 0x28, 0x14, 0x6A, 0x4A, 0x45, 0x22, 0x91, 0x48, 0xA7,
  0xD0, 0x08, 0x02, 0x00, 0xF0, 0x02, 0x03, 0x01, 0x41, 0x20, 0x90, 0x88,
  0x44, 0x42, 0x3F, 0x10, 0x50, 0x28, 0x18, 0x08, 0x3F, 0x10, 0x90, 0x28,
  0x14, 0x12, 0x09, 0xF8, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x6F, 0xE0, 0x1C,
  0x22, 0x41, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82, 0x84, 0x78,
  0x3E, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x81, 0x40, 0xA0,
  0x50, 0x4F, 0xC0, 0x3F, 0xC8, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xF1,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x00, 0x1E, 0x22, 0x41, 0x80, 0x80, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x82,
  0x86, 0x7A, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0xFC, 0x82, 0x81,
  0x40, 0xA0, 0x50, 0x28, 0x20, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x00, 0x1F, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x20, 0x88, 0x83,
  0x80, 0x20, 0x48, 0x24, 0x11, 0x08, 0x44, 0x12, 0x05, 0x81, 0x90, 0x44,
  0x20, 0x88, 0x22, 0x08, 0x81, 0x00, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x20, 0xC8, 0x26, 0x19, 0x4A, 0x52,
  0xA5, 0x29, 0x8A, 0x24, 0x81, 0x20, 0x48, 0x12, 0x04, 0x81, 0x00, 0x20,
  0xB0, 0x54, 0x2A, 0x15, 0x0A, 0x45, 0x25, 0x12, 0x85, 0x42, 0xA1, 0x50,
  0x68, 0x20, 0x0F, 0x18, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x40, 0xA0, 0x48, 0x43, 0xC0, 0x3F, 0x10, 0x48, 0x28, 0x14, 0x0A, 0x05,
  0x06, 0xFE, 0x40, 0x40, 0x20, 0x10, 0x08, 0x00, 0x0F, 0x18, 0x88, 0x28,
  0x14, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x48, 0x43, 0xC0, 0x48,
  0x2C, 0x0C, 0x3F, 0x10, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x06, 0xFE, 0x48,
  0x42, 0x21, 0x10, 0x48, 0x30, 0x1F, 0x10, 0x50, 0x28, 0x04, 0x01, 0x00,
  0x78, 0x02, 0x01, 0x00, 0xA0, 0x58, 0x43, 0xC0, 0xFF, 0x84, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x00, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78,
  0x80, 0xC0, 0xA0, 0x50, 0x24, 0x22, 0x11, 0x10, 0x88, 0x48, 0x24, 0x14,
  0x06, 0x02, 0x00, 0x40, 0x50, 0x14, 0x05, 0x02, 0x44, 0xA3, 0x29, 0x4A,
  0x54, 0xA5, 0x29, 0x4C, 0x53, 0x18, 0xC2, 0x00, 0x20, 0x22, 0x08, 0x42,
  0x04, 0x80, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x12, 0x02, 0x20, 0x84, 0x20,
  0x48, 0x08, 0x80, 0xE0, 0x24, 0x11, 0x08, 0x44, 0x0A, 0x02, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1F, 0xE4, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0F,
  0xF8, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x44, 0x44, 0x42, 0x22,
  0x21, 0x1F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0xF8, 0x04, 0x05, 0x04, 0x84, 0x22, 0x12, 0x0A,
  0x02, 0xFF, 0x80, 0x94, 0x1D, 0x63, 0x41, 0x81, 0x81, 0x82, 0x82, 0x46,
  0x7B, 0x20, 0x10, 0x08, 0x04, 0x04, 0xE2, 0x89, 0x82, 0x81, 0x40, 0xA0,
  0xA0, 0x58, 0x4B, 0xC0, 0x1E, 0x21, 0x41, 0x80, 0x80, 0x80, 0x83, 0x42,
  0x3C, 0x00, 0x80, 0x40, 0x20, 0x11, 0xD3, 0x19, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x88, 0xC7, 0xA0, 0x1E, 0x21, 0x41, 0x83, 0x7C, 0x80, 0x81, 0x42,
  0x3C, 0x01, 0xE0, 0x40, 0x08, 0x01, 0x03, 0xFE, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x81, 0x10, 0x12, 0x01, 0x40, 0x10,
  0x00, 0x1D, 0x23, 0x41, 0x81, 0x81, 0x81, 0x82, 0x46, 0x7A, 0x02, 0x02,
  0x84, 0x78, 0x20, 0x20, 0x20, 0x20, 0x2E, 0x51, 0x61, 0x41, 0x41, 0x41,
  0x42, 0x82, 0x82, 0x08, 0x00, 0x00, 0x0F, 0x02, 0x08, 0x10, 0x20, 0x44,
  0x92, 0xC2, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x91, 0x12, 0x14, 0x10, 0x20, 0x10, 0x08, 0x04, 0x04, 0xE2,
  0x89, 0x84, 0x82, 0x4E, 0x28, 0x22, 0x31, 0x28, 0x60, 0xF8, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x45, 0x12, 0xC6, 0x00, 0x5B, 0xB6, 0x52,
  0x31, 0x18, 0x8C, 0x46, 0x25, 0x22, 0x91, 0x00, 0x2E, 0x51, 0x61, 0x41,
  0x41, 0x41, 0x42, 0x82, 0x82, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0x4E, 0x28, 0x98, 0x28, 0x14, 0x0A, 0x0A, 0x05, 0x84, 0xBC,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x1D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x82,
  0x46, 0x7A, 0x02, 0x02, 0x02, 0x04, 0xF7, 0x8C, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x00, 0x1E, 0x10, 0x90, 0x2C, 0x01, 0xE0, 0x08,
  0x05, 0x02, 0x7E, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x88, 0xC5, 0x83, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xA1, 0x46, 0x74, 0xE1, 0x10, 0x48, 0x24, 0x22, 0x12, 0x09, 0x08, 0x98,
  0x78, 0x00, 0x44, 0xA4, 0x52, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x32, 0x66,
  0x00, 0x19, 0xC4, 0xCB, 0x18, 0x82, 0x20, 0x41, 0x08, 0x23, 0x14, 0xA4,
  0x73, 0x00, 0x41, 0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x46, 0x3A, 0x02,
  0x02, 0x84, 0x78, 0x3C, 0xA1, 0xD0, 0x40, 0xC0, 0x81, 0x91, 0x05, 0xE2,
  0x8F, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x08, 0x08, 0x08, 0xF0, 0x18, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x3C, 0x24, 0x94, 0x92, 0x4A, 0x49, 0x24,
  0x3E, 0x04, 0x04, 0x04, 0x08, 0x10, 0x10, 0x0F, 0x18, 0x20, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xF0, 0x30, 0xA4, 0x62, 0x50, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 4, 5, 11, 4, -13 },
  { 9, 11, 13, 11, 0, -13 },
  { 27, 9, 17, 11, 1, -15 },
  { 47, 12, 13, 11, 0, -13 },
  { 67, 11, 13, 11, 0, -13 },
  { 85, 1, 5, 11, 6, -13 },
  { 86, 6, 16, 11, 4, -14 },
  { 98, 6, 16, 11, 1, -14 },
  { 110, 9, 9, 11, 1, -10 },
  { 121, 9, 9, 11, 1, -10 },
  { 132, 3, 5, 11, 3, -2 },
  { 134, 5, 1, 11, 3, -6 },
  { 135, 2, 1, 11, 4, -1 },
  { 136, 9, 16, 11, 1, -14 },
  { 154, 9, 13, 11, 1, -13 },
  { 169, 8, 13, 11, 1, -13 },
  { 182, 9, 13, 11, 1, -13 },
  { 197, 9, 13, 11, 1, -13 },
  { 212, 10, 13, 11, 0, -13 },
  { 229, 9, 13, 11, 1, -13 },
  { 244, 8, 13, 11, 1, -13 },
  { 257, 9, 13, 11, 2, -13 },
  { 272, 9, 13, 11, 1, -13 },
  { 287, 8, 13, 11, 2, -13 },
  { 300, 3, 9, 11, 4, -9 },
  { 304, 4, 12, 11, 3, -9 },
  { 310, 8, 10, 11, 2, -11 },
  { 320, 9, 5, 11, 1, -8 },
  { 326, 8, 10, 11, 1, -11 },
  { 336, 7, 13, 11, 3, -13 },
  { 348, 9, 15, 11, 1, -13 },
  { 365, 9, 13, 11, 0, -13 },
  { 380, 9, 13, 11, 1, -13 },
  { 395, 8, 13, 11, 2, -13 },
  { 408, 9, 13, 11, 1, -13 },
  { 423, 10, 13, 11, 1, -13 },
  { 440, 10, 13, 11, 1, -13 },
  { 457, 8, 13, 11, 2, -13 },
  { 470, 9, 13, 11, 1, -13 },
  { 485, 10, 13, 11, 1, -13 },
  { 502, 9, 13, 11, 1, -13 },
  { 517, 10, 13, 11, 1, -13 },
  { 534, 7, 13, 11, 2, -13 },
  { 546, 10, 13, 11, 1, -13 },
  { 563, 9, 13, 11, 1, -13 },
  { 578, 9, 13, 11, 1, -13 },
  { 593, 9, 13, 11, 1, -13 },
  { 608, 9, 16, 11, 1, -13 },
  { 626, 9, 13, 11, 1, -13 },
  { 641, 9, 13, 11, 1, -13 },
  { 656, 9, 13, 11, 2, -13 },
  { 671, 8, 13, 11, 2, -13 },
  { 684, 9, 13, 11, 2, -13 },
  { 699, 10, 13, 11, 1, -13 },
  { 716, 11, 13, 11, 0, -13 },
  { 734, 10, 13, 11, 2, -13 },
  { 751, 11, 13, 11, 0, -13 },
  { 769, 8, 16, 11, 3, -14 },
  { 785, 4, 16, 11, 4, -14 },
  { 793, 8, 16, 11, 0, -14 },
  { 809, 9, 7, 11, 1, -13 },
  { 817, 9, 1, 11, 0, 2 },
  { 819, 2, 3, 11, 4, -14 },
  { 820, 8, 9, 11, 1, -9 },
  { 829, 9, 13, 11, 1, -13 },
  { 844, 8, 9, 11, 1, -9 },
  { 853, 9, 13, 11, 1, -13 },
  { 868, 8, 9, 11, 1, -9 },
  { 877, 11, 17, 11, 0, -13 },
  { 901, 8, 13, 11, 1, -9 },
  { 914, 8, 13, 11, 1, -13 },
  { 927, 7, 13, 11, 2, -13 },
  { 939, 7, 17, 11, 2, -13 },
  { 954, 9, 13, 11, 1, -13 },
  { 969, 7, 13, 11, 2, -13 },
  { 981, 9, 9, 11, 1, -9 },
  { 992, 8, 9, 11, 1, -9 },
  { 1001, 8, 9, 11, 1, -9 },
  { 1010, 9, 13, 11, 1, -9 },
  { 1025, 8, 13, 11, 1, -9 },
  { 1038, 9, 9, 11, 2, -9 },
  { 1049, 9, 9, 11, 1, -9 },
  { 1060, 9, 13, 11, 1, -13 },
  { 1075, 7, 9, 11, 2, -9 },
  { 1083, 9, 9, 11, 1, -9 },
  { 1094, 9, 9, 11, 1, -9 },
  { 1105, 11, 9, 11, 0, -9 },
  { 1118, 8, 13, 11, 1, -9 },
  { 1131, 9, 9, 11, 1, -9 },
  { 1142, 8, 16, 11, 2, -14 },
  { 1158, 3, 16, 11, 4, -14 },
  { 1164, 8, 16, 11, 1, -14 },
  { 1180, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC18PT7B_H_
