#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC49PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xE0, 0x30,
  0x66, 0x0C, 0xC1, 0x98, 0x22, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC,
  0x11, 0x02, 0x60, 0xCC, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x03, 0x00, 0x3F, 0xF0, 0x1F,
  0xF1, 0xFF, 0x01, 0xFF, 0x80, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x7F, 0xC0, 0x7F,
  0xE3, 0xFE, 0x03, 0xFE, 0x00, 0x30, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x86, 0x78, 0x03,
  0x81, 0x03, 0x01, 0xC0, 0x40, 0x60, 0x60, 0x10, 0x0C, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x08,
  0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0C, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x20, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x10, 0x06, 0x00, 0x04, 0x01, 0x88,
  0x01, 0x00, 0xC3, 0x00, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x0E, 0x0C, 0x0E,
  0x01, 0xE2, 0x1F, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC0,
  0x70, 0x70, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x03, 0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x60,
  0x04, 0x00, 0x60, 0x60, 0x02, 0x00, 0x20, 0x20, 0x01, 0x00, 0x10, 0x30,
  0x00, 0x80, 0x18, 0x30, 0x00, 0x40, 0x08, 0x30, 0x00, 0x30, 0x0C, 0x10,
  0x00, 0x0C, 0x1C, 0x18, 0x00, 0x03, 0xFC, 0x18, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0x83, 0xFC, 0x00, 0x01, 0x83, 0x87, 0x00, 0x01, 0x83,
  0x00, 0xC0, 0x00, 0x83, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x10, 0x00, 0xC0,
  0x80, 0x08, 0x00, 0xC0, 0xC0, 0x04, 0x00, 0x40, 0x60, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x80, 0x20,
  0x06, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x30, 0x00, 0xE0, 0xE0, 0x10,
  0x00, 0x3F, 0xE0, 0x10, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x20, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x3F, 0xDE,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x10, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01,
  0xC0, 0x24, 0x00, 0x0E, 0x01, 0xA0, 0x00, 0x58, 0x19, 0x80, 0x06, 0x61,
  0x8C, 0x00, 0x23, 0x0C, 0x30, 0x03, 0x0C, 0xC0, 0xE0, 0x70, 0x6E, 0x03,
  0xFF, 0x01, 0xE0, 0x07, 0xE0, 0x06, 0x00, 0x32, 0x66, 0x66, 0x44, 0xCC,
  0xCC, 0x80, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xF8, 0x04, 0x03, 0xCF, 0x82, 0x0F, 0x80, 0xFB, 0x7E, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38,
  0x30, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x78, 0x1E, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xE6, 0x00, 0x03, 0x8C, 0x00, 0x1E, 0x10, 0x00, 0x70, 0x20, 0x01,
  0xC0, 0xC0, 0x07, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xF0, 0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x3C, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x7F, 0x00, 0x09,
  0xFF, 0xC0, 0x1B, 0x80, 0xF0, 0x1E, 0x00, 0x30, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x60, 0x70, 0x00, 0xE0, 0x3C, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE1, 0xFC, 0x06, 0x7F, 0xF8, 0x37, 0x01, 0xE3, 0x60,
  0x03, 0x9E, 0x00, 0x0D, 0xA0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x31, 0x80, 0x03, 0x8E,
  0x00, 0x38, 0x3C, 0x07, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x32, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x98, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x03, 0x80, 0x70,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x70, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x78, 0x0E, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x98, 0x00, 0x02, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x60, 0x00, 0x51, 0xC0,
  0x06, 0xC3, 0xC0, 0x73, 0x07, 0xFF, 0x98, 0x07, 0xF8, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x1F, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0xF0, 0xE0, 0x00, 0xE0, 0x1F, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x0E, 0x03, 0xC1, 0x80, 0x0E, 0x30, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xE0,
  0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x06,
  0x00, 0x02, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x40, 0x1F, 0x11, 0x80,
  0xFF, 0x23, 0x03, 0x83, 0x46, 0x0E, 0x03, 0x88, 0x18, 0x03, 0x30, 0x60,
  0x06, 0x60, 0xC0, 0x0C, 0xC1, 0x00, 0x11, 0x82, 0x00, 0x22, 0x0C, 0x00,
  0xC4, 0x18, 0x01, 0x98, 0x30, 0x03, 0x30, 0x60, 0x06, 0x60, 0xC0, 0x08,
  0xC1, 0x80, 0x31, 0x83, 0x00, 0x62, 0x06, 0x01, 0xC4, 0x0E, 0x05, 0x88,
  0x0E, 0x3B, 0x10, 0x0F, 0xE4, 0x20, 0x07, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0C, 0x00,
  0x04, 0x06, 0x00, 0x02, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x70, 0x30, 0x00, 0x70, 0x60, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x88, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x1C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x38,
  0x01, 0xC0, 0x1E, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x06, 0x00, 0x78, 0x06, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x40, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0xC0,
  0x0F, 0xFC, 0xC0, 0x10, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00, 0xB0, 0x38,
  0x01, 0xB0, 0x1E, 0x07, 0x20, 0x0F, 0xFE, 0x20, 0x03, 0xF8, 0x40, 0x03,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x20, 0x00, 0x0C, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x00,
  0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x04, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x04,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x87, 0x80, 0x00, 0x18, 0xD8,
  0x00, 0x01, 0x98, 0xC0, 0x00, 0x13, 0x0C, 0x00, 0x03, 0x60, 0x60, 0x00,
  0x3C, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x05, 0x83, 0xC0, 0x01, 0xA0,
  0x48, 0x00, 0x24, 0x09, 0x00, 0x0D, 0x83, 0x30, 0x03, 0x30, 0x66, 0x00,
  0x46, 0x0C, 0x40, 0x18, 0xC1, 0x8C, 0x02, 0x10, 0x21, 0x80, 0xC2, 0x04,
  0x10, 0x30, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x60,
  0x60, 0xC0, 0x8C, 0x08, 0x10, 0x1B, 0x01, 0x02, 0x03, 0x40, 0x60, 0xC0,
  0x38, 0x0C, 0x18, 0x06, 0x01, 0x83, 0x00, 0x80, 0x30, 0x60, 0x10, 0x04,
  0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x00, 0x03, 0x80, 0x00, 0x40, 0xE0, 0x00, 0x30,
  0x2C, 0x00, 0x0C, 0x0B, 0x00, 0x03, 0x06, 0xC0, 0x00, 0xC1, 0x98, 0x00,
  0x20, 0x66, 0x00, 0x08, 0x19, 0x80, 0x06, 0x04, 0x30, 0x01, 0x81, 0x0C,
  0x00, 0x60, 0xC3, 0x00, 0x18, 0x30, 0x60, 0x04, 0x0C, 0x18, 0x01, 0x03,
  0x06, 0x00, 0xC0, 0x80, 0xC0, 0x30, 0x20, 0x30, 0x0C, 0x18, 0x0C, 0x03,
  0x06, 0x01, 0x00, 0x81, 0x80, 0x60, 0x20, 0x60, 0x18, 0x18, 0x10, 0x02,
  0x06, 0x04, 0x00, 0xC1, 0x83, 0x00, 0x30, 0x60, 0xC0, 0x04, 0x10, 0x30,
  0x01, 0x84, 0x0C, 0x00, 0x63, 0x02, 0x00, 0x08, 0xC0, 0x80, 0x03, 0x30,
  0x60, 0x00, 0xCC, 0x18, 0x00, 0x12, 0x06, 0x00, 0x06, 0x81, 0x80, 0x01,
  0xE0, 0x40, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0x30, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x78, 0x1E, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x10,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x3C, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xE0,
  0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0x78, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x1B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x3C, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x06, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x20, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0x38, 0x00, 0x38, 0x07, 0x80, 0x78, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x38, 0x07, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x10, 0x01, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0x18, 0x04, 0x00, 0x18, 0x0C, 0x00,
  0x08, 0x08, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xC6, 0x01, 0xC0, 0x31,
  0x80, 0x70, 0x08, 0x60, 0x3C, 0x06, 0x18, 0x0F, 0x01, 0x86, 0x06, 0x40,
  0x61, 0x81, 0x90, 0x10, 0x60, 0x44, 0x0C, 0x10, 0x31, 0x03, 0x04, 0x08,
  0x60, 0xC1, 0x06, 0x18, 0x20, 0x41, 0x06, 0x18, 0x10, 0xC1, 0x86, 0x0C,
  0x30, 0x61, 0x83, 0x18, 0x08, 0x40, 0xC6, 0x02, 0x30, 0x31, 0x00, 0x8C,
  0x0C, 0xC0, 0x22, 0x03, 0x20, 0x0C, 0x80, 0xD8, 0x03, 0x60, 0x34, 0x00,
  0xD8, 0x0B, 0x00, 0x34, 0x02, 0xC0, 0x0D, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x04, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x9C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x64, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x20, 0x01, 0x80,
  0x60, 0x06, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x06, 0x60, 0x00, 0x05,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC6, 0x18, 0xC3, 0x08, 0x61, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x0C, 0x0E,
  0x03, 0x10, 0x30, 0x01, 0x20, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x04,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x04, 0x00, 0x0A, 0x0C, 0x00, 0x14, 0x18, 0x00, 0x58, 0x18,
  0x01, 0xB0, 0x1C, 0x0E, 0x7E, 0x1F, 0xF8, 0xFC, 0x1F, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC1, 0xF8, 0x02, 0x1F, 0xF8, 0x08, 0xC0, 0xF0, 0x66,
  0x00, 0xE1, 0xA0, 0x01, 0x87, 0x80, 0x06, 0x1C, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x38, 0x00, 0x18, 0xD0, 0x00, 0xE3, 0x60, 0x07, 0x0C, 0xE0, 0x78, 0x21,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xE0,
  0x70, 0x1C, 0x00, 0xC1, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x66,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x09, 0x80, 0x00, 0x6C, 0x00, 0x06,
  0x30, 0x00, 0x61, 0x80, 0x06, 0x06, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0x81, 0x80, 0x3F, 0xF0, 0xC0, 0x38, 0x0E, 0x60, 0x38, 0x01, 0x20,
  0x30, 0x00, 0x50, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x81, 0x00, 0x02, 0xC0, 0xC0, 0x01, 0x40, 0x60, 0x01, 0x60, 0x18,
  0x01, 0xB0, 0x07, 0x03, 0x98, 0x01, 0xFF, 0x8C, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xF0, 0x3C, 0x0C, 0x00, 0x60, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x01, 0x90, 0x00, 0x19, 0x80, 0x07, 0x8C, 0x07, 0xF8, 0x7F, 0xFE,
  0x03, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x09, 0x80, 0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x03,
  0x06, 0x00, 0x30, 0x1C, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E, 0x20, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xC3, 0x03, 0xC0, 0x73, 0x07, 0x00, 0x12, 0x06, 0x00,
  0x0A, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x20, 0x00, 0x38, 0x30, 0x00,
  0x50, 0x30, 0x00, 0xB0, 0x18, 0x01, 0xB0, 0x0E, 0x07, 0x30, 0x07, 0xFE,
  0x30, 0x03, 0xF8, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0x78, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x07, 0xE0, 0x18, 0xFF, 0xC0, 0xCE, 0x0E, 0x06, 0xC0, 0x18, 0x2C,
  0x00, 0xC3, 0x40, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00,
  0x46, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x04, 0x03, 0x00, 0x30, 0x18,
  0x07, 0x00, 0xC0, 0x70, 0x04, 0x0F, 0x00, 0x20, 0xE0, 0x03, 0x0E, 0x00,
  0x19, 0xC0, 0x00, 0xDC, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x70, 0x06, 0x01, 0xC0, 0x20, 0x07, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x38,
  0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x1F, 0x80, 0x0C, 0x7F, 0xE0,
  0x08, 0xE0, 0x70, 0x19, 0x80, 0x30, 0x1B, 0x00, 0x18, 0x1E, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x20, 0x1E, 0x00,
  0x20, 0xF8, 0x00, 0x61, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x40, 0x02,
  0x60, 0x60, 0x03, 0x40, 0x30, 0x07, 0x40, 0x30, 0x0C, 0xC0, 0x18, 0x18,
  0xC0, 0x18, 0x30, 0xC0, 0x0C, 0x60, 0xC0, 0x0C, 0xC0, 0x80, 0x07, 0x80,
  0x00, 0x03, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x02, 0x00, 0x70, 0x40, 0x1C,
  0x18, 0x0E, 0x03, 0x03, 0x80, 0x61, 0xE0, 0x08, 0x70, 0x01, 0x1C, 0x00,
  0x6E, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x03, 0x7F,
  0x0F, 0xE0, 0xB0, 0xE6, 0x18, 0x68, 0x1B, 0x03, 0x1C, 0x03, 0x80, 0xC7,
  0x00, 0xC0, 0x31, 0x80, 0x20, 0x0C, 0x60, 0x18, 0x02, 0x10, 0x06, 0x00,
  0x8C, 0x01, 0x80, 0x23, 0x00, 0x60, 0x18, 0xC0, 0x10, 0x06, 0x30, 0x04,
  0x01, 0x88, 0x03, 0x00, 0x42, 0x00, 0xC0, 0x11, 0x80, 0x30, 0x04, 0x60,
  0x0C, 0x03, 0x18, 0x02, 0x00, 0xC6, 0x00, 0x80, 0x31, 0x00, 0x60, 0x08,
  0x40, 0x18, 0x02, 0x30, 0x06, 0x00, 0x8C, 0x01, 0x00, 0x63, 0x00, 0x40,
  0x18, 0xC0, 0x30, 0x06, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x63,
  0xFF, 0x03, 0x38, 0x38, 0x13, 0x00, 0x60, 0xB0, 0x03, 0x0D, 0x00, 0x0C,
  0x70, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x84, 0x00,
  0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4,
  0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x78,
  0x1E, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x34, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x61, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x3C,
  0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0x1F, 0xF8, 0x02, 0x30, 0x3C, 0x06, 0x60, 0x0E, 0x06, 0x80, 0x06, 0x07,
  0x80, 0x06, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0x34, 0x00, 0x38, 0x36, 0x00, 0x70, 0x33, 0x81, 0xE0, 0x21,
  0xFF, 0x80, 0x20, 0x7E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0x0C, 0x0E, 0x03, 0x98, 0x38, 0x01, 0x20, 0xC0, 0x01, 0x43, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x84, 0x00, 0x07, 0x0C, 0x00, 0x14, 0x18,
  0x00, 0x58, 0x18, 0x01, 0xB0, 0x1C, 0x0E, 0x60, 0x1F, 0xF8, 0xC0, 0x1F,
  0xC1, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0x30,
  0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x1E, 0x01,
  0xE0, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x98, 0x00, 0x03, 0x38, 0x00, 0x0C, 0x38, 0x00,
  0x38, 0x3E, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0xE0, 0x18, 0x07, 0x80, 0x30, 0x1C, 0x00, 0x40, 0xE0,
  0x00, 0x87, 0x80, 0x03, 0x1C, 0x00, 0x06, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0x00, 0x13, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x20, 0x00, 0x26, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x4C,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C,
  0x80, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x58, 0xE0, 0x09,
  0x87, 0x03, 0x10, 0x3F, 0xE1, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1B, 0xFC,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0x40, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x03, 0x81, 0x80, 0x1C,
  0x06, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x78, 0x01, 0x0F, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x02, 0x02, 0x0C, 0x03, 0x01, 0x86,
  0x01, 0x80, 0xC3, 0x00, 0xC0, 0x21, 0x00, 0x60, 0x10, 0x80, 0x20, 0x0C,
  0xC0, 0x10, 0x06, 0x60, 0x18, 0x03, 0x30, 0x0C, 0x01, 0x98, 0x06, 0x00,
  0xC8, 0x03, 0x00, 0x64, 0x01, 0x00, 0x36, 0x00, 0x80, 0x1B, 0x00, 0xC0,
  0x09, 0x80, 0x60, 0x04, 0xC0, 0x30, 0x06, 0x40, 0x18, 0x03, 0x20, 0x08,
  0x01, 0xB0, 0x0C, 0x01, 0x98, 0x06, 0x00, 0xCC, 0x03, 0x00, 0xE6, 0x02,
  0x80, 0x63, 0x03, 0x60, 0x60, 0xC3, 0x38, 0x70, 0x7F, 0x0F, 0xF0, 0x1F,
  0x03, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x81, 0xFC, 0x03, 0x98,
  0x38, 0xE0, 0xE0, 0xC6, 0x06, 0x38, 0x0C, 0x40, 0x36, 0x00, 0x4C, 0x03,
  0x00, 0x04, 0x80, 0x30, 0x00, 0x78, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x70, 0x02, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x60,
  0x00, 0xC0, 0x16, 0x00, 0x4C, 0x03, 0x60, 0x0C, 0xC0, 0x62, 0x03, 0x8C,
  0x0C, 0x30, 0xE0, 0x61, 0xC3, 0x38, 0x07, 0xF8, 0x1F, 0x00, 0x1E, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x40, 0x00,
  0x61, 0x80, 0x00, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x20, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x81,
  0x80, 0x0B, 0x03, 0x80, 0x26, 0x03, 0x81, 0xCC, 0x03, 0xFE, 0x10, 0x03,
  0xF8, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x78, 0x1F,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE,
  0x03, 0x0E, 0x07, 0xC2, 0x18, 0x00, 0xF2, 0x18, 0x00, 0x1E, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x0E, 0x00, 0x10, 0x1C, 0x00, 0x10, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x18, 0xFF, 0x00, 0x18, 0xC7, 0xF0, 0x18, 0x80, 0x7F, 0x88, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x01, 0x87,
  0xE0, 0x00, 0x86, 0x18, 0x00, 0xC6, 0x06, 0x00, 0x62, 0x01, 0x80, 0x63,
  0x00, 0xE0, 0x31, 0x00, 0x30, 0x31, 0x80, 0x0C, 0x30, 0x80, 0x03, 0xF0,
  0x40, 0x00, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 34, 29, 11, -34 },
  { 35, 11, 13, 29, 12, -36 },
  { 53, 29, 34, 29, 1, -34 },
  { 177, 26, 46, 29, 2, -40 },
  { 327, 33, 36, 29, -1, -35 },
  { 476, 29, 36, 29, 0, -35 },
  { 607, 4, 13, 29, 16, -36 },
  { 614, 16, 44, 29, 11, -37 },
  { 702, 16, 44, 29, 3, -37 },
  { 790, 25, 24, 29, 3, -27 },
  { 865, 24, 24, 29, 3, -27 },
  { 937, 8, 13, 29, 7, -5 },
  { 950, 14, 2, 29, 8, -16 },
  { 954, 4, 4, 29, 11, -4 },
  { 956, 26, 44, 29, 2, -37 },
  { 1099, 23, 36, 29, 4, -35 },
  { 1203, 23, 34, 29, 2, -34 },
  { 1301, 24, 35, 29, 2, -35 },
  { 1406, 24, 36, 29, 2, -35 },
  { 1514, 26, 34, 29, 1, -34 },
  { 1625, 24, 35, 29, 3, -34 },
  { 1730, 21, 35, 29, 4, -34 },
  { 1822, 23, 34, 29, 6, -34 },
  { 1920, 24, 36, 29, 3, -35 },
  { 2028, 22, 35, 29, 5, -35 },
  { 2125, 8, 26, 29, 11, -26 },
  { 2151, 12, 34, 29, 7, -26 },
  { 2202, 24, 27, 29, 4, -28 },
  { 2283, 25, 11, 29, 3, -20 },
  { 2318, 24, 27, 29, 2, -28 },
  { 2399, 20, 35, 29, 7, -35 },
  { 2487, 23, 40, 29, 4, -35 },
  { 2602, 25, 34, 29, 0, -34 },
  { 2709, 23, 34, 29, 3, -34 },
  { 2807, 24, 36, 29, 4, -35 },
  { 2915, 24, 34, 29, 3, -34 },
  { 3017, 26, 34, 29, 3, -34 },
  { 3128, 26, 34, 29, 3, -34 },
  { 3239, 24, 36, 29, 4, -35 },
  { 3347, 26, 34, 29, 2, -34 },
  { 3458, 27, 34, 29, 2, -34 },
  { 3573, 23, 35, 29, 3, -34 },
  { 3674, 28, 34, 29, 3, -34 },
  { 3793, 19, 34, 29, 5, -34 },
  { 3874, 27, 34, 29, 2, -34 },
  { 3989, 26, 34, 29, 2, -34 },
  { 4100, 23, 36, 29, 4, -35 },
  { 4204, 25, 34, 29, 3, -34 },
  { 4311, 23, 44, 29, 4, -35 },
  { 4438, 25, 34, 29, 3, -34 },
  { 4545, 26, 36, 29, 2, -35 },
  { 4662, 26, 34, 29, 5, -34 },
  { 4773, 24, 35, 29, 4, -34 },
  { 4878, 24, 34, 29, 6, -34 },
  { 4980, 26, 34, 29, 4, -34 },
  { 5091, 31, 34, 29, 0, -34 },
  { 5223, 27, 34, 29, 5, -34 },
  { 5338, 30, 34, 29, 0, -34 },
  { 5466, 20, 44, 29, 9, -37 },
  { 5576, 11, 44, 29, 10, -37 },
  { 5637, 20, 44, 29, 1, -37 },
  { 5747, 23, 19, 29, 4, -34 },
  { 5802, 24, 2, 29, 0, 5 },
  { 5808, 5, 8, 29, 12, -37 },
  { 5813, 23, 27, 29, 3, -26 },
  { 5891, 22, 37, 29, 4, -36 },
  { 5993, 21, 27, 29, 4, -26 },
  { 6064, 25, 37, 29, 3, -36 },
  { 6180, 21, 27, 29, 4, -26 },
  { 6251, 31, 46, 29, -1, -36 },
  { 6430, 24, 36, 29, 2, -26 },
  { 6538, 21, 36, 29, 4, -36 },
  { 6633, 21, 37, 29, 4, -36 },
  { 6731, 21, 46, 29, 5, -36 },
  { 6852, 24, 37, 29, 4, -36 },
  { 6963, 19, 37, 29, 6, -36 },
  { 7051, 26, 26, 29, 2, -26 },
  { 7136, 21, 26, 29, 4, -26 },
  { 7205, 22, 27, 29, 4, -26 },
  { 7280, 24, 36, 29, 2, -26 },
  { 7388, 23, 36, 29, 3, -26 },
  { 7492, 23, 25, 29, 6, -25 },
  { 7564, 23, 27, 29, 3, -26 },
  { 7642, 23, 35, 29, 4, -34 },
  { 7743, 20, 26, 29, 5, -25 },
  { 7808, 22, 25, 29, 4, -25 },
  { 7877, 25, 26, 29, 3, -25 },
  { 7959, 28, 27, 29, 1, -26 },
  { 8054, 23, 35, 29, 2, -25 },
  { 8155, 24, 27, 29, 3, -26 },
  { 8236, 22, 44, 29, 6, -37 },
  { 8357, 9, 44, 29, 11, -37 },
  { 8407, 22, 44, 29, 2, -37 },
  { 8528, 25, 10, 29, 3, -20 },
};

const GFXfont IBMPlexMono_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC49PT7B_H_
