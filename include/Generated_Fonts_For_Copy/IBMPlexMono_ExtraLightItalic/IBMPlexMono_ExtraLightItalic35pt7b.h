#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC35PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x00, 0x00, 0x03, 0x8E, 0x30, 0x62, 0x85, 0x0A, 0x1C, 0x78,
  0xE1, 0x42, 0x84, 0x00, 0x30, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x06,
  0x18, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x83, 0x00, 0x08, 0x20, 0x3F,
  0x83, 0xF0, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x0C, 0x00,
  0x20, 0x80, 0x06, 0x08, 0x0F, 0xC1, 0xFC, 0x04, 0x10, 0x00, 0xC1, 0x00,
  0x08, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x03, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x0F, 0xE0, 0x06, 0x23, 0x03, 0x04, 0x10, 0x40, 0x81, 0x18, 0x10,
  0x02, 0x06, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x82, 0x00, 0x18, 0x40,
  0x01, 0x88, 0x00, 0x0F, 0x80, 0x00, 0x5C, 0x00, 0x08, 0x60, 0x01, 0x04,
  0x00, 0x20, 0xC0, 0x04, 0x08, 0x01, 0x01, 0x00, 0x20, 0x64, 0x04, 0x0C,
  0xC0, 0x81, 0x0C, 0x10, 0x40, 0xE2, 0x30, 0x07, 0xF8, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x03, 0x02, 0x18,
  0x06, 0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x04, 0x10, 0x08, 0x0C,
  0x30, 0x08, 0x08, 0x20, 0x08, 0x08, 0x40, 0x08, 0x18, 0x80, 0x0C, 0x31,
  0x80, 0x03, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83,
  0xC0, 0x01, 0x8C, 0x30, 0x01, 0x08, 0x10, 0x02, 0x10, 0x10, 0x04, 0x10,
  0x10, 0x04, 0x30, 0x10, 0x08, 0x30, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10,
  0x20, 0x20, 0x18, 0x40, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0C, 0x30,
  0x00, 0x80, 0x40, 0x04, 0x02, 0x00, 0x60, 0x10, 0x03, 0x00, 0x80, 0x18,
  0x04, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x18, 0x10, 0x00, 0x41, 0x00,
  0x1F, 0x30, 0x01, 0x0E, 0x00, 0x10, 0x20, 0x01, 0x00, 0x80, 0x08, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x02, 0x05, 0x80, 0x28, 0x34,
  0x01, 0x62, 0x30, 0x11, 0x10, 0xC1, 0x05, 0x03, 0xF0, 0x30, 0x2D, 0xA4,
  0x96, 0xC0, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0C,
  0x04, 0x0C, 0xE3, 0x1C, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x14, 0x00, 0x09,
  0x80, 0x04, 0x20, 0x03, 0x0C, 0x01, 0x81, 0x00, 0xC0, 0x20, 0x60, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x61, 0x8C, 0x30, 0x86, 0x10, 0xC0, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x06, 0x0C, 0x08, 0x02, 0x10,
  0x03, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x81, 0x81, 0x81, 0x81, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x08, 0x40,
  0x10, 0x30, 0x60, 0x1F, 0x80, 0x00, 0x38, 0x00, 0xD0, 0x01, 0x90, 0x03,
  0x10, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0xC0, 0x60, 0x18,
  0x10, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0xC0, 0x02, 0x18, 0x01,
  0x03, 0x81, 0x80, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x34, 0x00, 0x19, 0x00, 0x04, 0x40, 0x02, 0x10, 0x01, 0x0C, 0x00,
  0x83, 0x00, 0x60, 0x80, 0x30, 0x20, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x81, 0x00, 0x60, 0xC0, 0x10, 0x60, 0x04, 0x30, 0x01, 0x0F, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x07,
  0xFF, 0xC1, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x3F, 0x00,
  0x50, 0x30, 0x38, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x80, 0x04, 0x10, 0x03,
  0x03, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x47, 0xC1,
  0xB0, 0x62, 0x80, 0x6E, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x88, 0x03, 0x0C, 0x18,
  0x0F, 0xC0, 0x7F, 0xFF, 0xA0, 0x00, 0x90, 0x00, 0xD8, 0x00, 0x4C, 0x00,
  0x44, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0xC0, 0xC0, 0x18,
  0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x31, 0x00, 0x08, 0x40, 0x02, 0x10,
  0x01, 0x82, 0x00, 0xC0, 0x60, 0xE0, 0x0F, 0xC0, 0x1C, 0x0C, 0x0C, 0x00,
  0x86, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x0C, 0xC0, 0x02, 0x18, 0x01, 0x03, 0x03, 0x80, 0x3F, 0x80, 0x07,
  0xE0, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x24, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x64, 0x01, 0x4E,
  0x0D, 0x07, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x19, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x30, 0x03, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x10, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x60, 0xE2,
  0x00, 0x90, 0x01, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x07, 0x01, 0xF0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x01, 0xF8, 0x06, 0x04, 0x0C, 0x02, 0x08, 0x03, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x01, 0x20, 0xF9, 0x61, 0x85, 0x43, 0x03, 0x42, 0x02,
  0x42, 0x02, 0x44, 0x02, 0xC4, 0x02, 0x84, 0x02, 0x84, 0x06, 0x84, 0x04,
  0x84, 0x04, 0x84, 0x0C, 0x82, 0x14, 0x83, 0xE4, 0x80, 0x08, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x18, 0x80,
  0x04, 0x20, 0x03, 0x08, 0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0x40, 0x40, 0x10, 0x3F, 0xFC, 0x08, 0x01,
  0x86, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x00, 0x98, 0x00, 0x24,
  0x00, 0x0F, 0x00, 0x03, 0x0F, 0xFC, 0x04, 0x01, 0x82, 0x00, 0x43, 0x00,
  0x31, 0x80, 0x08, 0x80, 0x04, 0x40, 0x06, 0x20, 0x02, 0x10, 0x01, 0x18,
  0x01, 0x08, 0x01, 0x07, 0xFF, 0x02, 0x00, 0xC1, 0x00, 0x10, 0x80, 0x0C,
  0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00,
  0x26, 0x00, 0x32, 0x00, 0x71, 0xFF, 0xE0, 0x01, 0xF8, 0x01, 0x83, 0x01,
  0x00, 0xC1, 0x00, 0x21, 0x00, 0x19, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x01, 0x98,
  0x00, 0x84, 0x00, 0xC3, 0x00, 0xC0, 0xC1, 0xC0, 0x1F, 0x80, 0x0F, 0xF8,
  0x04, 0x03, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x06, 0x40, 0x02, 0x60, 0x01, 0x30, 0x01,
  0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x43, 0x00, 0xC1, 0xFF,
  0x80, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x82, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xFF, 0x82, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x83, 0x03,
  0x00, 0xC3, 0x00, 0x21, 0x00, 0x19, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x07,
  0xF2, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x18,
  0x00, 0x84, 0x00, 0xC3, 0x00, 0xA0, 0xC1, 0x90, 0x1F, 0x18, 0x08, 0x00,
  0x42, 0x00, 0x11, 0x80, 0x04, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0xFF,
  0xFC, 0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x06, 0x20, 0x01, 0x88,
  0x00, 0x42, 0x00, 0x10, 0x0F, 0xFF, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x18, 0x01, 0x04, 0x01, 0x83, 0x00, 0x80, 0xC1, 0x80, 0x3F,
  0x00, 0x08, 0x00, 0x30, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x30, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x60, 0x01,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x2C, 0x00, 0x24, 0x40, 0x02, 0x86, 0x00,
  0x30, 0x20, 0x02, 0x03, 0x00, 0x60, 0x10, 0x04, 0x01, 0x80, 0x40, 0x08,
  0x04, 0x00, 0xC0, 0x40, 0x04, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00,
  0x30, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0x0C, 0x00, 0x30, 0xE0, 0x06,
  0x0A, 0x00, 0xA0, 0xA0, 0x0A, 0x0A, 0x01, 0x21, 0xB0, 0x22, 0x11, 0x02,
  0x61, 0x10, 0x44, 0x11, 0x8C, 0x41, 0x08, 0x84, 0x10, 0x90, 0x43, 0x0B,
  0x04, 0x20, 0x60, 0xC2, 0x04, 0x08, 0x20, 0x40, 0x82, 0x00, 0x08, 0x20,
  0x00, 0x86, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x43, 0x00, 0x11,
  0xE0, 0x04, 0x48, 0x03, 0x12, 0x00, 0xC4, 0xC0, 0x21, 0x10, 0x08, 0x44,
  0x02, 0x31, 0x80, 0x88, 0x20, 0x62, 0x08, 0x18, 0x83, 0x04, 0x20, 0x41,
  0x08, 0x10, 0x46, 0x06, 0x11, 0x00, 0x8C, 0x40, 0x22, 0x10, 0x08, 0x84,
  0x01, 0x21, 0x00, 0x48, 0xC0, 0x12, 0x20, 0x03, 0x88, 0x00, 0xC2, 0x00,
  0x30, 0x01, 0xF8, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x03, 0x30, 0x01, 0x20,
  0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x08, 0x40, 0x10, 0x30, 0x60, 0x1F,
  0x80, 0x0F, 0xFE, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x01, 0x18, 0x00,
  0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x23,
  0x00, 0x18, 0xC0, 0x0C, 0x3F, 0xFC, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x06, 0x0C, 0x08,
  0x02, 0x10, 0x03, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0xC0,
  0x08, 0x40, 0x10, 0x30, 0x60, 0x1F, 0x80, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x86, 0x00, 0x8C, 0x00, 0x58, 0x00, 0x60, 0x0F, 0xFE, 0x02, 0x00, 0x60,
  0x80, 0x08, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0xC4, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x3F, 0xFC,
  0x08, 0x10, 0x02, 0x04, 0x00, 0x80, 0x80, 0x60, 0x20, 0x18, 0x04, 0x04,
  0x01, 0x01, 0x00, 0x20, 0x40, 0x08, 0x10, 0x03, 0x0C, 0x00, 0x42, 0x00,
  0x18, 0x00, 0xFE, 0x00, 0x60, 0x30, 0x30, 0x01, 0x04, 0x00, 0x11, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x40, 0x00,
  0xCC, 0x00, 0x10, 0xC0, 0x04, 0x0E, 0x03, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x26, 0x00,
  0x32, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x60, 0x01, 0x30,
  0x01, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x13, 0x00, 0x19,
  0x00, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00,
  0x86, 0x00, 0x81, 0x81, 0x80, 0x3F, 0x80, 0xC0, 0x00, 0xD0, 0x00, 0x24,
  0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x86, 0x00, 0x60, 0x80,
  0x10, 0x20, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x80, 0x80, 0x40, 0x30, 0x30,
  0x0C, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x01,
  0x18, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00,
  0x0C, 0x80, 0x01, 0x10, 0x00, 0x22, 0x06, 0x04, 0x41, 0x41, 0x08, 0x28,
  0x21, 0x0D, 0x04, 0x21, 0x21, 0x8C, 0x24, 0x21, 0x88, 0x84, 0x21, 0x10,
  0x84, 0x43, 0x30, 0x88, 0x24, 0x13, 0x04, 0x82, 0x40, 0x90, 0x58, 0x16,
  0x0A, 0x02, 0x81, 0x40, 0x50, 0x30, 0x0A, 0x06, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x20, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x00, 0xC0,
  0x06, 0x02, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x60,
  0x00, 0x0C, 0x80, 0x00, 0x63, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x40, 0x20, 0x02, 0x00, 0xC0, 0x18, 0x01, 0x00, 0xC0, 0x06, 0x06, 0x00,
  0x08, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x20, 0x00, 0xC2,
  0x00, 0x18, 0x10, 0x01, 0x01, 0x00, 0x20, 0x18, 0x06, 0x00, 0x80, 0xC0,
  0x0C, 0x18, 0x00, 0x41, 0x00, 0x06, 0x20, 0x00, 0x26, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x3F, 0xC0, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x07,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x90, 0x01, 0x10, 0x02, 0x18, 0x06, 0x08, 0x04, 0x0C, 0x08, 0x04, 0x10,
  0x04, 0x30, 0x02, 0x60, 0x02, 0x40, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0xC4, 0x62, 0x11, 0x03, 0xF1, 0x0C, 0x09, 0x18, 0x05, 0x30, 0x03, 0x20,
  0x03, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x04, 0xC0, 0x04, 0x40, 0x0C, 0x40, 0x14, 0x60, 0x14, 0x30,
  0x6C, 0x0F, 0x8F, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x31, 0xF0, 0x36, 0x0C, 0x28,
  0x06, 0x30, 0x02, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0,
  0x0C, 0xA0, 0x18, 0x90, 0x70, 0x8F, 0xC0, 0x03, 0xE0, 0x18, 0x30, 0x40,
  0x31, 0x00, 0x26, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x50, 0x01, 0x90, 0x06, 0x30,
  0x18, 0x30, 0x60, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x03,
  0xF1, 0x03, 0x82, 0x41, 0x80, 0x50, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x04, 0x01, 0x41, 0x80, 0x50, 0x30,
  0x6C, 0x03, 0xE3, 0x00, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x19, 0x00, 0x16,
  0x00, 0x28, 0x00, 0xF0, 0x01, 0x40, 0x0C, 0x80, 0xE1, 0xFC, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x90, 0x00, 0xB0, 0x02, 0x30, 0x08, 0x30, 0x60,
  0x1F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x88, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF1, 0x0E,
  0x09, 0x18, 0x05, 0x30, 0x03, 0x20, 0x03, 0x60, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x40,
  0x0C, 0x40, 0x14, 0x60, 0x14, 0x30, 0x6C, 0x0F, 0x88, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x80, 0x30, 0xE0, 0xC0, 0x3F, 0x80, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x11, 0xF0, 0x24, 0x18, 0xD0, 0x11, 0xC0, 0x23, 0x00, 0x64,
  0x00, 0xC8, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x64, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x30, 0x40, 0xC0, 0x82, 0x01, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC1, 0x01, 0x07, 0x02, 0x01, 0x04, 0x01, 0x08, 0x01, 0x30, 0x01,
  0x40, 0x01, 0x80, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x31, 0xF8, 0x19, 0x06,
  0x0B, 0x01, 0x86, 0x00, 0x43, 0x00, 0x21, 0x00, 0x31, 0x80, 0x10, 0xC0,
  0x10, 0x40, 0x30, 0x20, 0xE0, 0x11, 0x80, 0x08, 0x40, 0x0C, 0x30, 0x0E,
  0x08, 0x0A, 0x02, 0x19, 0x01, 0x18, 0x80, 0x58, 0x40, 0x30, 0x00, 0xFF,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0x18, 0x10,
  0x61, 0x81, 0x08, 0x04, 0xC0, 0x16, 0x00, 0x60, 0x00, 0x11, 0xC3, 0xC2,
  0xCC, 0x88, 0x60, 0xA0, 0x88, 0x18, 0x13, 0x02, 0x02, 0x60, 0x40, 0xC8,
  0x08, 0x11, 0x01, 0x02, 0x20, 0x60, 0x44, 0x08, 0x09, 0x81, 0x01, 0x30,
  0x20, 0x64, 0x04, 0x08, 0x80, 0x81, 0x10, 0x30, 0x22, 0x04, 0x04, 0xC0,
  0x80, 0x90, 0x10, 0x30, 0x11, 0xF0, 0x24, 0x18, 0xD0, 0x11, 0xC0, 0x23,
  0x00, 0x64, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x64, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x30, 0x03, 0xF0, 0x18, 0x30, 0x40, 0x11, 0x00, 0x36, 0x00, 0x28,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x50, 0x01, 0xB0, 0x02, 0x20, 0x08, 0x30, 0x60, 0x3F, 0x00,
  0x0C, 0x7C, 0x03, 0x60, 0xC0, 0xA0, 0x18, 0x30, 0x02, 0x0C, 0x00, 0x82,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xA0, 0x18,
  0x24, 0x1C, 0x08, 0xFC, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF1, 0x0E,
  0x09, 0x18, 0x05, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0x40,
  0x0C, 0x40, 0x14, 0x60, 0x14, 0x30, 0x6C, 0x0F, 0x8C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0xFE,
  0x3F, 0x81, 0x20, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x0C, 0x06, 0x18, 0x01, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x80, 0x02, 0x40, 0x04, 0x30, 0x18,
  0x0F, 0xE0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x03, 0xFF, 0xFE, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x01, 0x02, 0x03, 0x01, 0x03, 0x00, 0x86, 0x00, 0x44,
  0x00, 0x2C, 0x00, 0x18, 0x00, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x32, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x19,
  0x00, 0x22, 0x00, 0x4C, 0x01, 0x98, 0x05, 0x30, 0x0E, 0x20, 0x2C, 0x60,
  0x90, 0x3E, 0x20, 0xF8, 0x02, 0x08, 0x02, 0x08, 0x03, 0x08, 0x03, 0x08,
  0x03, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10,
  0x04, 0x10, 0x0C, 0x30, 0x08, 0x20, 0x10, 0x20, 0x20, 0x20, 0xC0, 0x23,
  0x80, 0x3E, 0x00, 0x10, 0x20, 0x8C, 0x08, 0x22, 0x02, 0x08, 0x81, 0x81,
  0x20, 0x40, 0x48, 0x10, 0x12, 0x04, 0x05, 0x81, 0x01, 0x40, 0x40, 0x50,
  0x30, 0x34, 0x08, 0x09, 0x02, 0x02, 0x40, 0x80, 0xB0, 0x60, 0x68, 0x18,
  0x13, 0x0A, 0x08, 0x44, 0xC6, 0x1E, 0x1E, 0x00, 0x03, 0x03, 0xC1, 0x90,
  0x8C, 0xC3, 0x20, 0xA0, 0x28, 0x10, 0x05, 0x02, 0x00, 0xC0, 0x40, 0x18,
  0x10, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x40, 0x60,
  0x08, 0x0C, 0x01, 0x02, 0x80, 0x20, 0x50, 0x14, 0x11, 0x0C, 0xC4, 0x26,
  0x0F, 0x03, 0x00, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30,
  0x80, 0x10, 0x40, 0x08, 0x60, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x84, 0x00, 0x86, 0x00, 0x43, 0x00, 0x21, 0x80, 0x70, 0xC0, 0x38, 0x20,
  0x2C, 0x18, 0x24, 0x03, 0xE2, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x41, 0x00, 0x41, 0xC0, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x8C,
  0x1E, 0x48, 0x01, 0xE4, 0x00, 0x62, 0x00, 0x61, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x81, 0x80,
  0x61, 0x80, 0x11, 0x80, 0x09, 0xFC, 0x04, 0x87, 0xF2, 0x40, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0xFE, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x1F, 0xE0, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41,
  0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41, 0x04,
  0x30, 0x82, 0x08, 0x20, 0x07, 0xF8, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1F, 0x01, 0xC0,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0x00, 0x1E, 0x00, 0x4C, 0x40, 0x26, 0x08, 0x09, 0x03,
  0x04, 0x80, 0x62, 0x20, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 24, 21, 8, -24 },
  { 19, 7, 9, 21, 9, -26 },
  { 27, 20, 24, 21, 1, -24 },
  { 87, 19, 32, 21, 1, -28 },
  { 163, 24, 24, 21, -1, -24 },
  { 235, 21, 24, 21, 0, -24 },
  { 298, 3, 9, 21, 11, -26 },
  { 302, 11, 32, 21, 8, -27 },
  { 346, 12, 32, 21, 2, -27 },
  { 394, 18, 17, 21, 2, -19 },
  { 433, 17, 17, 21, 2, -19 },
  { 470, 6, 9, 21, 5, -3 },
  { 477, 10, 1, 21, 6, -11 },
  { 479, 3, 3, 21, 8, -3 },
  { 481, 19, 32, 21, 1, -27 },
  { 557, 16, 24, 21, 3, -24 },
  { 605, 16, 24, 21, 2, -24 },
  { 653, 18, 24, 21, 1, -24 },
  { 707, 18, 24, 21, 1, -24 },
  { 761, 18, 24, 21, 1, -24 },
  { 815, 18, 24, 21, 2, -24 },
  { 869, 15, 24, 21, 3, -24 },
  { 914, 17, 24, 21, 4, -24 },
  { 965, 18, 24, 21, 2, -24 },
  { 1019, 15, 24, 21, 4, -24 },
  { 1064, 5, 19, 21, 8, -19 },
  { 1076, 8, 25, 21, 5, -19 },
  { 1101, 17, 19, 21, 3, -20 },
  { 1142, 18, 7, 21, 2, -14 },
  { 1158, 16, 19, 21, 2, -20 },
  { 1196, 14, 24, 21, 5, -24 },
  { 1238, 16, 28, 21, 3, -24 },
  { 1294, 18, 24, 21, 0, -24 },
  { 1348, 17, 24, 21, 2, -24 },
  { 1399, 17, 24, 21, 3, -24 },
  { 1450, 17, 24, 21, 2, -24 },
  { 1501, 19, 24, 21, 2, -24 },
  { 1558, 19, 24, 21, 2, -24 },
  { 1615, 17, 24, 21, 3, -24 },
  { 1666, 18, 24, 21, 2, -24 },
  { 1720, 18, 24, 21, 2, -24 },
  { 1774, 17, 24, 21, 2, -24 },
  { 1825, 20, 24, 21, 2, -24 },
  { 1885, 14, 24, 21, 3, -24 },
  { 1927, 20, 24, 21, 1, -24 },
  { 1987, 18, 24, 21, 2, -24 },
  { 2041, 16, 24, 21, 3, -24 },
  { 2089, 18, 24, 21, 2, -24 },
  { 2143, 16, 30, 21, 3, -24 },
  { 2203, 18, 24, 21, 2, -24 },
  { 2257, 19, 24, 21, 1, -24 },
  { 2314, 18, 24, 21, 4, -24 },
  { 2368, 17, 24, 21, 3, -24 },
  { 2419, 18, 24, 21, 4, -24 },
  { 2473, 19, 24, 21, 3, -24 },
  { 2530, 22, 24, 21, 0, -24 },
  { 2596, 20, 24, 21, 3, -24 },
  { 2656, 21, 24, 21, 0, -24 },
  { 2719, 14, 32, 21, 7, -27 },
  { 2775, 8, 32, 21, 7, -27 },
  { 2807, 14, 32, 21, 1, -27 },
  { 2863, 16, 13, 21, 3, -24 },
  { 2889, 17, 1, 21, 0, 4 },
  { 2892, 4, 6, 21, 8, -27 },
  { 2895, 16, 18, 21, 2, -18 },
  { 2931, 16, 26, 21, 3, -26 },
  { 2983, 15, 18, 21, 3, -18 },
  { 3017, 18, 26, 21, 2, -26 },
  { 3076, 15, 18, 21, 3, -18 },
  { 3110, 22, 33, 21, 0, -26 },
  { 3201, 16, 25, 21, 2, -18 },
  { 3251, 15, 26, 21, 3, -26 },
  { 3300, 15, 26, 21, 3, -26 },
  { 3349, 15, 33, 21, 3, -26 },
  { 3411, 17, 26, 21, 3, -26 },
  { 3467, 14, 26, 21, 4, -26 },
  { 3513, 19, 18, 21, 1, -18 },
  { 3556, 15, 18, 21, 3, -18 },
  { 3590, 15, 18, 21, 3, -18 },
  { 3624, 18, 25, 21, 1, -18 },
  { 3681, 16, 25, 21, 2, -18 },
  { 3731, 17, 18, 21, 4, -18 },
  { 3770, 16, 18, 21, 2, -18 },
  { 3806, 17, 24, 21, 3, -24 },
  { 3857, 15, 18, 21, 3, -18 },
  { 3891, 16, 18, 21, 3, -18 },
  { 3927, 18, 18, 21, 2, -18 },
  { 3968, 19, 18, 21, 1, -18 },
  { 4011, 17, 25, 21, 1, -18 },
  { 4065, 17, 18, 21, 2, -18 },
  { 4104, 16, 32, 21, 4, -27 },
  { 4168, 6, 32, 21, 8, -27 },
  { 4192, 15, 32, 21, 2, -27 },
  { 4252, 18, 6, 21, 2, -14 },
};

const GFXfont IBMPlexMono_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC35PT7B_H_
