#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC37PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0x00, 0x00, 0x00, 0x30, 0xE1, 0xC0,
  0x21, 0x21, 0x61, 0x63, 0x43, 0x42, 0x42, 0x42, 0xC6, 0x00, 0x10, 0x20,
  0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x01,
  0x82, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x00, 0xFE, 0x0F,
  0xF0, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x06, 0x00, 0x04, 0x10, 0x00,
  0x30, 0x40, 0x00, 0x83, 0x00, 0xFE, 0x0F, 0xE0, 0x10, 0x20, 0x00, 0x41,
  0x80, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x82, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x38, 0x8C,
  0x06, 0x08, 0x60, 0xC0, 0x83, 0x08, 0x10, 0x01, 0x81, 0x00, 0x18, 0x10,
  0x01, 0x81, 0x00, 0x18, 0x10, 0x00, 0x81, 0x00, 0x0C, 0x20, 0x00, 0x72,
  0x00, 0x00, 0xF0, 0x00, 0x02, 0xE0, 0x00, 0x23, 0x00, 0x06, 0x08, 0x00,
  0x40, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0x40, 0xC4,
  0x0C, 0x08, 0xC0, 0x81, 0x82, 0x08, 0x30, 0x18, 0x8E, 0x00, 0x7F, 0x80,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x01, 0x81, 0x84, 0x00, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0xC0, 0x40, 0x20, 0x40, 0x20, 0x10, 0x40, 0x10, 0x08, 0x40, 0x08,
  0x0C, 0x60, 0x04, 0x04, 0x20, 0x01, 0x0C, 0x20, 0x00, 0x7C, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0x8C, 0x30,
  0x01, 0x8C, 0x08, 0x00, 0x84, 0x04, 0x00, 0x86, 0x03, 0x00, 0xC2, 0x01,
  0x00, 0xC1, 0x00, 0x80, 0x40, 0x80, 0x40, 0x40, 0x40, 0x20, 0x60, 0x30,
  0x20, 0x60, 0x0C, 0x20, 0x60, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x06,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x02,
  0x00, 0x20, 0x08, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x0C, 0x06, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x80, 0x07, 0xCC, 0x00, 0x61, 0xC0, 0x02, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x40, 0x10, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x30, 0x03, 0x00, 0xC0, 0x0C, 0x0D, 0x00, 0x28, 0x24, 0x01, 0x31, 0x18,
  0x04, 0x4C, 0x30, 0x60, 0xA0, 0x3E, 0x03, 0x00, 0x6D, 0x25, 0xB6, 0x80,
  0x00, 0x38, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x20, 0x10,
  0x0B, 0x82, 0x0F, 0x0E, 0x4F, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x90,
  0x00, 0x33, 0x00, 0x0C, 0x20, 0x03, 0x06, 0x00, 0xC0, 0x40, 0x30, 0x0C,
  0x0C, 0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x63, 0x0C, 0x61, 0x84, 0x30, 0x80, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0xC0, 0x10, 0x20, 0x06, 0x10,
  0x00, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00,
  0x3C, 0x00, 0x0B, 0x03, 0x02, 0xC1, 0xC0, 0xA0, 0x70, 0x28, 0x00, 0x0A,
  0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x01, 0x04, 0x00, 0xC1, 0x80, 0x60, 0x30, 0x70, 0x03, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x34, 0x00, 0x32, 0x00, 0x23, 0x00, 0x61, 0x80,
  0x60, 0x80, 0x60, 0x40, 0x40, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x30, 0x30, 0x08, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x10, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFC, 0x01, 0xC0, 0xC0, 0xC0, 0x18, 0x20, 0x02, 0x10, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x20, 0x00,
  0x88, 0x00, 0x63, 0x00, 0x30, 0x30, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xC8, 0x00, 0x11,
  0x00, 0x04, 0x20, 0x01, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x20, 0x06, 0x04,
  0x01, 0x80, 0x80, 0x20, 0x10, 0x08, 0x06, 0x02, 0x00, 0xC0, 0xC0, 0x10,
  0x30, 0x02, 0x0C, 0x00, 0x43, 0x00, 0x08, 0x7F, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x03, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x47, 0xE0, 0x0B, 0x07, 0x01, 0x80, 0x30, 0x40, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x11, 0x00, 0x06, 0x30, 0x00, 0x83, 0x00, 0x20, 0x38, 0x18, 0x01,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x23, 0xF0,
  0x2C, 0x0C, 0x50, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0xC0, 0x04,
  0x60, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x7F, 0xFF, 0xD0, 0x00, 0x24, 0x00,
  0x19, 0x00, 0x04, 0x40, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x70, 0x18, 0x03,
  0x06, 0x00, 0x20, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x02,
  0x10, 0x00, 0x43, 0x00, 0x10, 0x30, 0x06, 0x03, 0x03, 0x00, 0x1F, 0x80,
  0x1C, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x13,
  0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80, 0x03, 0x10, 0x00, 0xC3,
  0x00, 0x30, 0x38, 0x1C, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0C, 0x0C, 0x10,
  0x06, 0x20, 0x02, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x0A, 0x30,
  0x34, 0x0F, 0xC4, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x70, 0x00, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x8E, 0x38, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x30, 0x30, 0x60,
  0x60, 0x40, 0xC0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x08, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x10, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xF0, 0x38, 0x30, 0xC0, 0x13, 0x00, 0x34, 0x00,
  0x38, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x80, 0x41, 0x80,
  0x30, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x7C, 0x90,
  0x61, 0x58, 0x40, 0x68, 0x20, 0x24, 0x20, 0x12, 0x10, 0x09, 0x08, 0x05,
  0x8C, 0x02, 0xC6, 0x03, 0x42, 0x01, 0x21, 0x00, 0x90, 0xC0, 0xC8, 0x20,
  0xA4, 0x18, 0x92, 0x07, 0x99, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x46, 0x00, 0x08,
  0xC0, 0x02, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0,
  0xC0, 0x10, 0x18, 0x06, 0x01, 0x00, 0x80, 0x20, 0x30, 0x04, 0x07, 0xFF,
  0x81, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00,
  0x88, 0x00, 0x13, 0x00, 0x02, 0x40, 0x00, 0x78, 0x00, 0x0C, 0x0F, 0xFE,
  0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x46, 0x00, 0x11,
  0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0xC0,
  0x18, 0x3F, 0xF8, 0x08, 0x01, 0x82, 0x00, 0x10, 0x80, 0x06, 0x20, 0x00,
  0x98, 0x00, 0x26, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x90, 0x00, 0x44,
  0x00, 0x33, 0x00, 0x08, 0xC0, 0x0C, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0xC0, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x23, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x10, 0x00, 0x86, 0x00,
  0x40, 0x80, 0x30, 0x18, 0x30, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0x80,
  0xE0, 0x30, 0x06, 0x04, 0x00, 0x40, 0x80, 0x0C, 0x10, 0x00, 0x82, 0x00,
  0x10, 0xC0, 0x02, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00,
  0xC4, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x10, 0x80, 0x06,
  0x10, 0x01, 0x82, 0x00, 0x60, 0x40, 0x38, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0x83, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0x83,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0,
  0xC0, 0x40, 0x18, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x22, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x07, 0xF2, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x0C, 0xC0, 0x02, 0x10, 0x01, 0x84, 0x00, 0xA0,
  0x80, 0x28, 0x38, 0x36, 0x03, 0xF1, 0x80, 0x0C, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0xFF, 0xF8, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x40, 0x0F, 0xFF, 0xF0,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x41, 0x80, 0x60, 0x60, 0xE0, 0x0F, 0xC0, 0x00, 0x0C, 0x00,
  0x18, 0x60, 0x01, 0x82, 0x00, 0x18, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x10, 0x03, 0x03, 0x00, 0x10, 0x30, 0x00, 0x83, 0x00,
  0x04, 0x30, 0x00, 0x23, 0x80, 0x03, 0x34, 0x00, 0x1B, 0x30, 0x00, 0xB0,
  0x80, 0x07, 0x06, 0x00, 0x30, 0x10, 0x01, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x04, 0x00, 0x40, 0x20, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x60, 0xC0, 0x01, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x03, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x14, 0x00, 0xA0, 0xB0, 0x0D, 0x04, 0x80, 0x48, 0x24, 0x04, 0x43,
  0x30, 0x66, 0x18, 0x82, 0x30, 0x84, 0x31, 0x04, 0x21, 0x08, 0x21, 0x90,
  0x41, 0x05, 0x82, 0x18, 0x28, 0x30, 0xC1, 0xC1, 0x84, 0x04, 0x08, 0x20,
  0x40, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x21, 0xC0, 0x04, 0x28, 0x00, 0x85, 0x00, 0x11,
  0xB0, 0x06, 0x32, 0x00, 0xC4, 0x40, 0x10, 0x8C, 0x02, 0x10, 0x80, 0x42,
  0x10, 0x08, 0xC3, 0x03, 0x18, 0x20, 0x62, 0x04, 0x08, 0x40, 0x81, 0x08,
  0x18, 0x21, 0x01, 0x04, 0x60, 0x21, 0x8C, 0x06, 0x31, 0x00, 0x44, 0x20,
  0x08, 0x84, 0x01, 0x90, 0x80, 0x12, 0x30, 0x02, 0xC6, 0x00, 0x78, 0x80,
  0x06, 0x10, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0xC0, 0x10, 0x20,
  0x06, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x01, 0x04, 0x00, 0xC1, 0x80, 0x60, 0x30, 0x70,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0x80, 0x18, 0x20, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00,
  0x62, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x43, 0x00, 0x38, 0x7F, 0xFC,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0xC0, 0x10,
  0x20, 0x06, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80, 0x03, 0x40,
  0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x32,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x04, 0x00, 0xC1, 0x80, 0x60, 0x30,
  0x70, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x06, 0x04, 0x00, 0x83, 0x00, 0x11,
  0x00, 0x06, 0x80, 0x00, 0xC0, 0x0F, 0xFF, 0x01, 0x80, 0x18, 0x20, 0x01,
  0x04, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01,
  0x10, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x43, 0x00, 0x30,
  0x7F, 0xFC, 0x08, 0x18, 0x01, 0x01, 0x00, 0x20, 0x30, 0x04, 0x02, 0x01,
  0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0x80, 0x80, 0x18, 0x10, 0x01, 0x02,
  0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x38, 0x0C,
  0x06, 0x00, 0x60, 0xC0, 0x03, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC4,
  0x00, 0x08, 0xC0, 0x01, 0x82, 0x00, 0x30, 0x1C, 0x0E, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x00, 0x20, 0x30,
  0x30, 0x07, 0xF0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A, 0x00,
  0x04, 0xC0, 0x03, 0x30, 0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x40, 0x0C,
  0x10, 0x02, 0x06, 0x00, 0x81, 0x80, 0x40, 0x60, 0x10, 0x08, 0x0C, 0x02,
  0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0x46,
  0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x58, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x20, 0x00, 0x16, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00,
  0x02, 0x60, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0xC0, 0x44, 0x0E, 0x0C, 0x41, 0xE0, 0x84, 0x12, 0x08, 0x41, 0x21, 0x84,
  0x22, 0x10, 0x42, 0x21, 0x0C, 0x62, 0x10, 0xC4, 0x23, 0x0C, 0xC2, 0x20,
  0xC8, 0x22, 0x09, 0x83, 0x20, 0x90, 0x16, 0x09, 0x01, 0x40, 0xA0, 0x14,
  0x0A, 0x01, 0x40, 0xE0, 0x1C, 0x0C, 0x01, 0x80, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x08, 0x00, 0x60, 0x18, 0x00, 0x80, 0x10, 0x02, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x43, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x90, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x30, 0x18, 0x00, 0x40, 0x10, 0x01, 0x00, 0x30, 0x06,
  0x00, 0x20, 0x18, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x3C, 0x00, 0x06, 0x40, 0x00, 0xC6, 0x00, 0x08, 0x20, 0x01, 0x03,
  0x00, 0x30, 0x10, 0x06, 0x01, 0x00, 0x40, 0x08, 0x08, 0x00, 0x81, 0x80,
  0x0C, 0x30, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x80, 0x20, 0x10, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x07, 0xFE, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x28, 0x00, 0x36, 0x00, 0x31, 0x00, 0x10, 0x80, 0x10, 0x20, 0x18,
  0x10, 0x18, 0x0C, 0x08, 0x02, 0x08, 0x01, 0x8C, 0x00, 0x4C, 0x00, 0x24,
  0x00, 0x0C, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x84, 0x42, 0x21, 0x01, 0xF0,
  0x83, 0x06, 0x42, 0x00, 0xA2, 0x00, 0x53, 0x00, 0x19, 0x00, 0x09, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xD8, 0x00, 0x4C,
  0x00, 0x22, 0x00, 0x31, 0x00, 0x18, 0x80, 0x1C, 0x20, 0x16, 0x1C, 0x32,
  0x03, 0xE1, 0xE0, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0xF8, 0x09, 0x83,
  0x0D, 0x00, 0xC7, 0x00, 0x23, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x06, 0x40,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32,
  0x00, 0x13, 0x00, 0x09, 0x80, 0x08, 0xA0, 0x08, 0x4C, 0x18, 0x21, 0xF8,
  0x00, 0x03, 0xF0, 0x0E, 0x0C, 0x18, 0x06, 0x30, 0x02, 0x20, 0x03, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x02, 0xC0, 0x04, 0x40, 0x0C, 0x60, 0x18, 0x30,
  0x70, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0xF0,
  0x80, 0xC1, 0x90, 0x20, 0x0A, 0x08, 0x01, 0x43, 0x00, 0x18, 0x40, 0x03,
  0x18, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x82, 0x00, 0x50,
  0x20, 0x1E, 0x07, 0x04, 0xC0, 0x3F, 0x10, 0x00, 0x01, 0xF8, 0x06, 0x06,
  0x18, 0x02, 0x10, 0x03, 0x20, 0x01, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x06,
  0xC0, 0x1C, 0x80, 0xF0, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04,
  0xC0, 0x02, 0x40, 0x04, 0x60, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x04, 0x02, 0x00, 0x04, 0x04, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x06, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF0, 0x83, 0x06, 0x42, 0x00, 0xA2, 0x00, 0x53, 0x00, 0x19, 0x00,
  0x0D, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xD8,
  0x00, 0x4C, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x14, 0x20, 0x16,
  0x1C, 0x12, 0x03, 0xF1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x21, 0x00, 0x20, 0x60, 0x60, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0xF8, 0x13, 0x0C, 0x14, 0x02, 0x18, 0x02, 0x38, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x06,
  0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C,
  0x80, 0x08, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x03, 0x06, 0x04,
  0x04, 0x18, 0x04, 0x20, 0x04, 0xC0, 0x05, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x08, 0x04, 0x0C, 0x08, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x80,
  0x0D, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0xFC,
  0x04, 0xC1, 0x83, 0x40, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2,
  0x00, 0x20, 0x80, 0x10, 0x60, 0x18, 0x18, 0x18, 0x06, 0x38, 0x01, 0x18,
  0x00, 0x41, 0x00, 0x10, 0x60, 0x3C, 0x08, 0x1B, 0x03, 0x0C, 0x80, 0x46,
  0x20, 0x1A, 0x08, 0x03, 0x00, 0x7F, 0x81, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x61, 0x03, 0x02, 0x08,
  0x0C, 0x60, 0x19, 0x00, 0x2C, 0x00, 0x70, 0x00, 0x19, 0xE1, 0xE1, 0xA2,
  0x22, 0x1C, 0x1C, 0x11, 0x81, 0x81, 0x10, 0x10, 0x11, 0x01, 0x03, 0x30,
  0x30, 0x33, 0x02, 0x02, 0x20, 0x20, 0x22, 0x02, 0x02, 0x20, 0x20, 0x22,
  0x02, 0x06, 0x60, 0x60, 0x64, 0x04, 0x04, 0x40, 0x40, 0x44, 0x04, 0x04,
  0x40, 0x40, 0x44, 0x0C, 0x0C, 0xC0, 0xC0, 0xC0, 0x10, 0xF8, 0x13, 0x0C,
  0x14, 0x02, 0x18, 0x02, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x06, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0x80, 0x08, 0x03, 0xF0,
  0x0C, 0x0C, 0x18, 0x06, 0x30, 0x03, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x06, 0x40, 0x0C, 0x60, 0x18, 0x30, 0x30, 0x0F, 0xC0,
  0x08, 0x7C, 0x02, 0x60, 0xC1, 0xA0, 0x18, 0x70, 0x02, 0x18, 0x00, 0x86,
  0x00, 0x31, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x46, 0x00, 0x11, 0x80, 0x08,
  0x50, 0x04, 0x13, 0x06, 0x04, 0x3F, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xF0, 0x83, 0x06, 0x42, 0x00, 0xA2, 0x00, 0x53, 0x00, 0x19, 0x00, 0x0D,
  0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x14, 0x20, 0x16, 0x1C,
  0x13, 0x03, 0xF1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0xFF, 0x1F, 0xC0, 0x58, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFC, 0x01, 0x80, 0xC0, 0x80, 0x08, 0x40, 0x03, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x13,
  0x00, 0x04, 0x60, 0x02, 0x0E, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x03, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x04, 0x06, 0x03, 0x06, 0x00, 0xC2,
  0x00, 0x23, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00, 0x20, 0x02, 0x40, 0x05,
  0x80, 0x1A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0,
  0x0D, 0x00, 0x1A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x06,
  0x40, 0x1C, 0xC0, 0x50, 0xC3, 0x20, 0xF8, 0x40, 0xFC, 0x01, 0x06, 0x00,
  0x83, 0x00, 0x61, 0x00, 0x30, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x10,
  0x02, 0x18, 0x01, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x40,
  0x80, 0x60, 0x40, 0x60, 0x60, 0x60, 0x30, 0x60, 0x10, 0xC0, 0x0F, 0x80,
  0x00, 0x10, 0x10, 0x42, 0x06, 0x08, 0xC0, 0x81, 0x98, 0x10, 0x12, 0x02,
  0x02, 0x40, 0x40, 0x48, 0x08, 0x09, 0x03, 0x01, 0x60, 0x40, 0x2C, 0x08,
  0x05, 0x01, 0x01, 0xA0, 0x20, 0x24, 0x04, 0x04, 0x81, 0x80, 0xB0, 0x30,
  0x26, 0x0A, 0x04, 0x41, 0x41, 0x08, 0x48, 0x60, 0xF0, 0xF0, 0x00, 0x03,
  0x81, 0xE0, 0x76, 0x11, 0x8E, 0x11, 0x04, 0xC0, 0x90, 0x30, 0x07, 0x81,
  0x80, 0x18, 0x0C, 0x00, 0xC0, 0x40, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x0A, 0x00, 0x40, 0x50, 0x02,
  0x02, 0x80, 0x10, 0x24, 0x0E, 0x83, 0x31, 0xC6, 0x30, 0x98, 0x1E, 0x07,
  0x00, 0x04, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00,
  0x82, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x40,
  0x1C, 0x18, 0x0A, 0x03, 0x0C, 0x80, 0x7C, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC1, 0x00, 0x60, 0xF0, 0x70, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x46, 0x0F, 0x11, 0x00, 0x7C, 0x80, 0x06, 0x20, 0x03, 0x08,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x08, 0x04, 0x02, 0x06, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x04,
  0xFF, 0x01, 0x20, 0xFE, 0x48, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x41, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x60, 0x80, 0x07,
  0xF8, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0xE0, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x22, 0x30, 0x08, 0x82, 0x01,
  0x20, 0x20, 0x64, 0x06, 0x09, 0x00, 0x62, 0x20, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 26, 22, 8, -26 },
  { 24, 8, 9, 22, 9, -27 },
  { 33, 22, 26, 22, 1, -26 },
  { 105, 20, 34, 22, 1, -30 },
  { 190, 25, 26, 22, -1, -26 },
  { 272, 22, 26, 22, 0, -26 },
  { 344, 3, 9, 22, 12, -27 },
  { 348, 13, 33, 22, 8, -28 },
  { 402, 12, 33, 22, 2, -28 },
  { 452, 19, 18, 22, 2, -20 },
  { 495, 17, 17, 22, 3, -20 },
  { 532, 6, 9, 22, 6, -3 },
  { 539, 10, 1, 22, 6, -12 },
  { 541, 3, 3, 22, 8, -3 },
  { 543, 20, 33, 22, 1, -28 },
  { 626, 18, 26, 22, 3, -26 },
  { 685, 17, 26, 22, 2, -26 },
  { 741, 19, 26, 22, 1, -26 },
  { 803, 18, 26, 22, 2, -26 },
  { 862, 19, 26, 22, 1, -26 },
  { 924, 19, 26, 22, 2, -26 },
  { 986, 16, 26, 22, 3, -26 },
  { 1038, 18, 26, 22, 4, -26 },
  { 1097, 19, 26, 22, 2, -26 },
  { 1159, 16, 26, 22, 4, -26 },
  { 1211, 6, 20, 22, 8, -20 },
  { 1226, 8, 26, 22, 6, -20 },
  { 1252, 18, 20, 22, 3, -21 },
  { 1297, 19, 8, 22, 2, -15 },
  { 1316, 17, 20, 22, 2, -21 },
  { 1359, 15, 26, 22, 5, -26 },
  { 1408, 17, 30, 22, 3, -26 },
  { 1472, 19, 26, 22, 0, -26 },
  { 1534, 18, 26, 22, 2, -26 },
  { 1593, 18, 26, 22, 3, -26 },
  { 1652, 19, 26, 22, 2, -26 },
  { 1714, 20, 26, 22, 2, -26 },
  { 1779, 20, 26, 22, 2, -26 },
  { 1844, 18, 26, 22, 3, -26 },
  { 1903, 19, 26, 22, 2, -26 },
  { 1965, 20, 26, 22, 2, -26 },
  { 2030, 17, 26, 22, 3, -26 },
  { 2086, 21, 26, 22, 2, -26 },
  { 2155, 14, 26, 22, 4, -26 },
  { 2201, 21, 26, 22, 1, -26 },
  { 2270, 19, 26, 22, 2, -26 },
  { 2332, 18, 26, 22, 3, -26 },
  { 2391, 19, 26, 22, 2, -26 },
  { 2453, 18, 32, 22, 3, -26 },
  { 2525, 19, 26, 22, 2, -26 },
  { 2587, 20, 26, 22, 1, -26 },
  { 2652, 20, 26, 22, 4, -26 },
  { 2717, 18, 26, 22, 3, -26 },
  { 2776, 18, 26, 22, 5, -26 },
  { 2835, 20, 26, 22, 3, -26 },
  { 2900, 23, 26, 22, 0, -26 },
  { 2975, 20, 26, 22, 4, -26 },
  { 3040, 22, 26, 22, 0, -26 },
  { 3112, 15, 33, 22, 7, -28 },
  { 3174, 9, 33, 22, 7, -28 },
  { 3212, 15, 33, 22, 1, -28 },
  { 3274, 17, 14, 22, 3, -26 },
  { 3304, 18, 1, 22, 0, 4 },
  { 3307, 4, 6, 22, 9, -28 },
  { 3310, 17, 19, 22, 2, -19 },
  { 3351, 17, 27, 22, 3, -27 },
  { 3409, 16, 19, 22, 3, -19 },
  { 3447, 19, 27, 22, 2, -27 },
  { 3512, 16, 19, 22, 3, -19 },
  { 3550, 23, 34, 22, 0, -27 },
  { 3648, 17, 26, 22, 2, -19 },
  { 3704, 16, 27, 22, 3, -27 },
  { 3758, 16, 28, 22, 3, -28 },
  { 3814, 15, 35, 22, 4, -28 },
  { 3880, 18, 27, 22, 3, -27 },
  { 3941, 15, 27, 22, 4, -27 },
  { 3992, 20, 19, 22, 1, -19 },
  { 4040, 16, 19, 22, 3, -19 },
  { 4078, 16, 19, 22, 3, -19 },
  { 4116, 18, 26, 22, 2, -19 },
  { 4175, 17, 26, 22, 2, -19 },
  { 4231, 18, 19, 22, 4, -19 },
  { 4274, 18, 19, 22, 2, -19 },
  { 4317, 18, 26, 22, 3, -26 },
  { 4376, 15, 19, 22, 4, -19 },
  { 4412, 17, 19, 22, 3, -19 },
  { 4453, 19, 19, 22, 2, -19 },
  { 4499, 21, 19, 22, 1, -19 },
  { 4549, 18, 26, 22, 1, -19 },
  { 4608, 18, 19, 22, 2, -19 },
  { 4651, 17, 33, 22, 4, -28 },
  { 4722, 7, 33, 22, 8, -28 },
  { 4751, 16, 33, 22, 2, -28 },
  { 4817, 19, 7, 22, 2, -15 },
};

const GFXfont IBMPlexMono_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC37PT7B_H_
