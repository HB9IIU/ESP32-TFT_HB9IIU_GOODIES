#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC47PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0x70, 0x20, 0xC8,
  0x36, 0x0D, 0x83, 0x60, 0x98, 0x64, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x13,
  0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x18, 0x18, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0x10, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x80, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0x01, 0x80, 0x00, 0x30, 0x10,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0x8C, 0x70, 0x06, 0x06, 0x0C, 0x06, 0x02,
  0x03, 0x02, 0x01, 0x00, 0xC3, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x1E, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x10, 0xE0,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01,
  0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x40, 0x10, 0x0C, 0x30, 0x08, 0x06, 0x0C, 0x04,
  0x06, 0x03, 0x02, 0x06, 0x00, 0xF3, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x06, 0x01, 0x86, 0x00, 0x08, 0x04,
  0x02, 0x00, 0x30, 0x18, 0x06, 0x00, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x08, 0x04, 0x01, 0x00, 0x10, 0x18, 0x02, 0x00, 0x60, 0x60, 0x04, 0x00,
  0xC1, 0x80, 0x08, 0x01, 0x82, 0x00, 0x10, 0x02, 0x0C, 0x00, 0x20, 0x0C,
  0x30, 0x00, 0x40, 0x10, 0xC0, 0x00, 0xC0, 0x61, 0x00, 0x00, 0xC1, 0x84,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x83, 0x0C, 0x00, 0x02, 0x0C, 0x04,
  0x00, 0x08, 0x30, 0x0C, 0x00, 0x30, 0x40, 0x08, 0x00, 0xC1, 0x80, 0x10,
  0x01, 0x03, 0x00, 0x20, 0x04, 0x04, 0x00, 0xC0, 0x18, 0x08, 0x01, 0x80,
  0x60, 0x10, 0x03, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x40, 0x08, 0x0C,
  0x00, 0x80, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x40, 0x01, 0x83, 0x01, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x04, 0x00, 0x03,
  0xD1, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0xC0, 0x34, 0x00, 0x16, 0x02, 0x40, 0x01, 0x20, 0x46, 0x00, 0x13, 0x0C,
  0x20, 0x02, 0x10, 0x83, 0x00, 0x41, 0x98, 0x1C, 0x18, 0x0F, 0x00, 0x7E,
  0x00, 0x60, 0x33, 0x26, 0x66, 0x66, 0x4C, 0xCC, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x18,
  0x03, 0xF8, 0x18, 0x1F, 0x1F, 0x11, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x30, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60,
  0x40, 0xC0, 0xFF, 0xF8, 0x7F, 0xF7, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0xE0,
  0x06, 0x00, 0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83,
  0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x0C, 0x03, 0x60, 0x38, 0x06, 0xC0, 0x70, 0x0D, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2,
  0x00, 0x01, 0x06, 0x00, 0x06, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x0C, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x06, 0x06,
  0x00, 0x30, 0x10, 0x01, 0x80, 0x40, 0x1C, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x60, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x18, 0x00, 0x18, 0x18, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x08, 0x00, 0x18, 0x08, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10, 0x07, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFE, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x1F, 0xC0, 0x0C, 0xC0, 0xE0, 0x1E, 0x00, 0x60, 0x30, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x88, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x38, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x0F, 0xE0, 0x33, 0x03, 0x82, 0xC0,
  0x0C, 0x78, 0x00, 0x65, 0x00, 0x02, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C,
  0x60, 0x01, 0x83, 0x00, 0x30, 0x18, 0x0C, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xFE, 0x40, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x10, 0x00, 0x60, 0x60, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x03, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x60, 0x00, 0xFF, 0x00, 0x0E, 0x03,
  0x80, 0x70, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x64, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x01, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xA1, 0x80, 0x1B, 0x07, 0x03,
  0x10, 0x0F, 0xE1, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xF0, 0xF0, 0x70, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x60, 0x06, 0x18, 0x00, 0x66, 0x00, 0x05,
  0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x07,
  0x00, 0x60, 0x0C, 0x04, 0x00, 0x20, 0x60, 0x01, 0x86, 0x00, 0x04, 0x20,
  0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x03, 0xE2,
  0x40, 0x60, 0x92, 0x06, 0x03, 0x90, 0x20, 0x0D, 0x83, 0x00, 0x6C, 0x10,
  0x02, 0x41, 0x80, 0x12, 0x0C, 0x00, 0x90, 0x60, 0x0D, 0x82, 0x00, 0x6C,
  0x10, 0x03, 0x60, 0x80, 0x13, 0x0C, 0x00, 0x90, 0x20, 0x0C, 0x81, 0x00,
  0x64, 0x08, 0x07, 0x20, 0x60, 0x59, 0x01, 0x84, 0x88, 0x07, 0xC4, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x20, 0x00,
  0x03, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x08, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x0C, 0x03, 0xFF, 0xFC, 0x06, 0x00, 0x04, 0x06, 0x00, 0x04, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x83, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01,
  0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x3F, 0xFF,
  0x00, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x18,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0x81, 0xC0, 0x18, 0x03, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x1C, 0x06, 0x00,
  0xE0, 0x0C, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0C, 0x01,
  0xC0, 0x18, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x40, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x01, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00,
  0x02, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x30, 0x00, 0xE0,
  0x60, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0x81, 0x80, 0x18, 0x03, 0x00, 0x80, 0x06, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x07, 0xFE, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02,
  0x30, 0x00, 0x18, 0x40, 0x00, 0x61, 0x80, 0x03, 0x82, 0x00, 0x16, 0x0C,
  0x00, 0x90, 0x1C, 0x0C, 0x40, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x81,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1F, 0xFF,
  0xFE, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0x82, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x04, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00,
  0x30, 0x1C, 0x01, 0x80, 0x38, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x10, 0x00, 0x38, 0x04,
  0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x43,
  0x40, 0x00, 0x11, 0x98, 0x00, 0x0C, 0xC2, 0x00, 0x03, 0x60, 0xC0, 0x00,
  0xF0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x50, 0x00, 0x38, 0x14,
  0x00, 0x1A, 0x0D, 0x80, 0x07, 0x83, 0x60, 0x03, 0x60, 0xC8, 0x00, 0xD8,
  0x32, 0x00, 0x66, 0x08, 0xC0, 0x31, 0x02, 0x10, 0x0C, 0x41, 0x84, 0x06,
  0x30, 0x61, 0x81, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x08, 0x60, 0xC1, 0x02,
  0x18, 0x20, 0x40, 0xCC, 0x08, 0x30, 0x32, 0x06, 0x0C, 0x05, 0x81, 0x83,
  0x01, 0xC0, 0x60, 0xC0, 0x70, 0x18, 0x20, 0x08, 0x04, 0x08, 0x04, 0x01,
  0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x80, 0x00, 0x81, 0xC0, 0x00, 0xC1, 0xE0, 0x00, 0x60, 0xD8,
  0x00, 0x30, 0x6C, 0x00, 0x10, 0x36, 0x00, 0x08, 0x11, 0x00, 0x04, 0x08,
  0xC0, 0x06, 0x0C, 0x60, 0x03, 0x06, 0x10, 0x01, 0x83, 0x0C, 0x00, 0xC1,
  0x86, 0x00, 0x40, 0x81, 0x00, 0x20, 0x40, 0xC0, 0x30, 0x60, 0x60, 0x18,
  0x30, 0x10, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x06, 0x02, 0x04, 0x01, 0x01,
  0x02, 0x00, 0xC1, 0x83, 0x00, 0x60, 0xC1, 0x80, 0x10, 0x60, 0xC0, 0x0C,
  0x30, 0x60, 0x06, 0x10, 0x20, 0x03, 0x08, 0x10, 0x00, 0xCC, 0x18, 0x00,
  0x66, 0x0C, 0x00, 0x33, 0x06, 0x00, 0x09, 0x83, 0x00, 0x06, 0x81, 0x00,
  0x03, 0x40, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC0,
  0x80, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x21,
  0x00, 0x00, 0xC2, 0x00, 0x01, 0x06, 0x00, 0x06, 0x04, 0x00, 0x18, 0x0C,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x06, 0x00, 0x18, 0x06, 0x00, 0x04, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x10,
  0x00, 0x70, 0x3F, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x06, 0x00,
  0x06, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x0C, 0x0E,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x01, 0x01,
  0x80, 0x03, 0x04, 0x00, 0x03, 0x10, 0x00, 0x02, 0x40, 0x00, 0x03, 0x00,
  0x07, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x06, 0x00, 0x04, 0x04, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x10, 0x00, 0x70, 0x3F, 0xFF, 0xC0, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x88, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x1E, 0x01, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x00, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x01, 0x84,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0x42, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0x10, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38, 0x0E, 0x00, 0x1F, 0xE0, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x40, 0x30, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0xC0, 0x20, 0xC0,
  0x70, 0x08, 0x30, 0x14, 0x06, 0x08, 0x0D, 0x01, 0x82, 0x02, 0x40, 0x40,
  0x81, 0x98, 0x10, 0x20, 0x66, 0x0C, 0x08, 0x31, 0x83, 0x02, 0x0C, 0x60,
  0x81, 0x82, 0x18, 0x20, 0x61, 0x82, 0x18, 0x18, 0x40, 0x86, 0x06, 0x30,
  0x21, 0x01, 0x88, 0x08, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x04,
  0xC0, 0x32, 0x01, 0x30, 0x0D, 0x80, 0x48, 0x03, 0x60, 0x16, 0x00, 0x58,
  0x05, 0x00, 0x14, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x61, 0x00, 0x01,
  0x06, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x43,
  0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFE, 0x47, 0x18, 0x63, 0x08, 0x61, 0x00, 0xFE, 0x00, 0x0E, 0x06,
  0x30, 0x60, 0x04, 0x83, 0x00, 0x0A, 0x18, 0x00, 0x38, 0x40, 0x00, 0x63,
  0x00, 0x01, 0x88, 0x00, 0x06, 0x60, 0x00, 0x11, 0x80, 0x00, 0x46, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x38, 0x40, 0x00, 0xC1, 0x80, 0x05, 0x02, 0x00, 0x2C, 0x0C, 0x01,
  0x30, 0x1C, 0x18, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x41,
  0xF8, 0x03, 0x18, 0x38, 0x0C, 0x80, 0x30, 0x34, 0x00, 0x60, 0xA0, 0x01,
  0x83, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x88, 0x00, 0x06,
  0x20, 0x00, 0x11, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0xC1, 0x20, 0x06, 0x04, 0x60, 0x70, 0x20, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x38, 0x38, 0x06, 0x00, 0xC0, 0x80, 0x06, 0x18, 0x00, 0x23, 0x00,
  0x05, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06,
  0x40, 0x00, 0xC6, 0x00, 0x18, 0x20, 0x03, 0x03, 0x00, 0x60, 0x1C, 0x1C,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xF8, 0x30, 0x1C,
  0x0C, 0x60, 0x60, 0x04, 0x81, 0x80, 0x05, 0x06, 0x00, 0x0E, 0x08, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x00,
  0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x1C, 0x10, 0x00, 0x30, 0x30, 0x00, 0xA0, 0x20,
  0x02, 0x40, 0x60, 0x09, 0x80, 0x70, 0x63, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x18, 0x1C, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x00, 0x03, 0x20, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x24, 0x00, 0x06,
  0xC0, 0x01, 0xCC, 0x00, 0x70, 0xC0, 0x7C, 0x0F, 0xF8, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x2C, 0x00,
  0x06, 0x40, 0x00, 0xC6, 0x00, 0x08, 0x20, 0x01, 0x83, 0x00, 0x30, 0x1C,
  0x0C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x81, 0x8C, 0x0C,
  0x00, 0x90, 0x30, 0x00, 0xA0, 0xC0, 0x01, 0xC1, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC1,
  0x00, 0x03, 0x83, 0x00, 0x0A, 0x02, 0x00, 0x24, 0x06, 0x00, 0x98, 0x07,
  0x06, 0x30, 0x03, 0xF0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x20, 0x01,
  0x80, 0xE0, 0x06, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x3F, 0x00, 0x8C, 0x1C, 0x09, 0x00, 0x61, 0xA0, 0x06, 0x1C, 0x00, 0x21,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x02,
  0x30, 0x00, 0x23, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x06, 0x20, 0x00,
  0x66, 0x00, 0x04, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00,
  0x0C, 0x40, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x20, 0x18, 0x03,
  0x01, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x02, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x22, 0x00, 0x02, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x80, 0x0C, 0x10, 0x00, 0xC6, 0x00,
  0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x1F, 0xC0, 0x0C, 0x60, 0x60, 0x0C, 0x80, 0x30, 0x0D, 0x00,
  0x18, 0x0A, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x60, 0x10, 0x00,
  0xC0, 0x10, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0xF0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x02, 0x20, 0x30, 0x03, 0x60, 0x30,
  0x04, 0x60, 0x18, 0x08, 0x60, 0x18, 0x10, 0x60, 0x0C, 0x20, 0x40, 0x04,
  0x40, 0x40, 0x06, 0x80, 0x80, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x30, 0x07, 0x0C, 0x02,
  0x03, 0x01, 0x00, 0x81, 0x80, 0x60, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x01,
  0xA0, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x3E, 0x04, 0x86, 0x21, 0x86, 0x81,
  0x20, 0x43, 0x80, 0xA0, 0x31, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x0C, 0x40,
  0x10, 0x04, 0x20, 0x08, 0x02, 0x30, 0x0C, 0x01, 0x18, 0x06, 0x01, 0x8C,
  0x03, 0x00, 0xC4, 0x01, 0x80, 0x62, 0x00, 0x80, 0x21, 0x00, 0x40, 0x11,
  0x80, 0x60, 0x08, 0xC0, 0x30, 0x0C, 0x60, 0x18, 0x06, 0x20, 0x0C, 0x03,
  0x10, 0x04, 0x01, 0x08, 0x02, 0x00, 0x8C, 0x03, 0x00, 0x46, 0x01, 0x80,
  0x63, 0x00, 0xC0, 0x31, 0x00, 0x60, 0x18, 0x80, 0x20, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0x8C, 0x1C, 0x09, 0x00, 0x61, 0xA0, 0x06, 0x1C, 0x00, 0x21,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x02,
  0x30, 0x00, 0x23, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x06, 0x20, 0x00,
  0x66, 0x00, 0x04, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00,
  0x0C, 0x40, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x80, 0x00, 0xFE, 0x00, 0x1C, 0x1C, 0x01, 0x80, 0x30, 0x10, 0x00,
  0xC1, 0x80, 0x02, 0x18, 0x00, 0x18, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60,
  0x00, 0x12, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x01,
  0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00,
  0x01, 0x20, 0x00, 0x19, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x20, 0x00, 0x41,
  0x80, 0x04, 0x06, 0x00, 0x40, 0x1C, 0x0C, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x0C, 0x60, 0xE0, 0x19, 0x00, 0x60, 0x34, 0x00, 0x60, 0x50,
  0x00, 0xC0, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x07,
  0x00, 0x06, 0x0E, 0x00, 0x18, 0x12, 0x00, 0x60, 0x23, 0x03, 0x80, 0xC1,
  0xFC, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0E, 0x06, 0x30, 0x60, 0x04, 0x83, 0x00, 0x0A,
  0x18, 0x00, 0x38, 0x40, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00, 0x06, 0x60,
  0x00, 0x11, 0x80, 0x00, 0x46, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0x40, 0x00, 0xC1, 0x80,
  0x05, 0x02, 0x00, 0x24, 0x0C, 0x01, 0x30, 0x1C, 0x18, 0xC0, 0x1F, 0x83,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x7F,
  0xC1, 0xFF, 0x01, 0x8C, 0x00, 0x03, 0x60, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0E,
  0x03, 0x80, 0x60, 0x03, 0x83, 0x00, 0x03, 0x08, 0x00, 0x08, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x06, 0x0C,
  0x00, 0x30, 0x1C, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x30, 0x00, 0x61, 0x00, 0x01, 0x98, 0x00,
  0x04, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x26, 0x00, 0x04, 0xC0,
  0x01, 0x90, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00,
  0x02, 0x60, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00,
  0x09, 0x80, 0x01, 0x30, 0x00, 0x64, 0x00, 0x0C, 0x80, 0x01, 0x90, 0x00,
  0x22, 0x00, 0x0C, 0x40, 0x02, 0x88, 0x00, 0x71, 0x80, 0x16, 0x10, 0x04,
  0xC1, 0x83, 0x10, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x30, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00,
  0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x10, 0x20, 0x01, 0x83, 0x00, 0x08,
  0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00,
  0xC0, 0x08, 0x1C, 0x00, 0xC3, 0x80, 0x03, 0xE0, 0x00, 0x18, 0x06, 0x04,
  0x18, 0x04, 0x06, 0x10, 0x04, 0x06, 0x10, 0x0C, 0x02, 0x30, 0x0C, 0x02,
  0x30, 0x0C, 0x02, 0x30, 0x0C, 0x03, 0x30, 0x08, 0x03, 0x20, 0x08, 0x03,
  0x20, 0x08, 0x03, 0x20, 0x18, 0x03, 0x60, 0x18, 0x02, 0x60, 0x18, 0x02,
  0x60, 0x10, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x06, 0x40, 0x30, 0x06,
  0xC0, 0x30, 0x04, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x70, 0x08,
  0xC0, 0x90, 0x10, 0xC0, 0x90, 0x30, 0x61, 0x18, 0x60, 0x3E, 0x0F, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x72, 0x06, 0x38, 0x38, 0x61, 0x03, 0x1C, 0x04,
  0x60, 0x26, 0x00, 0x88, 0x04, 0x00, 0x1A, 0x00, 0xC0, 0x03, 0x40, 0x10,
  0x00, 0x28, 0x02, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x70, 0x00, 0x60, 0x0A, 0x00, 0x0C, 0x02, 0x40, 0x01, 0x80,
  0x48, 0x03, 0x30, 0x11, 0x81, 0xC6, 0x04, 0x10, 0xE0, 0x61, 0x03, 0x70,
  0x07, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00,
  0xC1, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x83,
  0x00, 0x02, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C,
  0x10, 0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x0A, 0x04, 0x00, 0x38, 0x18,
  0x01, 0x60, 0x20, 0x09, 0x80, 0xE0, 0xC6, 0x00, 0xFC, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x08, 0x00, 0x30, 0x30, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x06, 0x03, 0x0C, 0x01, 0xC2, 0x08,
  0x00, 0x32, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x10, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x03, 0x00, 0x10, 0x06, 0x00, 0x10, 0x0C,
  0x00, 0x10, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x4F, 0x80, 0x18, 0x40,
  0x78, 0x08, 0x40, 0x07, 0x88, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0x86, 0x30, 0x00, 0x86, 0x0C, 0x00, 0xC6,
  0x03, 0x00, 0x42, 0x00, 0xC0, 0x63, 0x00, 0x20, 0x61, 0x00, 0x0C, 0x61,
  0x80, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 33, 28, 10, -33 },
  { 34, 10, 12, 28, 12, -35 },
  { 49, 28, 33, 28, 1, -33 },
  { 165, 25, 44, 28, 2, -38 },
  { 303, 31, 34, 28, -1, -33 },
  { 435, 28, 34, 28, 0, -33 },
  { 554, 4, 12, 28, 15, -35 },
  { 560, 15, 42, 28, 11, -36 },
  { 639, 15, 42, 28, 3, -36 },
  { 718, 24, 23, 28, 3, -26 },
  { 787, 23, 23, 28, 3, -26 },
  { 854, 8, 12, 28, 7, -4 },
  { 866, 13, 1, 28, 8, -15 },
  { 868, 4, 4, 28, 10, -4 },
  { 870, 25, 42, 28, 2, -36 },
  { 1002, 23, 34, 28, 3, -33 },
  { 1100, 22, 33, 28, 2, -33 },
  { 1191, 23, 33, 28, 2, -33 },
  { 1286, 23, 34, 28, 2, -33 },
  { 1384, 24, 33, 28, 1, -33 },
  { 1483, 23, 34, 28, 3, -33 },
  { 1581, 20, 34, 28, 4, -33 },
  { 1666, 23, 33, 28, 5, -33 },
  { 1761, 23, 34, 28, 3, -33 },
  { 1859, 21, 33, 28, 5, -33 },
  { 1946, 8, 25, 28, 10, -25 },
  { 1971, 11, 33, 28, 7, -25 },
  { 2017, 23, 26, 28, 4, -27 },
  { 2092, 25, 9, 28, 2, -19 },
  { 2121, 23, 26, 28, 2, -27 },
  { 2196, 19, 33, 28, 7, -33 },
  { 2275, 21, 38, 28, 4, -33 },
  { 2375, 24, 33, 28, 0, -33 },
  { 2474, 22, 33, 28, 3, -33 },
  { 2565, 22, 34, 28, 4, -33 },
  { 2659, 23, 33, 28, 3, -33 },
  { 2754, 25, 33, 28, 3, -33 },
  { 2858, 25, 33, 28, 3, -33 },
  { 2962, 22, 34, 28, 4, -33 },
  { 3056, 25, 33, 28, 2, -33 },
  { 3160, 25, 33, 28, 2, -33 },
  { 3264, 22, 34, 28, 3, -33 },
  { 3358, 26, 33, 28, 3, -33 },
  { 3466, 18, 33, 28, 5, -33 },
  { 3541, 26, 33, 28, 2, -33 },
  { 3649, 25, 33, 28, 2, -33 },
  { 3753, 23, 34, 28, 3, -33 },
  { 3851, 24, 33, 28, 3, -33 },
  { 3950, 23, 41, 28, 3, -33 },
  { 4068, 24, 33, 28, 3, -33 },
  { 4167, 25, 34, 28, 2, -33 },
  { 4274, 25, 33, 28, 5, -33 },
  { 4378, 23, 34, 28, 4, -33 },
  { 4476, 23, 33, 28, 6, -33 },
  { 4571, 26, 33, 28, 3, -33 },
  { 4679, 29, 33, 28, 0, -33 },
  { 4799, 25, 33, 28, 5, -33 },
  { 4903, 28, 33, 28, 0, -33 },
  { 5019, 19, 42, 28, 9, -36 },
  { 5119, 11, 42, 28, 9, -36 },
  { 5177, 19, 42, 28, 1, -36 },
  { 5277, 22, 18, 28, 4, -33 },
  { 5327, 23, 1, 28, 0, 6 },
  { 5330, 5, 8, 28, 11, -36 },
  { 5335, 22, 26, 28, 3, -25 },
  { 5407, 22, 36, 28, 3, -35 },
  { 5506, 20, 26, 28, 4, -25 },
  { 5571, 23, 36, 28, 3, -35 },
  { 5675, 20, 26, 28, 4, -25 },
  { 5740, 30, 45, 28, -1, -35 },
  { 5909, 23, 35, 28, 2, -25 },
  { 6010, 20, 35, 28, 4, -35 },
  { 6098, 20, 36, 28, 4, -35 },
  { 6188, 19, 45, 28, 5, -35 },
  { 6295, 24, 36, 28, 3, -35 },
  { 6403, 18, 36, 28, 6, -35 },
  { 6484, 25, 25, 28, 2, -25 },
  { 6563, 20, 25, 28, 4, -25 },
  { 6626, 21, 26, 28, 4, -25 },
  { 6695, 23, 34, 28, 2, -25 },
  { 6793, 22, 34, 28, 3, -25 },
  { 6887, 23, 24, 28, 5, -24 },
  { 6956, 22, 26, 28, 3, -25 },
  { 7028, 22, 34, 28, 4, -33 },
  { 7122, 19, 25, 28, 5, -24 },
  { 7182, 21, 24, 28, 4, -24 },
  { 7245, 24, 25, 28, 3, -24 },
  { 7320, 27, 26, 28, 1, -25 },
  { 7408, 22, 34, 28, 2, -24 },
  { 7502, 24, 26, 28, 2, -25 },
  { 7580, 21, 42, 28, 6, -36 },
  { 7691, 9, 42, 28, 10, -36 },
  { 7739, 21, 42, 28, 2, -36 },
  { 7850, 25, 8, 28, 2, -18 },
};

const GFXfont IBMPlexMono_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC47PT7B_H_
