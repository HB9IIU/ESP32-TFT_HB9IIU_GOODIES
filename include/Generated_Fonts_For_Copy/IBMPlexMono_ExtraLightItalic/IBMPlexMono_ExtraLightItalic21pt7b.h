#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC21PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x50, 0x01, 0x20, 0x4A, 0x65, 0x29, 0x00, 0x03,
  0x20, 0x11, 0x00, 0x88, 0x08, 0x80, 0x44, 0x1E, 0x3C, 0x22, 0x01, 0x10,
  0x09, 0x07, 0x8F, 0x04, 0x40, 0x24, 0x02, 0x20, 0x11, 0x00, 0x90, 0x00,
  0x02, 0x00, 0x40, 0x3E, 0x19, 0x22, 0x22, 0x84, 0x11, 0x01, 0x20, 0x34,
  0x01, 0xE0, 0x12, 0x04, 0x20, 0x84, 0x10, 0xA2, 0x22, 0x4C, 0x3E, 0x02,
  0x00, 0x40, 0x00, 0x1E, 0x0C, 0x88, 0x42, 0x11, 0x10, 0x48, 0x42, 0x40,
  0x8A, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x68, 0x81, 0x21, 0x09, 0x04,
  0x44, 0x22, 0x08, 0x88, 0x1C, 0x00, 0x07, 0x80, 0x88, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x08, 0x83, 0x70, 0x44, 0x08, 0x20, 0x82, 0x08, 0x11,
  0x82, 0x94, 0x2A, 0x3C, 0x60, 0xF8, 0x06, 0x10, 0x41, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x43, 0x00, 0x02, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4E, 0x3E,
  0x03, 0x00, 0x90, 0x22, 0x08, 0x20, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x41, 0xFF, 0xC1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x00, 0x32, 0x44,
  0x80, 0xF8, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x00, 0x0F, 0x0C, 0x24, 0x09, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x22, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x30, 0x87,
  0xC0, 0x03, 0x01, 0x81, 0xA0, 0xC8, 0x62, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x0F, 0xFC, 0x0F, 0x84, 0x32, 0x04,
  0x81, 0x00, 0x40, 0x10, 0x08, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x30, 0x0F, 0xF8, 0x0F, 0x84, 0x32, 0x04, 0x01, 0x00, 0x40, 0x21, 0xF0,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x00, 0xC0,
  0x50, 0x18, 0x0A, 0x04, 0x82, 0x21, 0x08, 0x82, 0x21, 0x10, 0x48, 0x13,
  0xFF, 0x01, 0x00, 0x40, 0x20, 0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x0B, 0xC1, 0x84, 0x40, 0x80, 0x08, 0x01, 0x00, 0x48, 0x08, 0x82,
  0x0F, 0x80, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x79, 0xC2, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x14, 0x11, 0xF0, 0x7F, 0xD0, 0x18, 0x0A, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x00, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x84, 0x20,
  0x78, 0x30, 0x88, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x83, 0x0F, 0x80, 0x1F,
  0x10, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x87, 0x3D, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x81, 0x80, 0x6C, 0x00, 0x00, 0x12, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x88, 0x84, 0x40, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x18,
  0x18, 0x18, 0x08, 0x0C, 0x00, 0x1E, 0x61, 0x81, 0x81, 0x01, 0x01, 0x02,
  0x0C, 0x30, 0x20, 0x20, 0x00, 0x00, 0x60, 0x60, 0x0F, 0x18, 0x48, 0x28,
  0x14, 0x7C, 0x4E, 0x43, 0x21, 0x90, 0xD0, 0x68, 0x52, 0x29, 0xF4, 0x02,
  0x01, 0x80, 0x7E, 0x00, 0x01, 0x00, 0x50, 0x0A, 0x02, 0x40, 0x48, 0x11,
  0x02, 0x20, 0x82, 0x10, 0x43, 0xF8, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0,
  0x08, 0x1F, 0x88, 0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09, 0xFC, 0x40,
  0x90, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x2F, 0xF0, 0x0F, 0x04, 0x22, 0x05,
  0x02, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02, 0x81,
  0x10, 0x83, 0xC0, 0x1F, 0x04, 0x18, 0x81, 0x10, 0x12, 0x02, 0x40, 0x50,
  0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x48, 0x09, 0x02, 0x3F, 0x80,
  0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x03, 0xFE, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x3F, 0xE0, 0x1F, 0xE4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x03, 0xFE, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x0C, 0x22, 0x09, 0x03, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x87, 0xA0, 0x28, 0x0A, 0x04, 0x83, 0x10, 0xC3,
  0xD0, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x04, 0x80, 0x90, 0x13, 0xFE,
  0x40, 0x48, 0x09, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x3F, 0xE0,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x3F, 0xE0, 0x0F, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x81, 0x10,
  0x83, 0xC0, 0x20, 0x12, 0x02, 0x20, 0x42, 0x08, 0x23, 0x02, 0x40, 0x4C,
  0x05, 0x40, 0x62, 0x04, 0x20, 0x41, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80,
  0xC0, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x20, 0x26, 0x0C, 0xC1, 0xA8, 0x55, 0x12, 0x92,
  0x52, 0x92, 0x62, 0x44, 0x51, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20,
  0x20, 0x30, 0x26, 0x04, 0xC0, 0x94, 0x14, 0x84, 0x90, 0x91, 0x12, 0x22,
  0x44, 0x48, 0x49, 0x0A, 0x41, 0x48, 0x19, 0x03, 0x20, 0x60, 0x0F, 0x0C,
  0x24, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A,
  0x04, 0x81, 0x30, 0x87, 0xC0, 0x1F, 0xC4, 0x0C, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x50, 0x0A, 0x02, 0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x00, 0x0F, 0x0C, 0x24, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x30, 0x87, 0xC0, 0x40, 0x08, 0x81,
  0x40, 0x60, 0x1F, 0xC4, 0x0C, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A,
  0x02, 0x7F, 0x88, 0x81, 0x08, 0x21, 0x04, 0x11, 0x02, 0x20, 0x20, 0x0F,
  0x86, 0x08, 0x80, 0xA0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x78, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x28, 0x08, 0x83, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0xA0,
  0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x87, 0xC0,
  0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x44, 0x11,
  0x04, 0x81, 0x20, 0x50, 0x14, 0x02, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40,
  0x28, 0x05, 0x18, 0xA3, 0x24, 0xA4, 0x94, 0x94, 0x92, 0x94, 0x62, 0x8C,
  0x51, 0x06, 0x20, 0x80, 0x10, 0x08, 0x80, 0x82, 0x08, 0x10, 0x80, 0x48,
  0x02, 0x40, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x48, 0x02, 0x20, 0x21, 0x02,
  0x04, 0x20, 0x22, 0x00, 0x80, 0x80, 0x34, 0x04, 0x40, 0x44, 0x08, 0x21,
  0x02, 0x20, 0x12, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x03, 0xFF, 0x80, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF8,
  0x84, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x42,
  0x1F, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x04, 0x02, 0x81, 0x20, 0x44,
  0x21, 0x10, 0x28, 0x0A, 0x03, 0xFF, 0xC0, 0xA5, 0x1F, 0x4C, 0x34, 0x05,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x90, 0xC3, 0xCC, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x79, 0x46, 0xC1, 0x40, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0B, 0x09, 0x78, 0x1E, 0x30, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01,
  0x02, 0x81, 0x63, 0x0F, 0x00, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x3E, 0x8C, 0x32, 0x02, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x03,
  0x10, 0xC1, 0xE8, 0x1F, 0x10, 0xD0, 0x30, 0x18, 0x37, 0xE2, 0x01, 0x02,
  0x81, 0x61, 0x0F, 0x00, 0x00, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x0F, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x10, 0x80, 0x84, 0x03, 0x40, 0x0E, 0x00, 0x30,
  0x00, 0x1F, 0x4C, 0x34, 0x05, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81,
  0x90, 0xC3, 0xD0, 0x04, 0x01, 0x20, 0x87, 0xC0, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x71, 0x44, 0xC1, 0x40, 0xA0, 0xA0, 0x50, 0x28, 0x14, 0x0A,
  0x05, 0x04, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x44, 0x32, 0x61, 0x40, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x22, 0x11,
  0x88, 0x64, 0x0A, 0x02, 0x00, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x13,
  0xC5, 0x19, 0x82, 0x40, 0xA0, 0x48, 0xE2, 0x40, 0x90, 0x62, 0x28, 0x52,
  0x18, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x42, 0x47, 0x4C, 0x50, 0x60, 0x5C, 0xCC, 0xA5, 0x08, 0xA2, 0x14, 0x43,
  0x08, 0xA1, 0x14, 0x22, 0x88, 0x51, 0x0A, 0x21, 0x00, 0x4E, 0x28, 0x98,
  0x28, 0x14, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x80, 0x1E, 0x30,
  0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x61, 0x1F, 0x00, 0x27,
  0x8A, 0x33, 0x04, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0xA8, 0x49,
  0xE2, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x4C, 0x34, 0x05, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x02, 0x81, 0x90, 0xC3, 0xD0, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x7B, 0xF1, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x00, 0x1F, 0x08, 0x32, 0x00, 0x80, 0x20, 0x07,
  0xC0, 0x08, 0x02, 0x80, 0x90, 0x23, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x40,
  0xFF, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x86, 0x26, 0x0A,
  0x03, 0x00, 0x40, 0xA0, 0x50, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x87,
  0x43, 0x1E, 0x80, 0xE0, 0x90, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x04, 0x82,
  0x42, 0x26, 0x1C, 0x00, 0x42, 0x48, 0x45, 0x10, 0xA2, 0x14, 0x42, 0x88,
  0x61, 0x0C, 0x22, 0x8C, 0x52, 0x91, 0xCC, 0x00, 0x0C, 0x63, 0x49, 0x43,
  0x10, 0x21, 0x02, 0x00, 0x20, 0x02, 0x08, 0x60, 0x8A, 0x18, 0xA6, 0x71,
  0x80, 0x20, 0x48, 0x12, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x43,
  0x10, 0xC3, 0xD0, 0x04, 0x01, 0x21, 0x87, 0xC0, 0x3E, 0x48, 0x74, 0x05,
  0x06, 0x02, 0x01, 0x01, 0x80, 0x82, 0x40, 0xBF, 0x28, 0x78, 0x0F, 0x84,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x78, 0x06, 0x01, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x1F, 0x00, 0x24, 0x92, 0x92, 0x49,
  0x49, 0x24, 0x92, 0x00, 0x1F, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x08, 0x03, 0xC3, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x3E, 0x00, 0x38, 0x29, 0x8A, 0x11, 0x41, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 5, 5, 13, 5, -16 },
  { 11, 13, 15, 13, 0, -15 },
  { 36, 11, 19, 13, 1, -17 },
  { 63, 14, 15, 13, 0, -15 },
  { 90, 12, 15, 13, 0, -15 },
  { 113, 1, 5, 13, 7, -16 },
  { 114, 7, 19, 13, 5, -16 },
  { 131, 7, 19, 13, 1, -16 },
  { 148, 11, 10, 13, 1, -12 },
  { 162, 11, 11, 13, 1, -12 },
  { 178, 4, 5, 13, 3, -2 },
  { 181, 5, 1, 13, 4, -7 },
  { 182, 1, 2, 13, 5, -2 },
  { 183, 11, 19, 13, 1, -16 },
  { 210, 10, 15, 13, 2, -15 },
  { 229, 10, 15, 13, 1, -15 },
  { 248, 10, 15, 13, 1, -15 },
  { 267, 10, 15, 13, 1, -15 },
  { 286, 10, 15, 13, 1, -15 },
  { 305, 11, 15, 13, 1, -15 },
  { 326, 9, 15, 13, 2, -15 },
  { 343, 10, 15, 13, 2, -15 },
  { 362, 11, 15, 13, 1, -15 },
  { 383, 9, 15, 13, 2, -15 },
  { 400, 3, 11, 13, 5, -11 },
  { 405, 5, 14, 13, 3, -11 },
  { 414, 10, 11, 13, 2, -12 },
  { 428, 11, 5, 13, 1, -9 },
  { 435, 10, 11, 13, 1, -12 },
  { 449, 8, 15, 13, 3, -15 },
  { 464, 9, 17, 13, 2, -15 },
  { 484, 11, 15, 13, 0, -15 },
  { 505, 10, 15, 13, 1, -15 },
  { 524, 10, 15, 13, 2, -15 },
  { 543, 11, 15, 13, 1, -15 },
  { 564, 11, 15, 13, 1, -15 },
  { 585, 11, 15, 13, 1, -15 },
  { 606, 10, 15, 13, 2, -15 },
  { 625, 11, 15, 13, 1, -15 },
  { 646, 11, 15, 13, 1, -15 },
  { 667, 10, 15, 13, 1, -15 },
  { 686, 12, 15, 13, 1, -15 },
  { 709, 8, 15, 13, 2, -15 },
  { 724, 11, 15, 13, 1, -15 },
  { 745, 11, 15, 13, 1, -15 },
  { 766, 10, 15, 13, 2, -15 },
  { 785, 11, 15, 13, 1, -15 },
  { 806, 10, 19, 13, 2, -15 },
  { 830, 11, 15, 13, 1, -15 },
  { 851, 11, 15, 13, 1, -15 },
  { 872, 11, 15, 13, 2, -15 },
  { 893, 10, 15, 13, 2, -15 },
  { 912, 10, 15, 13, 3, -15 },
  { 931, 11, 15, 13, 2, -15 },
  { 952, 13, 15, 13, 0, -15 },
  { 977, 12, 15, 13, 2, -15 },
  { 1000, 13, 15, 13, 0, -15 },
  { 1025, 8, 19, 13, 4, -16 },
  { 1044, 5, 19, 13, 4, -16 },
  { 1056, 8, 19, 13, 1, -16 },
  { 1075, 10, 8, 13, 2, -15 },
  { 1085, 10, 1, 13, 0, 2 },
  { 1087, 2, 4, 13, 5, -17 },
  { 1088, 10, 11, 13, 1, -11 },
  { 1102, 9, 16, 13, 2, -16 },
  { 1120, 9, 11, 13, 2, -11 },
  { 1133, 11, 16, 13, 1, -16 },
  { 1155, 9, 11, 13, 2, -11 },
  { 1168, 13, 20, 13, 0, -16 },
  { 1201, 10, 15, 13, 1, -11 },
  { 1220, 9, 16, 13, 2, -16 },
  { 1238, 9, 15, 13, 2, -15 },
  { 1255, 9, 19, 13, 2, -15 },
  { 1277, 10, 16, 13, 2, -16 },
  { 1297, 8, 16, 13, 3, -16 },
  { 1313, 11, 11, 13, 1, -11 },
  { 1329, 9, 11, 13, 2, -11 },
  { 1342, 9, 11, 13, 2, -11 },
  { 1355, 10, 15, 13, 1, -11 },
  { 1374, 10, 15, 13, 1, -11 },
  { 1393, 11, 11, 13, 2, -11 },
  { 1409, 10, 11, 13, 1, -11 },
  { 1423, 10, 15, 13, 2, -15 },
  { 1442, 9, 11, 13, 2, -11 },
  { 1455, 9, 11, 13, 2, -11 },
  { 1468, 11, 11, 13, 1, -11 },
  { 1484, 12, 11, 13, 0, -11 },
  { 1501, 10, 15, 13, 1, -11 },
  { 1520, 10, 11, 13, 1, -11 },
  { 1534, 9, 19, 13, 3, -16 },
  { 1556, 3, 19, 13, 5, -16 },
  { 1564, 9, 19, 13, 1, -16 },
  { 1586, 11, 4, 13, 1, -8 },
};

const GFXfont IBMPlexMono_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC21PT7B_H_
