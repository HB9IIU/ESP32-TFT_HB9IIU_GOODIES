#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC36PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x61, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x80, 0x00, 0x00, 0x0E, 0x38, 0xE0, 0x61, 0x63, 0x43, 0x42,
  0x42, 0x42, 0xC2, 0xC6, 0x86, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x08,
  0x30, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x10, 0x20, 0x3F, 0x83, 0xF8, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0xFC,
  0x0F, 0xE0, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00,
  0x0C, 0x10, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00,
  0x30, 0x9C, 0x04, 0x10, 0x60, 0x81, 0x03, 0x08, 0x10, 0x01, 0x81, 0x00,
  0x18, 0x10, 0x01, 0x81, 0x00, 0x18, 0x20, 0x00, 0x82, 0x00, 0x06, 0x20,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x06, 0x70, 0x00, 0x41, 0x00, 0x04,
  0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x80,
  0x80, 0x84, 0x08, 0x10, 0x60, 0x83, 0x01, 0x88, 0xE0, 0x07, 0xF0, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0,
  0x01, 0x03, 0x08, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x04, 0x0C, 0x08, 0x04,
  0x08, 0x08, 0x04, 0x10, 0x08, 0x04, 0x20, 0x08, 0x0C, 0x60, 0x08, 0x08,
  0x40, 0x08, 0x18, 0x80, 0x04, 0x31, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xC6, 0x30, 0x01, 0x88, 0x18, 0x01, 0x18,
  0x08, 0x02, 0x10, 0x08, 0x04, 0x10, 0x08, 0x0C, 0x10, 0x08, 0x08, 0x10,
  0x18, 0x10, 0x10, 0x10, 0x20, 0x10, 0x30, 0x60, 0x08, 0x60, 0xC0, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x40, 0x04, 0x03, 0x00,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x30, 0x02, 0x01,
  0x00, 0x18, 0x08, 0x00, 0x40, 0x80, 0x07, 0x08, 0x01, 0xCF, 0x80, 0x18,
  0x20, 0x01, 0x81, 0x80, 0x08, 0x04, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0,
  0x30, 0x02, 0x01, 0x80, 0x18, 0x1C, 0x01, 0x61, 0xA0, 0x09, 0x09, 0x80,
  0x84, 0x86, 0x0C, 0x2C, 0x0F, 0x80, 0xC0, 0x57, 0xEA, 0x80, 0x00, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x04,
  0x04, 0x07, 0xE1, 0x0F, 0x0F, 0x5C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0D,
  0x80, 0x06, 0x20, 0x01, 0x04, 0x00, 0x81, 0x00, 0x40, 0x20, 0x20, 0x0C,
  0x18, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xE0,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x19, 0x8C, 0x46, 0x23, 0x10, 0x80,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0x83, 0x03, 0x00, 0xC3, 0x00, 0x21, 0x00, 0x19, 0x00,
  0x0C, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x1C, 0x1C, 0x0C, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03,
  0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x46, 0x00, 0x41, 0x00,
  0x40, 0x60, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x78, 0x01, 0x98,
  0x03, 0x10, 0x06, 0x10, 0x18, 0x10, 0x30, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x60,
  0xC0, 0x60, 0x08, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0x83, 0x03, 0x00, 0x43,
  0x00, 0x31, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x41, 0x80, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x24, 0x00, 0x23, 0x00, 0x30, 0xE0, 0x60, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09, 0x80, 0x04,
  0x60, 0x03, 0x10, 0x01, 0x84, 0x00, 0xC1, 0x00, 0x60, 0x40, 0x10, 0x30,
  0x08, 0x08, 0x04, 0x02, 0x02, 0x00, 0x81, 0x80, 0x20, 0xC0, 0x08, 0x60,
  0x06, 0x30, 0x01, 0x0F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC1, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x1F, 0x80, 0x58, 0x30, 0x38,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x30, 0x01, 0x86, 0x00, 0xC0,
  0xC0, 0x60, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x23, 0xF0, 0x6C, 0x1C, 0x50, 0x06, 0xE0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0xC0,
  0x0C, 0x40, 0x18, 0x30, 0x30, 0x1F, 0xC0, 0x7F, 0xFF, 0xA0, 0x00, 0xD0,
  0x00, 0x48, 0x00, 0x64, 0x00, 0x66, 0x00, 0x22, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x20, 0x03, 0x18, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x18, 0x00, 0x82, 0x00, 0x40,
  0x60, 0x60, 0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x00, 0xC6, 0x00, 0x11, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0xC0, 0x01,
  0x10, 0x00, 0x86, 0x00, 0x60, 0xE0, 0x60, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x1C, 0x18, 0x30, 0x04, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0xC0, 0x0E, 0x40, 0x14,
  0x30, 0x24, 0x1F, 0xCC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0x8E, 0x00, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x80, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x10, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xE0, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x24, 0x00, 0x78, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x78,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x03, 0x06, 0x04, 0x03, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x79, 0x20, 0x85, 0x61, 0x03, 0x43, 0x01, 0x42, 0x01, 0x42,
  0x03, 0x46, 0x02, 0xC4, 0x02, 0x84, 0x02, 0x84, 0x02, 0x84, 0x06, 0x84,
  0x06, 0x86, 0x0C, 0x82, 0x14, 0x81, 0xE4, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x40, 0x18, 0x10, 0x04, 0x04,
  0x03, 0x01, 0x00, 0x80, 0x60, 0x60, 0x18, 0x10, 0x02, 0x0F, 0xFF, 0x82,
  0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x30, 0x00, 0xC8, 0x00, 0x36, 0x00,
  0x05, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x0F, 0xFC, 0x04, 0x01, 0x82, 0x00,
  0x61, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0xFF, 0x81, 0x00, 0x30,
  0x80, 0x0C, 0x40, 0x02, 0x60, 0x01, 0x30, 0x00, 0xD0, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x18, 0xFF, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x31, 0x00, 0x08, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x44, 0x00, 0x62, 0x00, 0x60, 0x80,
  0x60, 0x30, 0x60, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x02, 0x01, 0x80, 0x80,
  0x10, 0x20, 0x02, 0x08, 0x00, 0x86, 0x00, 0x31, 0x80, 0x04, 0x60, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x98, 0x00, 0x66, 0x00,
  0x11, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0xC3, 0x00, 0xC0,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF8, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x00, 0x31,
  0x00, 0x09, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x07, 0xFA, 0x00, 0x0D, 0x00,
  0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x62,
  0x00, 0x71, 0x80, 0x50, 0x60, 0x48, 0x0F, 0xC4, 0x00, 0x08, 0x00, 0x61,
  0x00, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x02, 0x10,
  0x00, 0x43, 0xFF, 0xF8, 0x40, 0x03, 0x08, 0x00, 0x43, 0x00, 0x08, 0x60,
  0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x21, 0x80,
  0x04, 0x30, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x00, 0x0F, 0xFF, 0xE0,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x8C, 0x00, 0xC2, 0x00, 0x41, 0x80, 0x40, 0x60, 0xC0,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80,
  0x18, 0x08, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x01, 0x80, 0x10,
  0x30, 0x01, 0x04, 0x00, 0x10, 0x80, 0x03, 0x1C, 0x00, 0x32, 0x40, 0x02,
  0x46, 0x00, 0x38, 0x20, 0x03, 0x03, 0x00, 0x20, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x04, 0x00, 0xC0, 0x40, 0x04, 0x04, 0x00, 0x60, 0x40, 0x02,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xFF, 0xFE, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x0A, 0x00,
  0x50, 0xA0, 0x0D, 0x0A, 0x00, 0xB0, 0x90, 0x1A, 0x19, 0x01, 0x21, 0x90,
  0x22, 0x11, 0x86, 0x21, 0x08, 0x46, 0x10, 0x88, 0x61, 0x08, 0x84, 0x30,
  0x50, 0x43, 0x07, 0x04, 0x20, 0x60, 0x42, 0x04, 0x0C, 0x20, 0x40, 0xC2,
  0x00, 0x08, 0x60, 0x00, 0x86, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x18,
  0x40, 0x01, 0x84, 0x00, 0x10, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x21, 0x80,
  0x0C, 0x38, 0x01, 0x0D, 0x00, 0x21, 0xA0, 0x04, 0x26, 0x00, 0x84, 0x40,
  0x10, 0x88, 0x06, 0x11, 0x80, 0x86, 0x10, 0x10, 0xC2, 0x02, 0x10, 0x60,
  0x42, 0x04, 0x08, 0x40, 0x83, 0x08, 0x18, 0x43, 0x01, 0x08, 0x60, 0x21,
  0x08, 0x06, 0x21, 0x00, 0x44, 0x20, 0x09, 0x84, 0x01, 0xA1, 0x80, 0x14,
  0x20, 0x02, 0x84, 0x00, 0x70, 0x80, 0x06, 0x00, 0x01, 0xF8, 0x03, 0x83,
  0x03, 0x00, 0xC3, 0x00, 0x21, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0xC8, 0x00, 0x46, 0x00, 0x41, 0x00, 0x40, 0x60, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x01, 0x00, 0x30, 0x20, 0x03, 0x04, 0x00, 0x20,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x7F, 0xF8, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0x83, 0x03, 0x00, 0xC3, 0x00, 0x21, 0x00,
  0x19, 0x00, 0x0C, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x03, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x46, 0x00,
  0x41, 0x00, 0x40, 0x60, 0xC0, 0x0F, 0x80, 0x01, 0x80, 0x00, 0x40, 0x80,
  0x10, 0x60, 0x0C, 0x40, 0x02, 0xC0, 0x00, 0xC0, 0x0F, 0xFF, 0x01, 0x00,
  0x30, 0x20, 0x03, 0x04, 0x00, 0x20, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x18, 0x00,
  0xC3, 0x00, 0x30, 0x7F, 0xF8, 0x08, 0x10, 0x01, 0x01, 0x00, 0x20, 0x20,
  0x0C, 0x06, 0x01, 0x80, 0x40, 0x20, 0x0C, 0x04, 0x00, 0x80, 0x80, 0x18,
  0x10, 0x01, 0x06, 0x00, 0x30, 0xC0, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x60,
  0x38, 0x10, 0x01, 0x84, 0x00, 0x10, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x48, 0x00, 0x08, 0x80, 0x02,
  0x18, 0x00, 0xC0, 0xC0, 0x60, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0xC4, 0x00,
  0x31, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18,
  0x80, 0x06, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x03, 0x10, 0x00, 0xC4, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x01,
  0x88, 0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x30, 0x02, 0x04, 0x01, 0x81,
  0x80, 0xC0, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x09,
  0x00, 0x06, 0x40, 0x01, 0x18, 0x00, 0xC6, 0x00, 0x20, 0x80, 0x18, 0x20,
  0x04, 0x08, 0x03, 0x02, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x04, 0x0C,
  0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x30, 0x01, 0x88, 0x00,
  0x66, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x01, 0xA0, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x32, 0x06, 0x04, 0x40, 0xC0, 0x88,
  0x38, 0x11, 0x05, 0x06, 0x21, 0xA0, 0x84, 0x26, 0x11, 0x84, 0xC2, 0x31,
  0x08, 0xC6, 0x21, 0x10, 0x8C, 0x22, 0x11, 0x04, 0x42, 0x60, 0x98, 0x48,
  0x12, 0x09, 0x02, 0x41, 0x40, 0x78, 0x28, 0x0E, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x00, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x20, 0x01, 0x00, 0xC0,
  0x0C, 0x01, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0x40,
  0x00, 0x42, 0x00, 0x01, 0x98, 0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x33, 0x00, 0x01, 0x84,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x20, 0x01, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x60, 0x06, 0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80,
  0x00, 0x78, 0x00, 0x09, 0x00, 0x02, 0x30, 0x00, 0x82, 0x00, 0x30, 0x60,
  0x0C, 0x04, 0x03, 0x00, 0x80, 0x40, 0x08, 0x10, 0x01, 0x06, 0x00, 0x11,
  0x80, 0x02, 0x60, 0x00, 0x68, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x3F, 0xE0, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x03, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xE0,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x24, 0x00, 0x33, 0x00, 0x30, 0x80, 0x10,
  0x60, 0x10, 0x10, 0x18, 0x08, 0x18, 0x02, 0x08, 0x01, 0x08, 0x00, 0xCC,
  0x00, 0x2C, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x8C, 0x46, 0x23,
  0x03, 0xF0, 0x83, 0x06, 0xC6, 0x01, 0x42, 0x00, 0x62, 0x00, 0x11, 0x00,
  0x09, 0x80, 0x04, 0x80, 0x06, 0x40, 0x03, 0x20, 0x01, 0x30, 0x00, 0x98,
  0x00, 0x4C, 0x00, 0x66, 0x00, 0x31, 0x00, 0x38, 0x80, 0x18, 0x60, 0x14,
  0x18, 0x32, 0x03, 0xE1, 0xE0, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x11, 0xF8, 0x12,
  0x0C, 0x34, 0x02, 0x28, 0x03, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x04, 0xC0, 0x0C, 0xA0, 0x18, 0x90, 0x30, 0x8F, 0xC0, 0x03,
  0xF0, 0x18, 0x30, 0x60, 0x11, 0x80, 0x16, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0xB0, 0x01, 0xA0, 0x04, 0x60, 0x10, 0x60, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x03, 0xF0, 0x81, 0x83, 0x60, 0x80, 0x38,
  0x40, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x0C, 0x40,
  0x03, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01,
  0x84, 0x00, 0x61, 0x00, 0x30, 0x20, 0x14, 0x0C, 0x19, 0x00, 0xF8, 0x40,
  0x01, 0xF0, 0x0C, 0x18, 0x60, 0x19, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x50,
  0x00, 0xE0, 0x02, 0xC0, 0x19, 0x03, 0xC3, 0xFC, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0xA0, 0x01, 0xA0, 0x06, 0x60, 0x18, 0x60, 0x60, 0x3F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x20, 0x30, 0x00, 0x40, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x88,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0,
  0x83, 0x06, 0xC2, 0x00, 0xE2, 0x00, 0x62, 0x00, 0x11, 0x00, 0x09, 0x80,
  0x04, 0x80, 0x06, 0x40, 0x03, 0x20, 0x01, 0x30, 0x00, 0x98, 0x00, 0x4C,
  0x00, 0x22, 0x00, 0x31, 0x00, 0x18, 0x80, 0x18, 0x20, 0x14, 0x18, 0x32,
  0x03, 0xE1, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x61, 0x00,
  0x60, 0xE0, 0x60, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0xF8, 0x26,
  0x18, 0x50, 0x19, 0xC0, 0x13, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x06, 0xC0, 0x0D, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x03, 0x60, 0x06, 0xC0, 0x09, 0x00, 0x12, 0x00, 0x20, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x20, 0x81, 0x81, 0x04, 0x02, 0x30, 0x0C, 0xC0, 0x1A, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x04, 0x06, 0x04, 0x0C, 0x04, 0x10, 0x06, 0x20, 0x06, 0x40,
  0x06, 0x80, 0x06, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0xF8,
  0x04, 0xC1, 0x03, 0x40, 0x20, 0xE0, 0x08, 0x30, 0x02, 0x0C, 0x00, 0x82,
  0x00, 0x60, 0x80, 0x30, 0x60, 0x18, 0x18, 0x18, 0x04, 0x78, 0x01, 0x08,
  0x00, 0x43, 0x00, 0x10, 0x40, 0x3C, 0x18, 0x13, 0x02, 0x08, 0x80, 0x44,
  0x20, 0x12, 0x08, 0x03, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x0C, 0x20, 0x41, 0x86, 0x06, 0x30, 0x11,
  0x00, 0x58, 0x01, 0x80, 0x00, 0x19, 0xC3, 0xC2, 0xC4, 0x8C, 0x60, 0xA0,
  0x8C, 0x18, 0x11, 0x03, 0x02, 0x60, 0x40, 0x4C, 0x08, 0x09, 0x01, 0x01,
  0x20, 0x20, 0x64, 0x04, 0x0C, 0x81, 0x81, 0x30, 0x20, 0x26, 0x04, 0x04,
  0x80, 0x80, 0x90, 0x10, 0x32, 0x02, 0x06, 0x40, 0xC0, 0x98, 0x10, 0x13,
  0x02, 0x02, 0x00, 0x10, 0xF8, 0x26, 0x18, 0x50, 0x19, 0xC0, 0x13, 0x00,
  0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x06, 0xC0, 0x0D, 0x80, 0x12,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x00,
  0x12, 0x00, 0x20, 0x03, 0xF0, 0x0C, 0x0C, 0x18, 0x04, 0x30, 0x02, 0x60,
  0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x40, 0x08, 0x60,
  0x18, 0x30, 0x70, 0x0F, 0x80, 0x04, 0x7E, 0x03, 0x20, 0xC0, 0xD0, 0x08,
  0x28, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x18,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00,
  0x23, 0x00, 0x10, 0xC0, 0x0C, 0x28, 0x06, 0x09, 0x03, 0x02, 0x3F, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x83, 0x06, 0xC2, 0x00, 0xE2, 0x00,
  0x62, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x06, 0x40, 0x03, 0x20,
  0x01, 0x30, 0x00, 0x98, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x31, 0x00, 0x18,
  0x80, 0x18, 0x20, 0x14, 0x18, 0x32, 0x03, 0xE1, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0xFF, 0x1F, 0x81, 0xB0, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x03, 0x03, 0x82, 0x00, 0x62,
  0x00, 0x21, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x05, 0x80, 0x04, 0x60, 0x06, 0x1C, 0x0E, 0x03, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x03, 0xFF,
  0xFE, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x81, 0x81, 0xA0, 0xC1, 0x80, 0x43, 0x00, 0x22, 0x00, 0x16,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x40, 0x28,
  0x40, 0x48, 0x30, 0xC8, 0x1F, 0x18, 0xFC, 0x03, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x03,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x08, 0x30, 0x18,
  0x20, 0x30, 0x20, 0x60, 0x23, 0x80, 0x3E, 0x00, 0x10, 0x20, 0x84, 0x08,
  0x13, 0x02, 0x04, 0x80, 0x81, 0x20, 0x20, 0x48, 0x18, 0x12, 0x04, 0x04,
  0x81, 0x01, 0x60, 0x40, 0x50, 0x10, 0x14, 0x04, 0x05, 0x03, 0x01, 0x40,
  0x80, 0xD0, 0x20, 0x2C, 0x08, 0x0B, 0x06, 0x04, 0xC2, 0x83, 0x10, 0x91,
  0x83, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0xC8, 0x62, 0x30, 0x48, 0x14, 0x04,
  0x81, 0x00, 0x50, 0x10, 0x05, 0x01, 0x00, 0x60, 0x10, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x80, 0xC0, 0x08,
  0x0C, 0x00, 0x81, 0x60, 0x08, 0x12, 0x06, 0x82, 0x21, 0x8C, 0x63, 0x60,
  0x78, 0x1C, 0x00, 0x04, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x02,
  0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x04,
  0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x03, 0x0C, 0x00, 0x83, 0x00,
  0x60, 0x40, 0x28, 0x10, 0x12, 0x03, 0x0D, 0x80, 0x7C, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x81, 0x00, 0x60, 0xE0, 0x70, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xC6, 0x0F, 0x23, 0x00, 0x78, 0x80, 0x06, 0x20,
  0x02, 0x08, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x08, 0x0C, 0x02, 0x06, 0x00, 0x83, 0x00, 0x21,
  0x80, 0x08, 0xFE, 0x03, 0x21, 0xFC, 0x48, 0x03, 0xE0, 0x00, 0xFF, 0x80,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x06, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x3F, 0xC0, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08,
  0x21, 0x84, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x20, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x01, 0xE0, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x4C,
  0x40, 0x12, 0x08, 0x09, 0x03, 0x02, 0x40, 0x41, 0x20, 0x08, 0xC8, 0x01,
  0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 25, 22, 8, -25 },
  { 20, 8, 9, 22, 9, -27 },
  { 29, 21, 25, 22, 1, -25 },
  { 95, 20, 33, 22, 1, -29 },
  { 178, 24, 25, 22, -1, -25 },
  { 253, 21, 25, 22, 0, -25 },
  { 319, 2, 9, 22, 12, -27 },
  { 322, 12, 32, 22, 8, -27 },
  { 370, 12, 32, 22, 2, -27 },
  { 418, 18, 18, 22, 2, -20 },
  { 459, 18, 17, 22, 2, -19 },
  { 498, 5, 9, 22, 6, -3 },
  { 504, 10, 1, 22, 6, -11 },
  { 506, 3, 3, 22, 8, -3 },
  { 508, 20, 32, 22, 1, -27 },
  { 588, 17, 25, 22, 3, -25 },
  { 642, 16, 25, 22, 2, -25 },
  { 692, 18, 25, 22, 1, -25 },
  { 749, 17, 25, 22, 2, -25 },
  { 803, 18, 25, 22, 1, -25 },
  { 860, 18, 25, 22, 2, -25 },
  { 917, 16, 25, 22, 3, -25 },
  { 967, 17, 25, 22, 4, -25 },
  { 1021, 18, 25, 22, 2, -25 },
  { 1078, 16, 25, 22, 4, -25 },
  { 1128, 6, 19, 22, 8, -19 },
  { 1143, 8, 25, 22, 6, -19 },
  { 1168, 17, 20, 22, 3, -21 },
  { 1211, 18, 8, 22, 2, -15 },
  { 1229, 17, 20, 22, 2, -21 },
  { 1272, 15, 25, 22, 5, -25 },
  { 1319, 16, 29, 22, 3, -25 },
  { 1377, 18, 25, 22, 0, -25 },
  { 1434, 17, 25, 22, 2, -25 },
  { 1488, 17, 25, 22, 3, -25 },
  { 1542, 18, 25, 22, 2, -25 },
  { 1599, 19, 25, 22, 2, -25 },
  { 1659, 19, 25, 22, 2, -25 },
  { 1719, 17, 25, 22, 3, -25 },
  { 1773, 19, 25, 22, 2, -25 },
  { 1833, 19, 25, 22, 2, -25 },
  { 1893, 17, 25, 22, 2, -25 },
  { 1947, 20, 25, 22, 2, -25 },
  { 2010, 15, 25, 22, 3, -25 },
  { 2057, 20, 25, 22, 1, -25 },
  { 2120, 19, 25, 22, 2, -25 },
  { 2180, 17, 25, 22, 3, -25 },
  { 2234, 19, 25, 22, 2, -25 },
  { 2294, 17, 31, 22, 3, -25 },
  { 2360, 19, 25, 22, 2, -25 },
  { 2420, 19, 25, 22, 1, -25 },
  { 2480, 19, 25, 22, 4, -25 },
  { 2540, 18, 25, 22, 3, -25 },
  { 2597, 18, 25, 22, 4, -25 },
  { 2654, 19, 25, 22, 3, -25 },
  { 2714, 22, 25, 22, 0, -25 },
  { 2783, 19, 25, 22, 4, -25 },
  { 2843, 22, 25, 22, 0, -25 },
  { 2912, 14, 32, 22, 7, -27 },
  { 2968, 9, 32, 22, 7, -27 },
  { 3004, 14, 32, 22, 1, -27 },
  { 3060, 17, 14, 22, 3, -25 },
  { 3090, 17, 1, 22, 0, 4 },
  { 3093, 4, 6, 22, 9, -27 },
  { 3096, 17, 19, 22, 2, -19 },
  { 3137, 16, 27, 22, 3, -27 },
  { 3191, 15, 19, 22, 3, -19 },
  { 3227, 18, 27, 22, 2, -27 },
  { 3288, 15, 19, 22, 3, -19 },
  { 3324, 22, 34, 22, 0, -27 },
  { 3418, 17, 26, 22, 2, -19 },
  { 3474, 15, 27, 22, 3, -27 },
  { 3525, 15, 27, 22, 3, -27 },
  { 3576, 15, 34, 22, 4, -27 },
  { 3640, 18, 27, 22, 3, -27 },
  { 3701, 14, 27, 22, 4, -27 },
  { 3749, 19, 19, 22, 1, -19 },
  { 3795, 15, 19, 22, 3, -19 },
  { 3831, 16, 19, 22, 3, -19 },
  { 3869, 18, 26, 22, 1, -19 },
  { 3928, 17, 26, 22, 2, -19 },
  { 3984, 17, 19, 22, 4, -19 },
  { 4025, 17, 19, 22, 2, -19 },
  { 4066, 17, 25, 22, 3, -25 },
  { 4120, 16, 19, 22, 3, -19 },
  { 4158, 16, 19, 22, 3, -19 },
  { 4196, 18, 19, 22, 2, -19 },
  { 4239, 20, 19, 22, 1, -19 },
  { 4287, 18, 26, 22, 1, -19 },
  { 4346, 18, 19, 22, 2, -19 },
  { 4389, 17, 32, 22, 4, -27 },
  { 4457, 6, 32, 22, 8, -27 },
  { 4481, 16, 32, 22, 2, -27 },
  { 4545, 18, 7, 22, 2, -14 },
};

const GFXfont IBMPlexMono_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC36PT7B_H_
