#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC58PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x03, 0x98,
  0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x06,
  0x30, 0x33, 0x81, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x31, 0xF0, 0x01, 0xC0,
  0x60, 0x70, 0x07, 0x00, 0xC0, 0x70, 0x1C, 0x01, 0x00, 0x70, 0x30, 0x02,
  0x00, 0x40, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x00, 0xF8, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x18, 0xF8, 0x00, 0x00, 0x20, 0x78, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00, 0x20, 0x03, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x40, 0x06,
  0x00, 0x61, 0xC0, 0x08, 0x01, 0x81, 0xC0, 0x10, 0x07, 0x01, 0xC0, 0x60,
  0x1C, 0x01, 0xC0, 0xC0, 0x70, 0x01, 0xF1, 0x87, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1C, 0x01, 0xC1, 0xE0, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x00, 0x80, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x83, 0xC1, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0E, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x38, 0x06, 0x00,
  0x00, 0x60, 0xE0, 0x06, 0x00, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x06, 0x02,
  0x00, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x80, 0x03, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x60, 0x02, 0x00, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x1C, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x1E, 0x00, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x1F, 0x83, 0x80, 0x00, 0x7E, 0xCF, 0x00, 0x00, 0x70, 0x7E, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x16, 0x00, 0xF0, 0x00, 0x0B, 0x80, 0xD8, 0x00, 0x0C, 0xC0, 0xCE, 0x00,
  0x04, 0x30, 0x63, 0x00, 0x06, 0x18, 0x61, 0xC0, 0x06, 0x06, 0x70, 0x78,
  0x0E, 0x03, 0xB0, 0x0F, 0xFE, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x38, 0x00,
  0x33, 0x37, 0x66, 0x66, 0x6E, 0xCC, 0xCC, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x07, 0xF0, 0x0C, 0x03, 0xF3,
  0xF0, 0x60, 0xFC, 0x03, 0xF3, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x70,
  0x03, 0x60, 0x0F, 0x00, 0x36, 0x00, 0xF0, 0x07, 0x60, 0x0F, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x60, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x78, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x03, 0xC0, 0x30,
  0x00, 0xF0, 0x0C, 0x00, 0x3C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x0F,
  0xF0, 0x00, 0x33, 0xFF, 0xE0, 0x01, 0xB8, 0x07, 0x80, 0x1B, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x1F, 0xE0,
  0x07, 0x1F, 0xFE, 0x01, 0x9E, 0x03, 0xE0, 0xEE, 0x00, 0x1C, 0x36, 0x00,
  0x03, 0x0F, 0x00, 0x00, 0x66, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x1F, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x3E, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x71, 0x80, 0x00, 0x2C,
  0x70, 0x00, 0x1B, 0x0E, 0x00, 0x1D, 0x81, 0xE0, 0x1E, 0x60, 0x3F, 0xFE,
  0x30, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x07, 0x80, 0x78, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x10, 0xC0, 0x0F, 0x86, 0x18, 0x07, 0xFC, 0xC6, 0x01,
  0xC0, 0xD8, 0xC0, 0x70, 0x0B, 0x18, 0x0C, 0x00, 0xE3, 0x03, 0x00, 0x1C,
  0xC0, 0x60, 0x03, 0x18, 0x18, 0x00, 0x63, 0x03, 0x00, 0x0C, 0x60, 0x60,
  0x01, 0x8C, 0x0C, 0x00, 0x33, 0x03, 0x00, 0x06, 0x60, 0x60, 0x01, 0x8C,
  0x0C, 0x00, 0x31, 0x81, 0x80, 0x06, 0x30, 0x30, 0x00, 0xC6, 0x06, 0x00,
  0x38, 0xC0, 0xC0, 0x07, 0x10, 0x18, 0x01, 0xC6, 0x03, 0x00, 0x38, 0xC0,
  0x30, 0x0B, 0x18, 0x07, 0x06, 0x63, 0x00, 0x7F, 0x8C, 0x60, 0x07, 0xE1,
  0x84, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x07, 0x06, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x38, 0x03, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xCC,
  0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x16,
  0x03, 0x00, 0x03, 0x60, 0x3C, 0x00, 0x66, 0x01, 0xF0, 0x1C, 0x60, 0x07,
  0xFF, 0x8C, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x06, 0xC0, 0x00, 0x01, 0x86, 0x60, 0x00, 0x00, 0xC6, 0x18,
  0x00, 0x00, 0x66, 0x0C, 0x00, 0x00, 0x76, 0x03, 0x00, 0x00, 0x3E, 0x01,
  0x80, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x60,
  0x00, 0x1B, 0x03, 0x60, 0x00, 0x1B, 0x03, 0x60, 0x00, 0x36, 0x03, 0x30,
  0x00, 0x76, 0x03, 0x30, 0x00, 0x66, 0x06, 0x30, 0x00, 0xC6, 0x06, 0x30,
  0x00, 0xC6, 0x06, 0x18, 0x01, 0x86, 0x06, 0x18, 0x03, 0x0C, 0x06, 0x18,
  0x03, 0x0C, 0x06, 0x08, 0x06, 0x0C, 0x0C, 0x0C, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x18, 0x18, 0x0C, 0x06,
  0x30, 0x18, 0x0C, 0x06, 0x30, 0x18, 0x18, 0x06, 0x60, 0x18, 0x18, 0x03,
  0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18, 0x18, 0x03, 0x80, 0x30, 0x18, 0x01,
  0x80, 0x30, 0x18, 0x01, 0x00, 0x30, 0x30, 0x02, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x18, 0x0F, 0x80,
  0x00, 0x30, 0x1B, 0x00, 0x00, 0x60, 0x36, 0x00, 0x00, 0xC0, 0x6E, 0x00,
  0x01, 0x80, 0xCC, 0x00, 0x07, 0x03, 0x18, 0x00, 0x0C, 0x06, 0x38, 0x00,
  0x18, 0x0C, 0x30, 0x00, 0x30, 0x18, 0x60, 0x00, 0x60, 0x30, 0xE0, 0x00,
  0xC0, 0x60, 0xC0, 0x03, 0x01, 0x81, 0x80, 0x06, 0x03, 0x03, 0x80, 0x0C,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x60,
  0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x38, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x18,
  0x00, 0xC0, 0xC0, 0x60, 0x01, 0x81, 0x80, 0xC0, 0x03, 0x03, 0x01, 0x80,
  0x03, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x06, 0x00, 0x0C, 0x18, 0x0C, 0x00,
  0x0C, 0x60, 0x30, 0x00, 0x18, 0xC0, 0x60, 0x00, 0x31, 0x80, 0xC0, 0x00,
  0x33, 0x01, 0x80, 0x00, 0x66, 0x03, 0x00, 0x00, 0xCC, 0x06, 0x00, 0x00,
  0xF0, 0x18, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x78, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x78, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xE0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x03, 0x80, 0x18, 0x30, 0x03, 0x80, 0x18, 0x30, 0x07, 0x80,
  0x30, 0x30, 0x07, 0x80, 0x30, 0x30, 0x05, 0x80, 0x30, 0x30, 0x0C, 0x80,
  0x30, 0x30, 0x0C, 0xC0, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x30, 0x18, 0xC0,
  0x60, 0x30, 0x30, 0xC0, 0x60, 0x30, 0x30, 0xC0, 0xC0, 0x20, 0x60, 0xC0,
  0xC0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0xC0, 0x41,
  0x80, 0x60, 0xC0, 0x61, 0x80, 0x61, 0x80, 0x61, 0x80, 0x61, 0x80, 0x61,
  0x80, 0x63, 0x00, 0x63, 0x00, 0x63, 0x00, 0x63, 0x00, 0x66, 0x00, 0x63,
  0x00, 0x66, 0x00, 0x66, 0x00, 0x66, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x26,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x58, 0x00, 0x3C, 0x00, 0xD8, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0E,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x43, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x10, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x30, 0x1E, 0x03, 0x8C, 0x0E, 0x00, 0x33, 0x06, 0x00,
  0x06, 0xC3, 0x00, 0x00, 0xB1, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x0F, 0x06, 0x00, 0x02,
  0xC1, 0xC0, 0x01, 0x30, 0x38, 0x01, 0xCC, 0x07, 0x81, 0xE3, 0xF0, 0xFF,
  0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x3F,
  0x00, 0x0C, 0x3F, 0xF8, 0x01, 0x8F, 0x03, 0xC0, 0x33, 0x00, 0x1C, 0x06,
  0xC0, 0x01, 0x80, 0xD0, 0x00, 0x38, 0x34, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x60, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x0E, 0x1A, 0x00, 0x03, 0x83, 0x60, 0x00, 0xE0, 0x66, 0x00, 0x38, 0x0C,
  0x70, 0x1E, 0x03, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x0C, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x03, 0x38, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x30, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFC, 0x06, 0x00, 0x7F, 0xF8,
  0x60, 0x07, 0x80, 0xE3, 0x00, 0x70, 0x01, 0x98, 0x07, 0x00, 0x06, 0xC0,
  0x60, 0x00, 0x16, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x60,
  0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xB0, 0x06, 0x00, 0x09, 0x80, 0x38,
  0x01, 0xCC, 0x00, 0xF0, 0x3C, 0x60, 0x03, 0xFF, 0x83, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x07, 0x80,
  0x70, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0E,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xE3, 0x00, 0x07,
  0xC1, 0x80, 0x7F, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x1F, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0x87, 0x00, 0xF0, 0x1C, 0x60, 0x3C, 0x00, 0x66, 0x03,
  0x00, 0x03, 0x60, 0x60, 0x00, 0x16, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0xB0, 0x30, 0x00, 0x0F,
  0x03, 0x00, 0x01, 0x60, 0x38, 0x00, 0x36, 0x01, 0xC0, 0x0E, 0x60, 0x0F,
  0x03, 0xC6, 0x00, 0x7F, 0xF8, 0x60, 0x01, 0xFC, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x07, 0xE0, 0x06, 0x1F, 0xF8, 0x0C, 0x78,
  0x1C, 0x0C, 0x60, 0x0E, 0x0C, 0x80, 0x07, 0x0D, 0x00, 0x03, 0x0D, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0xC0,
  0x30, 0x03, 0x80, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x3F, 0x80, 0x03, 0x07, 0xFF, 0x00, 0x18, 0xF0, 0x3C, 0x00, 0xCE,
  0x00, 0x70, 0x06, 0xC0, 0x01, 0x80, 0x34, 0x00, 0x0C, 0x03, 0x40, 0x00,
  0x60, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x80, 0x7C,
  0x00, 0x0C, 0x1F, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x4C, 0x03, 0x00, 0x0E, 0x60,
  0x1C, 0x00, 0xE6, 0x00, 0x60, 0x0E, 0x30, 0x03, 0x80, 0xE1, 0x80, 0x0C,
  0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x60, 0x01, 0x8E, 0x03, 0x00, 0x06, 0xE0,
  0x30, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x60, 0x07, 0x01, 0x80, 0x38, 0x06,
  0x03, 0x80, 0x18, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x0C, 0x70,
  0x00, 0x37, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x0C, 0xFF, 0x0F, 0xF0, 0x1B, 0x87, 0x38, 0x70, 0x34, 0x06, 0x40,
  0x70, 0xD0, 0x0D, 0x00, 0x61, 0xC0, 0x1A, 0x00, 0xC3, 0x80, 0x38, 0x01,
  0x86, 0x00, 0x70, 0x03, 0x0C, 0x00, 0xC0, 0x06, 0x18, 0x01, 0x80, 0x08,
  0x60, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0x01, 0x86, 0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x04, 0x30,
  0x01, 0x80, 0x18, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x61, 0x80,
  0x18, 0x00, 0xC3, 0x00, 0x30, 0x01, 0x86, 0x00, 0x60, 0x02, 0x18, 0x00,
  0xC0, 0x0C, 0x30, 0x01, 0x80, 0x18, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x0C,
  0x00, 0x61, 0x80, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x01, 0x0C, 0x00, 0x60,
  0x06, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x80, 0x18, 0x00, 0x00, 0x07,
  0xE0, 0x06, 0x1F, 0xF8, 0x0C, 0x78, 0x1C, 0x0C, 0x60, 0x0E, 0x0C, 0x80,
  0x07, 0x0D, 0x00, 0x03, 0x0D, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x03, 0x80,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0C, 0x3F, 0xF8, 0x00, 0x63, 0xC0, 0xF0, 0x03, 0x30,
  0x01, 0xC0, 0x1B, 0x00, 0x06, 0x00, 0xD0, 0x00, 0x38, 0x0D, 0x00, 0x00,
  0xC0, 0x78, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x80, 0x00,
  0xE0, 0x36, 0x00, 0x0E, 0x01, 0x98, 0x00, 0xE0, 0x0C, 0x70, 0x1E, 0x00,
  0xC1, 0xFF, 0xE0, 0x06, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x1C, 0x07, 0x80, 0xE3, 0x01, 0xC0, 0x06,
  0x60, 0x70, 0x00, 0x6C, 0x18, 0x00, 0x05, 0x87, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x16, 0x0C,
  0x00, 0x03, 0xC1, 0x80, 0x00, 0xB0, 0x18, 0x00, 0x36, 0x03, 0x80, 0x1C,
  0xC0, 0x3C, 0x0F, 0x18, 0x03, 0xFF, 0x83, 0x00, 0x1F, 0xC0, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x33, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x78, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x03,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x87, 0x80, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xB0, 0xC0, 0x01, 0xB0, 0xE0, 0x01, 0x30, 0x70,
  0x06, 0x30, 0x78, 0x1C, 0x60, 0x3F, 0xF8, 0x60, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xBF, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xE0, 0x06, 0x00, 0xE0, 0x01,
  0x80, 0xF0, 0x00, 0x61, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x60, 0xC0, 0x04, 0x01, 0x86, 0x00, 0x60, 0x0C,
  0x30, 0x03, 0x00, 0x61, 0x80, 0x18, 0x03, 0x0C, 0x00, 0xC0, 0x08, 0x60,
  0x06, 0x00, 0x66, 0x00, 0x20, 0x03, 0x30, 0x03, 0x00, 0x19, 0x80, 0x18,
  0x00, 0xCC, 0x00, 0xC0, 0x06, 0x60, 0x06, 0x00, 0x33, 0x00, 0x30, 0x01,
  0xB0, 0x01, 0x80, 0x0D, 0x80, 0x18, 0x00, 0x6C, 0x00, 0xC0, 0x03, 0x60,
  0x06, 0x00, 0x33, 0x00, 0x30, 0x01, 0x98, 0x01, 0x80, 0x0C, 0x80, 0x0C,
  0x00, 0x6C, 0x00, 0xC0, 0x03, 0x60, 0x06, 0x00, 0x33, 0x00, 0x30, 0x01,
  0x98, 0x01, 0x80, 0x1C, 0xC0, 0x1C, 0x00, 0xC6, 0x00, 0xA0, 0x0E, 0x30,
  0x09, 0x00, 0x61, 0x80, 0xCC, 0x06, 0x0E, 0x0C, 0x70, 0xE0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x3D, 0xC0, 0xE1, 0xC0, 0x70, 0x60, 0xC0, 0x60, 0xE0,
  0x38, 0xC0, 0x19, 0xC0, 0x0C, 0x40, 0x0C, 0x80, 0x06, 0x60, 0x06, 0x00,
  0x03, 0x20, 0x03, 0x00, 0x00, 0xB0, 0x01, 0x80, 0x00, 0x50, 0x00, 0xC0,
  0x00, 0x28, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x14, 0x00,
  0x03, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x0D, 0x00, 0x00, 0xC0, 0x04, 0xC0,
  0x00, 0x60, 0x06, 0x60, 0x03, 0x30, 0x02, 0x30, 0x07, 0x18, 0x03, 0x0C,
  0x0E, 0x06, 0x03, 0x06, 0x1E, 0x03, 0x87, 0x03, 0x9C, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xB0, 0x0C, 0x00, 0x0B, 0x00, 0xE0, 0x01,
  0x30, 0x07, 0x00, 0x63, 0x00, 0x78, 0x1C, 0x70, 0x03, 0xFF, 0x86, 0x00,
  0x0F, 0xE0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0,
  0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0xC1, 0xC0, 0x7E, 0x0C, 0x0C, 0x00, 0x7C, 0x60,
  0xC0, 0x00, 0x7B, 0x06, 0x00, 0x00, 0x78, 0x20, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x80, 0x1C, 0x00, 0x04, 0x01, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x60, 0xDF,
  0xE0, 0x01, 0x0C, 0x0F, 0xF8, 0x0C, 0x60, 0x07, 0xFC, 0x63, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x1F, 0xE0, 0x00, 0x20, 0xE1, 0xC0, 0x01, 0x87,
  0x03, 0x80, 0x06, 0x18, 0x06, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC3, 0x00,
  0x38, 0x06, 0x18, 0x00, 0x70, 0x30, 0x60, 0x00, 0xE1, 0xC3, 0x00, 0x01,
  0xFE, 0x0C, 0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 40, 35, 13, -40 },
  { 51, 13, 15, 35, 14, -43 },
  { 76, 35, 40, 35, 1, -40 },
  { 251, 31, 54, 35, 2, -47 },
  { 461, 39, 42, 35, -1, -41 },
  { 666, 33, 42, 35, 1, -41 },
  { 840, 4, 15, 35, 19, -43 },
  { 848, 19, 52, 35, 13, -44 },
  { 972, 19, 52, 35, 4, -44 },
  { 1096, 29, 29, 35, 4, -32 },
  { 1202, 28, 28, 35, 4, -32 },
  { 1300, 9, 15, 35, 9, -5 },
  { 1317, 16, 2, 35, 10, -19 },
  { 1321, 5, 5, 35, 13, -5 },
  { 1325, 31, 52, 35, 2, -44 },
  { 1527, 28, 42, 35, 4, -41 },
  { 1674, 27, 40, 35, 3, -40 },
  { 1809, 29, 41, 35, 2, -41 },
  { 1958, 29, 42, 35, 2, -41 },
  { 2111, 29, 40, 35, 2, -40 },
  { 2256, 29, 41, 35, 3, -40 },
  { 2405, 26, 41, 35, 4, -40 },
  { 2539, 27, 40, 35, 7, -40 },
  { 2674, 29, 42, 35, 3, -41 },
  { 2827, 26, 41, 35, 6, -41 },
  { 2961, 9, 31, 35, 13, -31 },
  { 2996, 13, 41, 35, 9, -31 },
  { 3063, 28, 32, 35, 5, -34 },
  { 3175, 30, 13, 35, 3, -24 },
  { 3224, 27, 32, 35, 3, -34 },
  { 3332, 24, 41, 35, 8, -41 },
  { 3455, 27, 47, 35, 4, -41 },
  { 3614, 30, 40, 35, 0, -40 },
  { 3764, 28, 40, 35, 3, -40 },
  { 3904, 28, 42, 35, 5, -41 },
  { 4051, 28, 40, 35, 4, -40 },
  { 4191, 30, 40, 35, 4, -40 },
  { 4341, 30, 40, 35, 4, -40 },
  { 4491, 28, 42, 35, 5, -41 },
  { 4638, 31, 40, 35, 3, -40 },
  { 4793, 31, 40, 35, 3, -40 },
  { 4948, 27, 41, 35, 4, -40 },
  { 5087, 33, 40, 35, 3, -40 },
  { 5252, 22, 40, 35, 6, -40 },
  { 5362, 32, 40, 35, 2, -40 },
  { 5522, 31, 40, 35, 3, -40 },
  { 5677, 28, 42, 35, 4, -41 },
  { 5824, 29, 40, 35, 4, -40 },
  { 5969, 28, 51, 35, 4, -41 },
  { 6148, 29, 40, 35, 4, -40 },
  { 6293, 31, 42, 35, 2, -41 },
  { 6456, 31, 40, 35, 6, -40 },
  { 6611, 29, 41, 35, 5, -40 },
  { 6760, 29, 40, 35, 7, -40 },
  { 6905, 32, 40, 35, 4, -40 },
  { 7065, 36, 40, 35, 0, -40 },
  { 7245, 32, 40, 35, 6, -40 },
  { 7405, 35, 40, 35, 0, -40 },
  { 7580, 23, 52, 35, 11, -44 },
  { 7730, 14, 52, 35, 11, -44 },
  { 7821, 23, 52, 35, 2, -44 },
  { 7971, 27, 22, 35, 5, -40 },
  { 8046, 28, 2, 35, 0, 7 },
  { 8053, 6, 10, 35, 14, -44 },
  { 8061, 26, 32, 35, 4, -31 },
  { 8165, 27, 44, 35, 4, -43 },
  { 8314, 24, 32, 35, 5, -31 },
  { 8410, 29, 44, 35, 4, -43 },
  { 8570, 25, 32, 35, 5, -31 },
  { 8670, 37, 55, 35, -1, -43 },
  { 8925, 28, 43, 35, 3, -31 },
  { 9076, 24, 43, 35, 5, -43 },
  { 9205, 25, 44, 35, 5, -43 },
  { 9343, 24, 55, 35, 6, -43 },
  { 9508, 29, 44, 35, 4, -43 },
  { 9668, 22, 44, 35, 7, -43 },
  { 9789, 31, 31, 35, 2, -31 },
  { 9910, 24, 31, 35, 5, -31 },
  { 10003, 25, 32, 35, 5, -31 },
  { 10103, 29, 43, 35, 2, -31 },
  { 10259, 27, 43, 35, 4, -31 },
  { 10405, 28, 30, 35, 7, -30 },
  { 10510, 28, 32, 35, 3, -31 },
  { 10622, 28, 41, 35, 4, -40 },
  { 10766, 24, 31, 35, 6, -30 },
  { 10859, 26, 30, 35, 5, -30 },
  { 10957, 29, 31, 35, 4, -30 },
  { 11070, 33, 32, 35, 1, -31 },
  { 11202, 28, 42, 35, 2, -30 },
  { 11349, 29, 32, 35, 3, -31 },
  { 11465, 26, 52, 35, 7, -44 },
  { 11634, 10, 52, 35, 13, -44 },
  { 11699, 26, 52, 35, 3, -44 },
  { 11868, 30, 11, 35, 3, -23 },
};

const GFXfont IBMPlexMono_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC58PT7B_H_
