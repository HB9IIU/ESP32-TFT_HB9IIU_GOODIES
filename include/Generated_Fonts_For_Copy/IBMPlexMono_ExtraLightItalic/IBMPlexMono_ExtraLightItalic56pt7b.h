#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC56PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E,
  0x07, 0x00, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x37, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x0C, 0xC0, 0xCC, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x78,
  0x23, 0xE0, 0x07, 0x81, 0x81, 0xC0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x18,
  0x07, 0x07, 0x00, 0x60, 0x08, 0x18, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x00, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x78, 0x60, 0x00, 0x00, 0xFD,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xDF,
  0x80, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x10, 0x03, 0x80, 0x00, 0x40, 0x0C, 0x10, 0x03, 0x00, 0x30, 0xC0, 0x0C,
  0x01, 0xC1, 0x80, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x07, 0x02, 0x03,
  0x80, 0x0F, 0x88, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x3C, 0x1C, 0x00,
  0x0C, 0x01, 0x80, 0x70, 0x00, 0x40, 0x18, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x60, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x01, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x08, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x0C, 0x08,
  0x00, 0x01, 0xC1, 0xC0, 0xC0, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC1,
  0xFF, 0x80, 0x00, 0x0C, 0x1E, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x20, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x18,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0xF8, 0x70, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x38, 0x02, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x5C,
  0x06, 0xC0, 0x00, 0x4C, 0x0C, 0xE0, 0x00, 0xC6, 0x0C, 0x60, 0x01, 0x87,
  0x18, 0x70, 0x03, 0x03, 0x38, 0x3C, 0x0F, 0x03, 0xB0, 0x1F, 0xFC, 0x01,
  0xE0, 0x07, 0xF0, 0x00, 0xE0, 0x33, 0x33, 0x36, 0x66, 0x66, 0x6C, 0xCC,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0xC0, 0x0F, 0xFC, 0x06, 0x07, 0xE0, 0xFC, 0x21,
  0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x38, 0x01, 0xB0, 0x07, 0x80, 0x36,
  0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x81,
  0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x1F, 0xE0, 0x00, 0x47, 0xFF, 0x80, 0x0D, 0xE0,
  0x3E, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x0C, 0x7F, 0xFC, 0x0E,
  0x70, 0x0F, 0x06, 0x60, 0x01, 0xC3, 0x40, 0x00, 0x73, 0x40, 0x00, 0x19,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x40, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x80, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1F, 0x00, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xF0, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x16, 0x70, 0x00, 0x36, 0x38, 0x00, 0x6E, 0x1E,
  0x03, 0xCC, 0x0F, 0xFF, 0x1C, 0x03, 0xFC, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x83, 0xC3, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x3E, 0x1F, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0,
  0x1E, 0x03, 0xC0, 0x70, 0x01, 0xC1, 0x80, 0x01, 0xC6, 0x00, 0x01, 0x9C,
  0x00, 0x03, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x04, 0x30, 0x00, 0x03, 0x08, 0x01, 0xF8, 0xC6, 0x01, 0xFF, 0x31, 0x80,
  0xF0, 0x6C, 0x60, 0x70, 0x0B, 0x10, 0x18, 0x01, 0xCC, 0x0C, 0x00, 0x63,
  0x03, 0x00, 0x18, 0xC0, 0xC0, 0x06, 0x30, 0x60, 0x01, 0x88, 0x18, 0x00,
  0x66, 0x06, 0x00, 0x19, 0x81, 0x80, 0x04, 0x60, 0x60, 0x03, 0x18, 0x10,
  0x00, 0xC6, 0x0C, 0x00, 0x31, 0x83, 0x00, 0x0C, 0x40, 0x40, 0x07, 0x30,
  0x10, 0x01, 0x8C, 0x06, 0x00, 0xE3, 0x01, 0x80, 0x58, 0xC0, 0x30, 0x36,
  0x30, 0x0F, 0xF9, 0x8C, 0x00, 0xF8, 0x63, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0C, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x06, 0x00, 0x03, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0C, 0x00, 0x78, 0x03, 0x80,
  0x03, 0x80, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x0C, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0x81, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xF3, 0x00, 0x1F, 0xFC,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x6C, 0x0E, 0x00, 0x33, 0x01, 0xE0, 0x38,
  0xC0, 0x3F, 0xFC, 0x30, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x07, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0E,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x0C, 0x36, 0x00, 0x00, 0x0C,
  0x63, 0x00, 0x00, 0x18, 0xC3, 0x00, 0x00, 0x19, 0x81, 0x80, 0x00, 0x1B,
  0x01, 0x80, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xB0, 0x36, 0x00, 0x03, 0x40, 0x6C, 0x00, 0x0D, 0x80,
  0x98, 0x00, 0x33, 0x03, 0x10, 0x00, 0x66, 0x06, 0x30, 0x01, 0x8C, 0x0C,
  0x60, 0x03, 0x18, 0x18, 0xC0, 0x0C, 0x20, 0x30, 0x80, 0x30, 0xC0, 0x41,
  0x80, 0x61, 0x81, 0x83, 0x01, 0x83, 0x03, 0x06, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x0C, 0x30, 0x10, 0x18, 0x18, 0x60, 0x60, 0x20, 0x11,
  0x80, 0xC0, 0xC0, 0x36, 0x01, 0x81, 0x80, 0x6C, 0x03, 0x03, 0x00, 0xF0,
  0x06, 0x06, 0x00, 0xE0, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x10, 0x02, 0x00,
  0x60, 0x60, 0x04, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x1E, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x30, 0x36,
  0x00, 0x01, 0x83, 0x30, 0x00, 0x0C, 0x19, 0x80, 0x00, 0xC0, 0xC6, 0x00,
  0x06, 0x06, 0x30, 0x00, 0x30, 0x31, 0x80, 0x01, 0x81, 0x86, 0x00, 0x0C,
  0x18, 0x30, 0x00, 0x60, 0xC1, 0x80, 0x06, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x30, 0x01, 0x81, 0x81, 0x80, 0x0C, 0x0C, 0x06, 0x00, 0x60, 0xC0, 0x30,
  0x03, 0x06, 0x01, 0x80, 0x30, 0x30, 0x06, 0x01, 0x81, 0x80, 0x30, 0x0C,
  0x0C, 0x01, 0x80, 0x60, 0x60, 0x06, 0x03, 0x06, 0x00, 0x30, 0x18, 0x30,
  0x01, 0x81, 0x81, 0x80, 0x06, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x60, 0x01,
  0x83, 0x03, 0x00, 0x06, 0x18, 0x30, 0x00, 0x30, 0xC1, 0x80, 0x01, 0x8C,
  0x0C, 0x00, 0x0E, 0x60, 0x60, 0x00, 0x33, 0x03, 0x00, 0x01, 0x98, 0x18,
  0x00, 0x0E, 0xC1, 0x80, 0x00, 0x36, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x78,
  0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x78, 0x06,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x0F,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x18, 0x01, 0x83, 0x00, 0x70, 0x02, 0x06, 0x00, 0xE0,
  0x0C, 0x0C, 0x03, 0x40, 0x18, 0x18, 0x06, 0xC0, 0x30, 0x30, 0x19, 0x80,
  0x40, 0x60, 0x33, 0x01, 0x80, 0x80, 0x46, 0x03, 0x01, 0x01, 0x8C, 0x06,
  0x06, 0x03, 0x18, 0x08, 0x0C, 0x0C, 0x30, 0x30, 0x18, 0x18, 0x20, 0x60,
  0x30, 0x60, 0x40, 0xC0, 0x60, 0xC0, 0xC3, 0x00, 0xC3, 0x01, 0x86, 0x01,
  0x86, 0x03, 0x0C, 0x03, 0x08, 0x06, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x0C,
  0x60, 0x18, 0xC0, 0x19, 0x80, 0x31, 0x80, 0x33, 0x00, 0x23, 0x00, 0x4C,
  0x00, 0x4C, 0x00, 0x98, 0x00, 0xD8, 0x03, 0x60, 0x01, 0xB0, 0x06, 0xC0,
  0x03, 0x60, 0x0D, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x41, 0xC1, 0x81,
  0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0,
  0xC0, 0xF0, 0x1C, 0x60, 0xE0, 0x03, 0x30, 0xE0, 0x00, 0xD8, 0xE0, 0x00,
  0x2C, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x38, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x78, 0xC0, 0x00, 0x28,
  0x30, 0x00, 0x2C, 0x1C, 0x00, 0x36, 0x07, 0x00, 0x33, 0x01, 0xE0, 0x71,
  0xF8, 0x7F, 0xF0, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x1F, 0xC0, 0x06, 0x1F,
  0xFC, 0x01, 0x8E, 0x07, 0x80, 0x66, 0x00, 0x70, 0x33, 0x00, 0x0C, 0x0D,
  0x80, 0x01, 0x83, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0E, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x1A, 0x00, 0x06, 0x04, 0xC0,
  0x07, 0x03, 0x1C, 0x07, 0x80, 0xC3, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0xC0,
  0xE0, 0x00, 0xC3, 0x80, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x38,
  0xC0, 0x00, 0x61, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x01, 0xE0, 0x78, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x0C,
  0x00, 0xFF, 0xE1, 0x80, 0x3C, 0x07, 0x18, 0x07, 0x00, 0x19, 0x80, 0xE0,
  0x00, 0xD8, 0x0C, 0x00, 0x05, 0x81, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x2C, 0x0E, 0x00, 0x02, 0xC0,
  0x60, 0x00, 0x58, 0x07, 0x00, 0x0D, 0x80, 0x38, 0x01, 0x98, 0x01, 0xE0,
  0x71, 0x80, 0x0F, 0xFE, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x07, 0x30, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38,
  0xC0, 0x01, 0xF0, 0xC0, 0x3F, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x30,
  0x1E, 0x03, 0x8C, 0x0E, 0x00, 0x33, 0x07, 0x00, 0x02, 0xC3, 0x80, 0x00,
  0xB0, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x58, 0x30,
  0x00, 0x3E, 0x0E, 0x00, 0x1B, 0x01, 0xC0, 0x0C, 0xC0, 0x3C, 0x0E, 0x30,
  0x07, 0xFF, 0x0C, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01,
  0xE0, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x7F, 0x00, 0xC3, 0xFF, 0x01,
  0x8E, 0x07, 0x03, 0x30, 0x07, 0x06, 0xC0, 0x07, 0x0D, 0x00, 0x06, 0x34,
  0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x1C, 0x00, 0x80, 0x38, 0x01, 0x80, 0xF0, 0x01, 0x81, 0xC0, 0x01,
  0x83, 0x80, 0x01, 0x8E, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x08, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x03, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x18, 0x00, 0x07, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x00, 0x06,
  0x1F, 0xFC, 0x00, 0x63, 0x80, 0xE0, 0x06, 0x60, 0x07, 0x00, 0xCC, 0x00,
  0x30, 0x0D, 0x80, 0x03, 0x00, 0xD0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x01, 0x80, 0x0F, 0x00,
  0x18, 0x03, 0xC0, 0x03, 0x01, 0xF0, 0x00, 0x30, 0x70, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x02, 0x30, 0x18, 0x00,
  0x36, 0x00, 0xC0, 0x06, 0x60, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x18, 0x60,
  0x06, 0x07, 0x06, 0x00, 0x30, 0xE0, 0x60, 0x03, 0x9C, 0x0C, 0x00, 0x1B,
  0x80, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x20, 0xC0, 0x07, 0x06, 0x00, 0x70, 0x30,
  0x0E, 0x01, 0x80, 0xE0, 0x18, 0x0E, 0x00, 0xC1, 0xC0, 0x06, 0x1C, 0x00,
  0x33, 0x80, 0x01, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xE0, 0x19, 0xFC, 0x1F, 0xC0, 0x4C, 0x38, 0xC3, 0x83, 0x60,
  0x66, 0x06, 0x0D, 0x00, 0xB0, 0x0C, 0x38, 0x02, 0x80, 0x30, 0xC0, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x03, 0x08, 0x00, 0xC0, 0x08, 0x60, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x01, 0x86, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x18,
  0x60, 0x06, 0x00, 0x61, 0x00, 0x10, 0x01, 0x0C, 0x00, 0xC0, 0x0C, 0x30,
  0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x0C, 0x00,
  0xC0, 0x0C, 0x20, 0x02, 0x00, 0x21, 0x80, 0x18, 0x01, 0x86, 0x00, 0x60,
  0x06, 0x18, 0x01, 0x80, 0x18, 0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01,
  0x84, 0x00, 0x40, 0x04, 0x30, 0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x18, 0x7F, 0xE0, 0x31, 0xC0,
  0xE0, 0x66, 0x00, 0xE0, 0xD8, 0x00, 0xE1, 0xA0, 0x00, 0xC6, 0x80, 0x01,
  0x8E, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x70,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x39, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xF0,
  0x1E, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x18, 0x7F, 0xF0, 0x01, 0x8E, 0x07, 0x80, 0x11, 0x80, 0x1C, 0x03, 0x30,
  0x00, 0xC0, 0x36, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x30, 0x1A, 0x00, 0x06, 0x01, 0x30, 0x01, 0xC0, 0x31, 0xC0,
  0x78, 0x03, 0x0F, 0xFF, 0x00, 0x30, 0x1F, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF0, 0xC0, 0xF0, 0x1C, 0x60, 0xE0, 0x03, 0x30, 0xE0, 0x00, 0xD8,
  0x60, 0x00, 0x2C, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x2C, 0x30, 0x00, 0x2C, 0x1C, 0x00, 0x36, 0x07, 0x00, 0x33, 0x01,
  0xE0, 0x71, 0x80, 0x7F, 0xF0, 0xC0, 0x0F, 0xE0, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0xF0,
  0x06, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x1E,
  0x00, 0x07, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xE0, 0x0C, 0x00,
  0xF0, 0x01, 0x80, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x0F, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x19, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0x60, 0x00, 0xB0, 0x60, 0x01, 0x30, 0x70, 0x03,
  0x30, 0x3C, 0x0E, 0x30, 0x1F, 0xF8, 0x60, 0x07, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0x9F, 0xE0, 0x00, 0x68, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x38, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0,
  0x18, 0x00, 0x30, 0x04, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x0C, 0x03, 0xC0, 0x03, 0x01, 0xE0, 0x00, 0xC3,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x80,
  0xC1, 0x80, 0x18, 0x06, 0x18, 0x01, 0x80, 0x61, 0x80, 0x10, 0x06, 0x18,
  0x03, 0x00, 0x61, 0x00, 0x30, 0x02, 0x30, 0x03, 0x00, 0x33, 0x00, 0x30,
  0x03, 0x30, 0x03, 0x00, 0x33, 0x00, 0x20, 0x03, 0x30, 0x06, 0x00, 0x32,
  0x00, 0x60, 0x03, 0x60, 0x06, 0x00, 0x36, 0x00, 0x60, 0x03, 0x60, 0x06,
  0x00, 0x26, 0x00, 0x40, 0x06, 0x60, 0x0C, 0x00, 0x64, 0x00, 0xC0, 0x06,
  0xC0, 0x0C, 0x00, 0x6C, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0xCC, 0x01,
  0xC0, 0x0C, 0xC0, 0x18, 0x00, 0xCC, 0x01, 0x80, 0x18, 0xC0, 0x28, 0x03,
  0x8C, 0x02, 0xC0, 0x30, 0xC0, 0x4C, 0x06, 0x0E, 0x1C, 0x61, 0xE0, 0x7F,
  0x87, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x7E,
  0x03, 0xFC, 0x01, 0xE6, 0x07, 0x0E, 0x07, 0x87, 0x0C, 0x06, 0x1E, 0x03,
  0x18, 0x07, 0x38, 0x03, 0x18, 0x03, 0x20, 0x01, 0x30, 0x03, 0x00, 0x01,
  0xA0, 0x03, 0x00, 0x01, 0xA0, 0x03, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x01,
  0xC0, 0x02, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x05, 0x80, 0x00, 0xC0, 0x05,
  0x80, 0x00, 0xC0, 0x0D, 0x80, 0x00, 0xC0, 0x09, 0x80, 0x0C, 0xC0, 0x18,
  0xC0, 0x38, 0xC0, 0x30, 0xC0, 0xF0, 0x60, 0x70, 0xC1, 0xC0, 0x70, 0xE0,
  0x67, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0xB0, 0x0C, 0x00, 0x26, 0x01, 0xC0,
  0x0C, 0xC0, 0x1E, 0x07, 0x18, 0x01, 0xFF, 0xC7, 0x00, 0x0F, 0xE0, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0x07, 0x01, 0xF0, 0x60, 0xC0, 0x03, 0xC6, 0x0C, 0x00, 0x07, 0xE0, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x70, 0x00, 0x20, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x03, 0x07, 0xE0, 0x00, 0x30,
  0xFF, 0xE0, 0x01, 0x0C, 0x1F, 0xF0, 0x18, 0xC0, 0x0F, 0xF1, 0x8C, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x3F, 0x80,
  0x01, 0x83, 0x8E, 0x00, 0x0C, 0x30, 0x38, 0x00, 0x63, 0x00, 0xE0, 0x06,
  0x18, 0x03, 0x00, 0x31, 0x80, 0x0C, 0x03, 0x0C, 0x00, 0x70, 0x30, 0x40,
  0x01, 0xC3, 0x86, 0x00, 0x07, 0xF8, 0x30, 0x00, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 39, 34, 12, -39 },
  { 50, 12, 14, 34, 14, -41 },
  { 71, 33, 39, 34, 1, -39 },
  { 232, 30, 53, 34, 2, -46 },
  { 431, 37, 41, 34, -1, -40 },
  { 621, 32, 41, 34, 1, -40 },
  { 785, 4, 14, 34, 18, -41 },
  { 792, 18, 51, 34, 13, -43 },
  { 907, 18, 51, 34, 4, -43 },
  { 1022, 29, 28, 34, 3, -31 },
  { 1124, 27, 28, 34, 4, -31 },
  { 1219, 8, 14, 34, 9, -5 },
  { 1233, 15, 2, 34, 10, -18 },
  { 1237, 5, 4, 34, 12, -4 },
  { 1240, 30, 51, 34, 2, -43 },
  { 1432, 27, 41, 34, 4, -40 },
  { 1571, 26, 39, 34, 3, -39 },
  { 1698, 28, 40, 34, 2, -40 },
  { 1838, 28, 41, 34, 2, -40 },
  { 1982, 28, 39, 34, 2, -39 },
  { 2119, 28, 40, 34, 3, -39 },
  { 2259, 25, 40, 34, 4, -39 },
  { 2384, 27, 39, 34, 6, -39 },
  { 2516, 28, 41, 34, 3, -40 },
  { 2660, 24, 40, 34, 6, -40 },
  { 2780, 9, 29, 34, 12, -29 },
  { 2813, 12, 38, 34, 9, -29 },
  { 2870, 27, 30, 34, 5, -32 },
  { 2972, 29, 12, 34, 3, -23 },
  { 3016, 26, 30, 34, 3, -32 },
  { 3114, 23, 40, 34, 8, -40 },
  { 3229, 26, 46, 34, 4, -40 },
  { 3379, 29, 39, 34, 0, -39 },
  { 3521, 27, 39, 34, 3, -39 },
  { 3653, 27, 41, 34, 5, -40 },
  { 3792, 27, 39, 34, 4, -39 },
  { 3924, 30, 39, 34, 3, -39 },
  { 4071, 30, 39, 34, 3, -39 },
  { 4218, 26, 41, 34, 5, -40 },
  { 4352, 29, 39, 34, 3, -39 },
  { 4494, 30, 39, 34, 3, -39 },
  { 4641, 26, 40, 34, 4, -39 },
  { 4771, 32, 39, 34, 3, -39 },
  { 4927, 23, 39, 34, 5, -39 },
  { 5040, 31, 39, 34, 2, -39 },
  { 5192, 29, 39, 34, 3, -39 },
  { 5334, 27, 41, 34, 4, -40 },
  { 5473, 29, 39, 34, 3, -39 },
  { 5615, 27, 50, 34, 4, -40 },
  { 5784, 29, 39, 34, 3, -39 },
  { 5926, 30, 41, 34, 2, -40 },
  { 6080, 30, 39, 34, 6, -39 },
  { 6227, 27, 40, 34, 5, -39 },
  { 6362, 28, 39, 34, 7, -39 },
  { 6499, 31, 39, 34, 4, -39 },
  { 6651, 35, 39, 34, 0, -39 },
  { 6822, 31, 39, 34, 5, -39 },
  { 6974, 34, 39, 34, 0, -39 },
  { 7140, 22, 51, 34, 11, -43 },
  { 7281, 13, 51, 34, 11, -43 },
  { 7364, 23, 51, 34, 1, -43 },
  { 7511, 27, 22, 34, 4, -39 },
  { 7586, 27, 2, 34, 0, 6 },
  { 7593, 7, 10, 34, 13, -43 },
  { 7602, 25, 31, 34, 4, -30 },
  { 7699, 26, 42, 34, 4, -41 },
  { 7836, 23, 31, 34, 5, -30 },
  { 7926, 28, 42, 34, 4, -41 },
  { 8073, 24, 31, 34, 5, -30 },
  { 8166, 36, 53, 34, -1, -41 },
  { 8405, 26, 42, 34, 3, -30 },
  { 8542, 23, 41, 34, 5, -41 },
  { 8660, 24, 43, 34, 5, -42 },
  { 8789, 23, 54, 34, 6, -42 },
  { 8945, 28, 42, 34, 4, -41 },
  { 9092, 21, 42, 34, 7, -41 },
  { 9203, 30, 30, 34, 2, -30 },
  { 9316, 23, 30, 34, 5, -30 },
  { 9403, 25, 31, 34, 4, -30 },
  { 9500, 28, 41, 34, 2, -30 },
  { 9644, 25, 41, 34, 4, -30 },
  { 9773, 26, 29, 34, 7, -29 },
  { 9868, 27, 31, 34, 3, -30 },
  { 9973, 27, 40, 34, 4, -39 },
  { 10108, 24, 30, 34, 5, -29 },
  { 10198, 26, 29, 34, 4, -29 },
  { 10293, 28, 30, 34, 4, -29 },
  { 10398, 32, 31, 34, 1, -30 },
  { 10522, 27, 41, 34, 2, -29 },
  { 10661, 28, 31, 34, 3, -30 },
  { 10770, 25, 51, 34, 7, -43 },
  { 10930, 10, 51, 34, 12, -43 },
  { 10994, 25, 51, 34, 3, -43 },
  { 11154, 29, 11, 34, 3, -22 },
};

const GFXfont IBMPlexMono_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC56PT7B_H_
