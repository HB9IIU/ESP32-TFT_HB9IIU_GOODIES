#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC9PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0x20, 0xF0, 0x29, 0xB5, 0x14, 0xDA, 0x80, 0x11, 0xBA, 0xC1,
  0xD5, 0xC8, 0x6E, 0xA7, 0x16, 0xAA, 0x60, 0x32, 0x95, 0x49, 0xF4, 0xC0,
  0x72, 0x49, 0x26, 0x49, 0x14, 0xA4, 0x44, 0xFA, 0x44, 0xF4, 0x40, 0x60,
  0xC0, 0x80, 0x08, 0x84, 0x42, 0x22, 0x10, 0x79, 0x9D, 0xAE, 0x11, 0x18,
  0x42, 0x7C, 0x32, 0x42, 0x26, 0x78, 0x3A, 0x4C, 0x29, 0x38, 0x09, 0x95,
  0x2F, 0x88, 0x3A, 0x2D, 0x99, 0x38, 0x2C, 0xE9, 0x9E, 0xF9, 0x24, 0x48,
  0x3A, 0x4D, 0x98, 0xB8, 0x79, 0x9E, 0x2C, 0x88, 0x40, 0x60, 0x16, 0x84,
  0x20, 0x78, 0x3E, 0x41, 0x06, 0x6C, 0x00, 0x79, 0x24, 0x04, 0x79, 0xF9,
  0xE8, 0xE0, 0x11, 0x94, 0xA7, 0x44, 0x7A, 0x5D, 0x18, 0xF8, 0x69, 0x88,
  0xBC, 0x69, 0x99, 0x9E, 0x78, 0xF8, 0x8E, 0x78, 0xF8, 0x88, 0x69, 0x8B,
  0xAE, 0x4C, 0x5F, 0x19, 0x48, 0x79, 0x08, 0x42, 0x78, 0x71, 0x22, 0xAE,
  0x9D, 0x31, 0x8A, 0x58, 0x92, 0x49, 0xC0, 0x4E, 0xEB, 0x58, 0xC8, 0x4A,
  0x6B, 0x59, 0x48, 0x79, 0x99, 0xAE, 0x79, 0x9F, 0x88, 0x79, 0x99, 0xAE,
  0x52, 0x79, 0x9F, 0xCA, 0x36, 0x58, 0x38, 0xB8, 0xFA, 0x10, 0x84, 0x20,
  0x99, 0x99, 0xAE, 0x9C, 0xA9, 0x4C, 0x20, 0x9C, 0xB5, 0xAA, 0x50, 0x4D,
  0x42, 0x08, 0x52, 0x60, 0x9C, 0x98, 0x84, 0x20, 0x78, 0x44, 0xC8, 0x7C,
  0x72, 0x49, 0x26, 0xAA, 0xA5, 0x31, 0x22, 0x22, 0x2E, 0x2E, 0x90, 0xF0,
  0xC0, 0x7A, 0xAA, 0xD0, 0x88, 0xE9, 0x99, 0xE0, 0x6A, 0x9A, 0xC0, 0x11,
  0x79, 0xAA, 0xE0, 0x69, 0xEA, 0xE0, 0x1C, 0x87, 0x88, 0x20, 0x8A, 0x30,
  0x40, 0x3E, 0x65, 0x27, 0x49, 0x80, 0x88, 0xE9, 0xAA, 0xA0, 0x60, 0xC4,
  0x8B, 0x40, 0x10, 0xE2, 0x22, 0xAC, 0x40, 0x88, 0xE9, 0xED, 0xA0, 0xC4,
  0x44, 0x8B, 0x40, 0xBF, 0x6B, 0x5A, 0x80, 0xE9, 0xAA, 0xA0, 0x69, 0x9A,
  0xE0, 0x72, 0x63, 0x1F, 0x42, 0x00, 0x79, 0xAA, 0xE2, 0x20, 0xF4, 0x48,
  0x80, 0x69, 0xE2, 0xE0, 0x4F, 0x48, 0xB4, 0x9A, 0xAA, 0xE0, 0x99, 0x9A,
  0xC0, 0xDD, 0xDD, 0xA0, 0x3F, 0x49, 0xDD, 0x00, 0x4C, 0xA5, 0x27, 0x49,
  0x80, 0x7C, 0x4D, 0xAF, 0x00, 0x34, 0x4A, 0x44, 0x86, 0x6A, 0xAA, 0x32,
  0x21, 0x64, 0x2E, 0x6C, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 2, 2, 5, 2, -7 },
  { 4, 6, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 6, 6, 5, 0, -6 },
  { 19, 5, 6, 5, 0, -6 },
  { 23, 1, 2, 5, 3, -7 },
  { 24, 3, 8, 5, 2, -7 },
  { 27, 3, 8, 5, 1, -7 },
  { 30, 4, 4, 5, 1, -5 },
  { 32, 4, 5, 5, 1, -5 },
  { 35, 2, 2, 5, 1, -1 },
  { 36, 2, 1, 5, 2, -3 },
  { 37, 1, 1, 5, 2, -1 },
  { 38, 5, 8, 5, 0, -7 },
  { 43, 4, 6, 5, 1, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 4, 6, 5, 1, -6 },
  { 69, 4, 6, 5, 1, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 4, 6, 5, 1, -6 },
  { 79, 1, 5, 5, 2, -5 },
  { 80, 2, 6, 5, 1, -5 },
  { 82, 4, 5, 5, 1, -5 },
  { 85, 5, 3, 5, 0, -4 },
  { 87, 5, 5, 5, 0, -5 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 4, 7, 5, 1, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 5, 6, 5, 1, -6 },
  { 136, 3, 6, 5, 1, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 4, 8, 5, 1, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 5, 6, 5, 1, -6 },
  { 168, 4, 6, 5, 1, -6 },
  { 171, 5, 6, 5, 1, -6 },
  { 175, 5, 6, 5, 1, -6 },
  { 179, 6, 6, 5, 0, -6 },
  { 184, 5, 6, 5, 1, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 3, 8, 5, 2, -7 },
  { 195, 2, 8, 5, 2, -7 },
  { 197, 4, 8, 5, 0, -7 },
  { 201, 4, 3, 5, 1, -6 },
  { 203, 4, 1, 5, 0, 1 },
  { 204, 1, 2, 5, 2, -8 },
  { 205, 4, 5, 5, 1, -5 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 4, 5, 5, 1, -5 },
  { 215, 4, 7, 5, 1, -7 },
  { 219, 4, 5, 5, 1, -5 },
  { 222, 6, 9, 5, 0, -7 },
  { 229, 5, 7, 5, 0, -5 },
  { 234, 4, 7, 5, 1, -7 },
  { 238, 4, 7, 5, 1, -7 },
  { 242, 4, 9, 5, 1, -7 },
  { 247, 4, 7, 5, 1, -7 },
  { 251, 4, 7, 5, 1, -7 },
  { 255, 5, 5, 5, 0, -5 },
  { 259, 4, 5, 5, 1, -5 },
  { 262, 4, 5, 5, 1, -5 },
  { 265, 5, 7, 5, 0, -5 },
  { 270, 4, 7, 5, 1, -5 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 4, 5, 5, 1, -5 },
  { 280, 4, 6, 5, 1, -6 },
  { 283, 4, 5, 5, 1, -5 },
  { 286, 4, 5, 5, 1, -5 },
  { 289, 4, 5, 5, 1, -5 },
  { 292, 5, 5, 5, 0, -5 },
  { 296, 5, 7, 5, 0, -5 },
  { 301, 5, 5, 5, 0, -5 },
  { 305, 4, 8, 5, 1, -7 },
  { 309, 2, 8, 5, 2, -7 },
  { 311, 4, 8, 5, 0, -7 },
  { 315, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC9PT7B_H_
