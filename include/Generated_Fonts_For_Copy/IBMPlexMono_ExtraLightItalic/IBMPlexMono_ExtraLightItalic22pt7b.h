#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC22PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x44, 0x00, 0x0C, 0xC0, 0x4A, 0x52, 0x98,
  0xC8, 0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x44, 0x1E, 0x3C, 0x11,
  0x01, 0x10, 0x08, 0x87, 0xC7, 0x84, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00,
  0x88, 0x00, 0x01, 0x00, 0x10, 0x0F, 0x81, 0x26, 0x22, 0x14, 0x20, 0x42,
  0x02, 0x40, 0x3C, 0x00, 0xF0, 0x04, 0xC0, 0x44, 0x04, 0x40, 0x84, 0x88,
  0x44, 0x88, 0x3F, 0x00, 0x80, 0x08, 0x00, 0x1E, 0x04, 0xC4, 0x22, 0x11,
  0x10, 0x44, 0x41, 0x20, 0x89, 0x01, 0xC8, 0x00, 0x00, 0x08, 0xE0, 0x44,
  0x41, 0x21, 0x08, 0x84, 0x42, 0x12, 0x08, 0x88, 0x1C, 0x00, 0x07, 0x80,
  0x42, 0x04, 0x10, 0x20, 0x81, 0x04, 0x04, 0x20, 0x22, 0x06, 0xE0, 0x44,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x18, 0x29, 0x21, 0x28, 0xF1, 0x80, 0x5A,
  0xA0, 0x02, 0x18, 0x40, 0x82, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x81, 0x80, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x20, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0xE4, 0x71, 0xF8,
  0x06, 0x00, 0xA0, 0x11, 0x02, 0x10, 0x40, 0x80, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0xFF, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x00,
  0x32, 0x24, 0x48, 0xFC, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x0C, 0x22, 0x05, 0x01, 0x80, 0x60, 0x18, 0xC6, 0x31, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x81, 0x30, 0x83, 0xC0, 0x03, 0x01, 0xC0, 0x90, 0xC4, 0x22,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F,
  0xFC, 0x07, 0x83, 0x08, 0x80, 0x90, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x0F, 0x82,
  0x08, 0x80, 0x80, 0x10, 0x04, 0x01, 0x83, 0xC0, 0x0C, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x28, 0x08, 0x82, 0x0F, 0x80, 0x00, 0x40, 0x18, 0x05, 0x01,
  0x20, 0x44, 0x11, 0x04, 0x20, 0x84, 0x20, 0x88, 0x12, 0x04, 0x7F, 0xF0,
  0x10, 0x02, 0x00, 0x40, 0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x0B, 0xC2, 0x86, 0x20, 0x40, 0x08, 0x01, 0x00, 0x28, 0x08, 0x83, 0x0F,
  0x80, 0x01, 0x83, 0x02, 0x02, 0x02, 0x02, 0x01, 0x7D, 0x43, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0E, 0x18, 0xF0, 0xFF, 0xE0, 0x28, 0x0A, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08,
  0x00, 0x07, 0xC3, 0x0C, 0x80, 0x90, 0x12, 0x02, 0x40, 0x44, 0x10, 0x7C,
  0x30, 0xC8, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x81, 0x0F, 0xC0, 0x1F, 0x08,
  0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x1D, 0x06, 0x3E, 0x80, 0x40, 0x30,
  0x08, 0x0C, 0x06, 0x06, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x08, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x42, 0x21, 0x10, 0x00, 0x40, 0x20, 0x30,
  0x30, 0x30, 0x30, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x1E,
  0x10, 0xD0, 0x30, 0x10, 0x08, 0x04, 0x04, 0x1C, 0x10, 0x08, 0x08, 0x00,
  0x00, 0x01, 0x01, 0x80, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x47, 0x62, 0x39,
  0x06, 0x42, 0x90, 0xA4, 0x29, 0x0A, 0x46, 0x8E, 0xA0, 0x08, 0x03, 0x00,
  0x3E, 0x00, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x82, 0x10,
  0x42, 0x10, 0x43, 0xF8, 0x81, 0x10, 0x14, 0x02, 0x80, 0x60, 0x08, 0x1F,
  0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x90, 0x11, 0xFC, 0x40, 0xC8,
  0x09, 0x01, 0x20, 0x28, 0x05, 0x01, 0x3F, 0xC0, 0x0F, 0x04, 0x22, 0x05,
  0x01, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02, 0x81,
  0x10, 0x83, 0xC0, 0x1F, 0x82, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x24, 0x09, 0x03, 0x3F, 0x80,
  0x1F, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xC0, 0x1F,
  0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x20, 0x08, 0x02, 0x00, 0x87, 0xE0, 0x28, 0x0A,
  0x02, 0x80, 0x90, 0xE3, 0xD0, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20,
  0x22, 0x02, 0x40, 0x27, 0xFC, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x80,
  0x48, 0x08, 0x80, 0x80, 0x1F, 0xF2, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x82, 0x21, 0x87, 0xC0, 0x10, 0x19,
  0x01, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x90, 0x09, 0x80, 0x52,
  0x03, 0x10, 0x10, 0x40, 0x82, 0x04, 0x08, 0x40, 0x42, 0x01, 0x00, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x03, 0xFE, 0x30, 0x13, 0x03, 0x30, 0x53, 0x0A, 0x48, 0xA4,
  0x92, 0x49, 0x24, 0x62, 0x44, 0x24, 0x44, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x40, 0x10, 0x13, 0x02, 0x28, 0x22, 0x82, 0x28, 0x24, 0x42,
  0x44, 0x24, 0x44, 0x42, 0x44, 0x24, 0x42, 0x48, 0x14, 0x81, 0x48, 0x18,
  0x80, 0x80, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x30, 0x83, 0xC0, 0x1F, 0xC2, 0x02,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x06, 0x7F, 0x84, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x0C, 0x22, 0x05,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81,
  0x30, 0x83, 0xC0, 0x20, 0x08, 0x81, 0x40, 0x20, 0x1F, 0xC2, 0x02, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x06, 0x7F, 0x84, 0x20, 0x42,
  0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0xC0, 0x0F, 0x81, 0x06, 0x20, 0x24,
  0x01, 0x40, 0x02, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x40, 0x28, 0x09, 0x01, 0x20, 0x24, 0x05,
  0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x86,
  0x1F, 0x00, 0x80, 0x70, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x10, 0x82,
  0x10, 0x44, 0x08, 0x81, 0x20, 0x24, 0x05, 0x00, 0x60, 0x08, 0x00, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x02, 0x84, 0x48, 0xC4, 0x8C, 0x49, 0x44, 0x94,
  0x8A, 0x28, 0xA2, 0x8C, 0x28, 0xC3, 0x0C, 0x30, 0x83, 0x00, 0x10, 0x0C,
  0x40, 0x40, 0x81, 0x02, 0x08, 0x04, 0x40, 0x12, 0x00, 0x30, 0x00, 0xC0,
  0x05, 0x00, 0x12, 0x00, 0x88, 0x04, 0x10, 0x20, 0x41, 0x00, 0x88, 0x02,
  0x00, 0x80, 0x14, 0x02, 0x40, 0x42, 0x08, 0x20, 0x81, 0x10, 0x12, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x1F, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0xFF,
  0x80, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x1F, 0x80,
  0x84, 0x20, 0x84, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08, 0x42, 0x08, 0x42,
  0x10, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0xF8, 0x06, 0x01, 0x80,
  0x90, 0x44, 0x20, 0x88, 0x24, 0x0A, 0x01, 0xFF, 0xE0, 0x89, 0x10, 0x0F,
  0x66, 0x18, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x40, 0x88,
  0x70, 0xF3, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x13, 0xC5, 0x09,
  0x81, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x2C, 0x32, 0xF8, 0x1E,
  0x10, 0x90, 0x30, 0x08, 0x04, 0x02, 0x01, 0x01, 0x81, 0x21, 0x0F, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1E, 0x8C, 0x31, 0x02, 0x40,
  0x48, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x81, 0x10, 0xE1, 0xE4, 0x1F, 0x10,
  0x50, 0x30, 0x18, 0x37, 0xE2, 0x01, 0x02, 0x81, 0xA1, 0x8F, 0x00, 0x00,
  0xFC, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x7F, 0xE0, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x21, 0x00, 0xC4, 0x01, 0x90, 0x03, 0x40, 0x02, 0x00, 0x0F, 0x66,
  0x18, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x40, 0x88, 0x70,
  0xF2, 0x00, 0x80, 0x11, 0x04, 0x1F, 0x00, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x79, 0x42, 0xC1, 0x40, 0xA0, 0x50, 0x30, 0x18, 0x14, 0x0A, 0x05,
  0x02, 0x06, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x11, 0x18, 0x90, 0xB0, 0x60, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x03, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x09,
  0x08, 0xC4, 0x12, 0x05, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x9E, 0x14, 0x23, 0x04, 0x40, 0x88, 0x22, 0x18, 0x4C, 0x08, 0x85,
  0x11, 0xE1, 0x64, 0x10, 0xF8, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x21, 0x42, 0x4C, 0x58, 0x60, 0x5C, 0xEC, 0x65, 0x08,
  0xA1, 0x14, 0x42, 0x88, 0x61, 0x0C, 0x21, 0x84, 0x51, 0x0A, 0x21, 0x00,
  0x4F, 0x28, 0x58, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0,
  0x40, 0x1F, 0x10, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x61,
  0x8F, 0x00, 0x27, 0x85, 0x08, 0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x12,
  0x02, 0x40, 0x4C, 0x32, 0x7C, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F,
  0x66, 0x18, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x40, 0x88,
  0x70, 0xF2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0xF3, 0xC7, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x0F, 0x86,
  0x08, 0x80, 0x90, 0x03, 0x00, 0x1F, 0x00, 0x10, 0x02, 0x80, 0x48, 0x10,
  0xFC, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC4, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x86, 0x23, 0x0B, 0x03, 0x00, 0x40, 0xA0, 0x50,
  0x28, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x83, 0x62, 0x9E, 0x40, 0xE0, 0x88,
  0x12, 0x04, 0x81, 0x20, 0x50, 0x24, 0x09, 0x04, 0x42, 0x13, 0x07, 0x80,
  0x22, 0x28, 0x45, 0x08, 0xA1, 0x14, 0x42, 0x88, 0x61, 0x0C, 0x21, 0x84,
  0x31, 0x89, 0xCE, 0x00, 0x0C, 0x70, 0x94, 0x58, 0xC2, 0x06, 0x10, 0x20,
  0x01, 0x00, 0x08, 0x10, 0x40, 0x86, 0x12, 0x4B, 0x1C, 0x60, 0x20, 0x48,
  0x12, 0x04, 0x81, 0x40, 0x50, 0x24, 0x09, 0x02, 0x41, 0x98, 0xA3, 0xC8,
  0x04, 0x01, 0x20, 0x87, 0xC0, 0x1F, 0x24, 0x3D, 0x01, 0x20, 0x40, 0x30,
  0x08, 0x02, 0x01, 0x84, 0x40, 0x5F, 0x8A, 0x1F, 0x00, 0x0F, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x08, 0x3C, 0x01, 0x80, 0x20,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0xF0, 0x11, 0x22,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x88, 0x1F, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x04, 0x00, 0xF0, 0xC0, 0x20, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x02, 0x00, 0x83, 0xE0, 0x38, 0x28, 0x86,
  0x09, 0x40, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 5, -15 },
  { 9, 5, 6, 13, 5, -16 },
  { 13, 13, 15, 13, 0, -15 },
  { 38, 12, 19, 13, 1, -17 },
  { 67, 14, 15, 13, 0, -15 },
  { 94, 13, 15, 13, 0, -15 },
  { 119, 2, 6, 13, 7, -16 },
  { 121, 7, 20, 13, 5, -17 },
  { 139, 8, 20, 13, 1, -17 },
  { 159, 12, 11, 13, 1, -12 },
  { 176, 11, 11, 13, 1, -12 },
  { 192, 4, 6, 13, 3, -2 },
  { 195, 6, 1, 13, 4, -7 },
  { 196, 2, 2, 13, 5, -2 },
  { 197, 12, 20, 13, 1, -17 },
  { 227, 10, 15, 13, 2, -15 },
  { 246, 10, 15, 13, 1, -15 },
  { 265, 11, 15, 13, 1, -15 },
  { 286, 11, 15, 13, 1, -15 },
  { 307, 11, 15, 13, 1, -15 },
  { 328, 11, 15, 13, 1, -15 },
  { 349, 9, 15, 13, 2, -15 },
  { 366, 10, 15, 13, 3, -15 },
  { 385, 11, 15, 13, 1, -15 },
  { 406, 10, 15, 13, 2, -15 },
  { 425, 3, 12, 13, 5, -12 },
  { 430, 5, 16, 13, 3, -12 },
  { 440, 10, 12, 13, 2, -13 },
  { 455, 11, 5, 13, 1, -9 },
  { 462, 11, 12, 13, 1, -13 },
  { 479, 9, 15, 13, 3, -15 },
  { 496, 10, 17, 13, 2, -15 },
  { 518, 11, 15, 13, 0, -15 },
  { 539, 11, 15, 13, 1, -15 },
  { 560, 10, 15, 13, 2, -15 },
  { 579, 11, 15, 13, 1, -15 },
  { 600, 12, 15, 13, 1, -15 },
  { 623, 12, 15, 13, 1, -15 },
  { 646, 10, 15, 13, 2, -15 },
  { 665, 12, 15, 13, 1, -15 },
  { 688, 12, 15, 13, 1, -15 },
  { 711, 10, 15, 13, 2, -15 },
  { 730, 13, 15, 13, 1, -15 },
  { 755, 9, 15, 13, 2, -15 },
  { 772, 12, 15, 13, 1, -15 },
  { 795, 12, 15, 13, 1, -15 },
  { 818, 10, 15, 13, 2, -15 },
  { 837, 12, 15, 13, 1, -15 },
  { 860, 10, 19, 13, 2, -15 },
  { 884, 12, 15, 13, 1, -15 },
  { 907, 12, 15, 13, 1, -15 },
  { 930, 12, 15, 13, 2, -15 },
  { 953, 11, 15, 13, 2, -15 },
  { 974, 11, 15, 13, 3, -15 },
  { 995, 12, 15, 13, 2, -15 },
  { 1018, 14, 15, 13, 0, -15 },
  { 1045, 12, 15, 13, 2, -15 },
  { 1068, 13, 15, 13, 0, -15 },
  { 1093, 9, 20, 13, 4, -17 },
  { 1116, 5, 20, 13, 4, -17 },
  { 1129, 8, 20, 13, 1, -17 },
  { 1149, 10, 8, 13, 2, -15 },
  { 1159, 11, 1, 13, 0, 2 },
  { 1161, 3, 4, 13, 5, -17 },
  { 1163, 11, 11, 13, 1, -11 },
  { 1179, 10, 16, 13, 2, -16 },
  { 1199, 9, 11, 13, 2, -11 },
  { 1212, 11, 16, 13, 1, -16 },
  { 1234, 9, 11, 13, 2, -11 },
  { 1247, 14, 20, 13, 0, -16 },
  { 1282, 11, 15, 13, 1, -11 },
  { 1303, 9, 16, 13, 2, -16 },
  { 1321, 9, 16, 13, 2, -16 },
  { 1339, 9, 20, 13, 2, -16 },
  { 1362, 11, 16, 13, 2, -16 },
  { 1384, 8, 16, 13, 3, -16 },
  { 1400, 11, 11, 13, 1, -11 },
  { 1416, 9, 11, 13, 2, -11 },
  { 1429, 9, 11, 13, 2, -11 },
  { 1442, 11, 15, 13, 1, -11 },
  { 1463, 11, 15, 13, 1, -11 },
  { 1484, 10, 11, 13, 3, -11 },
  { 1498, 11, 11, 13, 1, -11 },
  { 1514, 10, 15, 13, 2, -15 },
  { 1533, 9, 11, 13, 2, -11 },
  { 1546, 10, 11, 13, 2, -11 },
  { 1560, 11, 11, 13, 1, -11 },
  { 1576, 13, 11, 13, 0, -11 },
  { 1594, 10, 15, 13, 1, -11 },
  { 1613, 11, 11, 13, 1, -11 },
  { 1629, 10, 20, 13, 3, -17 },
  { 1654, 4, 20, 13, 5, -17 },
  { 1664, 10, 20, 13, 1, -17 },
  { 1689, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC22PT7B_H_
