#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC13PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0x80, 0xB6, 0x80, 0x0A, 0x14, 0x73, 0x14, 0x28, 0x28,
  0xCE, 0x48, 0x50, 0x08, 0x38, 0xAA, 0x43, 0x03, 0x84, 0x89, 0xD4, 0x78,
  0x80, 0x31, 0x4A, 0x8A, 0x74, 0x00, 0x2E, 0x52, 0x92, 0x8C, 0x1C, 0x24,
  0x44, 0x24, 0x78, 0x90, 0x8A, 0x97, 0x76, 0xE0, 0x12, 0x48, 0x88, 0x88,
  0x88, 0x84, 0x22, 0x11, 0x11, 0x11, 0x22, 0x48, 0x10, 0x4A, 0x5E, 0x52,
  0x60, 0x10, 0x42, 0x3F, 0x20, 0x82, 0x00, 0x68, 0xF0, 0x80, 0x02, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x39, 0x18, 0x61,
  0x96, 0x18, 0x62, 0x70, 0x10, 0xC5, 0x24, 0x10, 0x82, 0x08, 0xFC, 0x39,
  0x18, 0x41, 0x08, 0x42, 0x30, 0xF8, 0x39, 0x10, 0x42, 0x30, 0x20, 0xA2,
  0x70, 0x02, 0x18, 0x51, 0x24, 0x50, 0xBF, 0x84, 0x08, 0x3D, 0x04, 0x2E,
  0xC8, 0x10, 0xA2, 0x70, 0x08, 0xC4, 0x10, 0xBB, 0x18, 0x62, 0x70, 0x7F,
  0x0A, 0x20, 0x41, 0x04, 0x08, 0x20, 0x40, 0x3D, 0x18, 0x51, 0x3B, 0x38,
  0x61, 0xF8, 0x39, 0x18, 0x61, 0x7C, 0x21, 0x04, 0x60, 0x40, 0x08, 0x20,
  0x00, 0x14, 0x80, 0x04, 0x62, 0x30, 0x40, 0xC0, 0x80, 0xFC, 0x00, 0x3F,
  0x40, 0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x62, 0x11, 0x31, 0x00, 0x40,
  0x39, 0x18, 0x67, 0xA7, 0x1C, 0xAE, 0x81, 0xC0, 0x08, 0x30, 0x51, 0x22,
  0x48, 0x9F, 0x22, 0x82, 0x79, 0x18, 0x61, 0xFA, 0x18, 0x62, 0xF8, 0x39,
  0x18, 0x60, 0x82, 0x08, 0x62, 0x70, 0x79, 0x18, 0x61, 0x86, 0x18, 0x62,
  0xF0, 0x7E, 0x82, 0x04, 0x07, 0xD0, 0x20, 0x40, 0xF8, 0x7E, 0x82, 0x04,
  0x07, 0xD0, 0x20, 0x40, 0x80, 0x39, 0x18, 0x60, 0x9E, 0x18, 0xA2, 0x78,
  0x47, 0x0A, 0x14, 0x2F, 0xD0, 0xA2, 0x44, 0x88, 0x7E, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0xF8, 0x3C, 0x10, 0x42, 0x08, 0x20, 0xA2, 0x70, 0x42,
  0x8A, 0x65, 0x0E, 0x12, 0x24, 0x44, 0x8C, 0x42, 0x10, 0x88, 0x42, 0x10,
  0xF8, 0x21, 0x62, 0x66, 0x56, 0x5A, 0x52, 0x82, 0x84, 0x84, 0x47, 0x8A,
  0x95, 0x2A, 0x52, 0xA6, 0x4C, 0x88, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62,
  0x70, 0x7D, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x80, 0x39, 0x18, 0x61, 0x86,
  0x18, 0x62, 0x70, 0x81, 0x46, 0x7D, 0x18, 0x61, 0x87, 0xE9, 0x24, 0x88,
  0x1C, 0x45, 0x01, 0x01, 0xC0, 0x40, 0xE2, 0x38, 0xFE, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x47, 0x0A, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x70,
  0x86, 0x28, 0xA4, 0x92, 0x8A, 0x30, 0x40, 0x83, 0x06, 0x14, 0xAB, 0x5A,
  0xB6, 0x4C, 0x88, 0x41, 0x22, 0x24, 0x18, 0x10, 0x18, 0x28, 0x44, 0x86,
  0x83, 0x09, 0x12, 0x43, 0x04, 0x08, 0x10, 0x20, 0x3F, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0xFE, 0x3C, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x3C, 0x92, 0x49, 0x22, 0x49, 0x30, 0x3C, 0x20, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x3C, 0x10, 0xA4, 0xA1, 0x84, 0xFC, 0xB0, 0x76, 0x38,
  0xA2, 0x8A, 0x27, 0xC0, 0x41, 0x04, 0x1E, 0xC6, 0x18, 0x61, 0x8B, 0xC0,
  0x39, 0x28, 0x60, 0x8A, 0x27, 0x00, 0x04, 0x10, 0x5D, 0x8E, 0x28, 0xA2,
  0x89, 0xE0, 0x39, 0x18, 0xBC, 0x82, 0x27, 0x00, 0x07, 0x08, 0x08, 0x3F,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x90, 0x60, 0x20, 0x75, 0x38, 0xA2,
  0x8A, 0x27, 0x82, 0x93, 0x80, 0x41, 0x04, 0x16, 0x65, 0x28, 0xA2, 0x8A,
  0x20, 0x10, 0x00, 0x38, 0x20, 0x82, 0x13, 0x58, 0x80, 0x04, 0x00, 0x1E,
  0x08, 0x20, 0x84, 0x10, 0x49, 0x1C, 0x30, 0x41, 0x04, 0x1E, 0xC6, 0x2B,
  0x29, 0x96, 0x60, 0xE2, 0x10, 0x84, 0x22, 0x13, 0xA6, 0x00, 0x56, 0xD5,
  0x2A, 0x99, 0x32, 0x64, 0x80, 0x5B, 0x94, 0xA2, 0x8A, 0x28, 0x80, 0x39,
  0x18, 0x61, 0x86, 0x27, 0x00, 0xFB, 0x18, 0x61, 0x86, 0x2F, 0x20, 0x82,
  0x00, 0x76, 0x38, 0xA2, 0x8A, 0x27, 0x82, 0x08, 0x40, 0xDC, 0x84, 0x10,
  0x42, 0x08, 0x00, 0x7A, 0x18, 0x1E, 0x0A, 0x27, 0x80, 0x20, 0x8F, 0xC8,
  0x21, 0x04, 0x56, 0x60, 0x86, 0x18, 0xA2, 0x8A, 0x27, 0x80, 0xC5, 0x14,
  0x51, 0x8A, 0x66, 0x00, 0x96, 0x5A, 0x69, 0xA6, 0x9D, 0x80, 0x16, 0x79,
  0x09, 0x10, 0x90, 0xB2, 0x6C, 0x62, 0x85, 0x12, 0x24, 0x48, 0x8F, 0x02,
  0x88, 0xE0, 0x7E, 0x10, 0x8C, 0x4B, 0x2B, 0x80, 0x39, 0x10, 0x42, 0x61,
  0x88, 0x44, 0x20, 0xE0, 0x55, 0xAA, 0xAA, 0x32, 0x84, 0x42, 0x0C, 0x88,
  0x21, 0x09, 0xC0, 0x66, 0x99, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 3, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 11, 8, 0, -10 },
  { 25, 8, 9, 8, 0, -9 },
  { 34, 8, 9, 8, 0, -9 },
  { 43, 1, 3, 8, 4, -10 },
  { 44, 4, 12, 8, 3, -10 },
  { 50, 4, 12, 8, 1, -10 },
  { 56, 6, 6, 8, 1, -7 },
  { 61, 6, 7, 8, 1, -7 },
  { 67, 2, 3, 8, 2, -1 },
  { 68, 4, 1, 8, 2, -4 },
  { 69, 1, 1, 8, 3, -1 },
  { 70, 7, 12, 8, 0, -10 },
  { 81, 6, 9, 8, 1, -9 },
  { 88, 6, 9, 8, 1, -9 },
  { 95, 6, 9, 8, 1, -9 },
  { 102, 6, 9, 8, 1, -9 },
  { 109, 7, 9, 8, 0, -9 },
  { 117, 6, 9, 8, 1, -9 },
  { 124, 6, 9, 8, 1, -9 },
  { 131, 7, 9, 8, 1, -9 },
  { 139, 6, 9, 8, 1, -9 },
  { 146, 6, 9, 8, 1, -9 },
  { 153, 2, 7, 8, 3, -7 },
  { 155, 3, 9, 8, 2, -7 },
  { 159, 6, 7, 8, 1, -7 },
  { 165, 6, 4, 8, 1, -6 },
  { 168, 6, 7, 8, 1, -7 },
  { 174, 5, 9, 8, 2, -9 },
  { 180, 6, 10, 8, 1, -9 },
  { 188, 7, 9, 8, 0, -9 },
  { 196, 6, 9, 8, 1, -9 },
  { 203, 6, 9, 8, 1, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 7, 9, 8, 1, -9 },
  { 225, 7, 9, 8, 1, -9 },
  { 233, 6, 9, 8, 1, -9 },
  { 240, 7, 9, 8, 1, -9 },
  { 248, 7, 9, 8, 1, -9 },
  { 256, 6, 9, 8, 1, -9 },
  { 263, 7, 9, 8, 1, -9 },
  { 271, 5, 9, 8, 1, -9 },
  { 277, 8, 9, 8, 0, -9 },
  { 286, 7, 9, 8, 1, -9 },
  { 294, 6, 9, 8, 1, -9 },
  { 301, 6, 9, 8, 1, -9 },
  { 308, 6, 12, 8, 1, -9 },
  { 317, 6, 9, 8, 1, -9 },
  { 324, 7, 9, 8, 0, -9 },
  { 332, 7, 9, 8, 1, -9 },
  { 340, 7, 9, 8, 1, -9 },
  { 348, 6, 9, 8, 2, -9 },
  { 355, 7, 9, 8, 1, -9 },
  { 363, 8, 9, 8, 0, -9 },
  { 372, 7, 9, 8, 1, -9 },
  { 380, 8, 9, 8, 0, -9 },
  { 389, 6, 12, 8, 2, -10 },
  { 398, 3, 12, 8, 3, -10 },
  { 403, 6, 12, 8, 0, -10 },
  { 412, 6, 5, 8, 1, -9 },
  { 416, 6, 1, 8, 0, 1 },
  { 417, 2, 2, 8, 3, -11 },
  { 418, 6, 7, 8, 1, -7 },
  { 424, 6, 10, 8, 1, -10 },
  { 432, 6, 7, 8, 1, -7 },
  { 438, 6, 10, 8, 1, -10 },
  { 446, 6, 7, 8, 1, -7 },
  { 452, 8, 13, 8, 0, -10 },
  { 465, 6, 10, 8, 1, -7 },
  { 473, 6, 10, 8, 1, -10 },
  { 481, 6, 10, 8, 1, -10 },
  { 489, 6, 13, 8, 1, -10 },
  { 499, 6, 10, 8, 1, -10 },
  { 507, 5, 10, 8, 2, -10 },
  { 514, 7, 7, 8, 0, -7 },
  { 521, 6, 7, 8, 1, -7 },
  { 527, 6, 7, 8, 1, -7 },
  { 533, 6, 10, 8, 1, -7 },
  { 541, 6, 10, 8, 1, -7 },
  { 549, 6, 7, 8, 2, -7 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 6, 9, 8, 1, -9 },
  { 568, 6, 7, 8, 1, -7 },
  { 574, 6, 7, 8, 1, -7 },
  { 580, 6, 7, 8, 1, -7 },
  { 586, 8, 7, 8, 0, -7 },
  { 593, 7, 10, 8, 0, -7 },
  { 602, 6, 7, 8, 1, -7 },
  { 608, 5, 12, 8, 2, -10 },
  { 616, 2, 12, 8, 3, -10 },
  { 619, 5, 12, 8, 1, -10 },
  { 627, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC13PT7B_H_
