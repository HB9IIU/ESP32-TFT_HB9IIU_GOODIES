#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC54PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x07, 0x80, 0x18, 0x31, 0x83, 0x30,
  0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x0C, 0x60, 0xCE, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0x08, 0xF8, 0x01, 0xC0, 0x40, 0xE0, 0x1C, 0x02,
  0x03, 0x81, 0xC0, 0x30, 0x0E, 0x0C, 0x01, 0x80, 0x20, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x03, 0xEC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x13, 0xE0, 0x00,
  0x00, 0x83, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x08,
  0x00, 0xC0, 0x18, 0x60, 0x04, 0x01, 0xC1, 0x80, 0x20, 0x0C, 0x0E, 0x03,
  0x00, 0xE0, 0x3C, 0x18, 0x1E, 0x00, 0x78, 0xC3, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x06, 0x00, 0xE0, 0xE0, 0x00,
  0xC0, 0x1C, 0x03, 0x00, 0x08, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x01, 0x80, 0x40, 0x06,
  0x00, 0x10, 0x0C, 0x00, 0x60, 0x01, 0x01, 0x80, 0x06, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x03, 0x02, 0x00, 0x06, 0x00, 0x30, 0x60, 0x00, 0x60, 0x06,
  0x0C, 0x00, 0x03, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x3C, 0x10, 0x00, 0x01,
  0xFF, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0C, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0xC0, 0x00,
  0x30, 0x60, 0x06, 0x00, 0x06, 0x06, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x80, 0x06, 0x00, 0x60, 0x08, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x0C, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x70, 0x70, 0x0C, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x78, 0xFE, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0xB0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x2C, 0x06, 0xC0,
  0x00, 0x98, 0x1D, 0x80, 0x01, 0x18, 0x31, 0x80, 0x06, 0x38, 0xC3, 0x80,
  0x18, 0x33, 0x83, 0xC0, 0xE0, 0x36, 0x03, 0xFF, 0x80, 0x78, 0x01, 0xFC,
  0x00, 0x70, 0x00, 0x19, 0x8C, 0x63, 0x19, 0x8C, 0x63, 0x18, 0xCC, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x60, 0x01, 0xF8, 0x06, 0x01, 0xF1, 0xF0, 0x60, 0xFC,
  0x07, 0xE6, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x01,
  0x80, 0x10, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x77, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x03, 0x80, 0x36, 0x01, 0xE0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x1C, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x3C, 0x60, 0x00, 0x78, 0x60,
  0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xC0, 0x0F, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x18,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x40, 0x00, 0x06,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0xFE, 0x00, 0x0C, 0xFF, 0xF0, 0x01, 0xB8, 0x0F, 0x80, 0x3C,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x3F, 0xC0, 0x18, 0xFF,
  0xF0, 0x33, 0xC0, 0x78, 0x37, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x68, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF2, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00,
  0x1C, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x0F, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x36, 0x38, 0x00, 0x66, 0x1E,
  0x01, 0xCC, 0x0F, 0xFF, 0x8C, 0x01, 0xFC, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x3C, 0x1E,
  0x00, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x39,
  0xC0, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x1E, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x23, 0x00, 0x7E, 0x31, 0x80, 0x7F, 0x98,
  0xC0, 0x70, 0x6C, 0x40, 0x60, 0x16, 0x60, 0x60, 0x07, 0x30, 0x30, 0x03,
  0x18, 0x30, 0x01, 0x8C, 0x18, 0x00, 0xC4, 0x0C, 0x00, 0x66, 0x04, 0x00,
  0x33, 0x02, 0x00, 0x19, 0x83, 0x00, 0x08, 0xC1, 0x80, 0x0C, 0x60, 0xC0,
  0x06, 0x20, 0x60, 0x03, 0x30, 0x30, 0x01, 0x98, 0x18, 0x01, 0xCC, 0x0C,
  0x01, 0x46, 0x03, 0x00, 0xE3, 0x01, 0x81, 0xB1, 0x80, 0x7F, 0x98, 0xC0,
  0x1F, 0x8C, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x07, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x18, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x84, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x3C, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x43, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x38, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x7F, 0xF3, 0x00, 0x3F, 0xF9, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40,
  0x00, 0x03, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x1C, 0x1C, 0x00, 0x16, 0x07, 0x00, 0x1B, 0x01, 0xE0, 0x79,
  0x80, 0x7F, 0xF0, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x61, 0x98, 0x00,
  0x00, 0xC6, 0x38, 0x00, 0x01, 0x98, 0x30, 0x00, 0x03, 0x60, 0x70, 0x00,
  0x07, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1A, 0x02, 0xC0, 0x00, 0x78, 0x19, 0x00, 0x03, 0x60, 0x66,
  0x00, 0x19, 0x81, 0x98, 0x00, 0x66, 0x06, 0x60, 0x03, 0x18, 0x18, 0x80,
  0x1C, 0x40, 0x43, 0x00, 0x63, 0x03, 0x0C, 0x03, 0x0C, 0x0C, 0x10, 0x0C,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x03, 0x06, 0x0C, 0x08,
  0x08, 0x08, 0x60, 0x60, 0x60, 0x31, 0x81, 0x81, 0x80, 0xCC, 0x06, 0x06,
  0x01, 0x60, 0x18, 0x18, 0x05, 0x80, 0x60, 0x60, 0x1C, 0x01, 0x01, 0x00,
  0x70, 0x0C, 0x0C, 0x00, 0x80, 0x30, 0x30, 0x04, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x02, 0xC0, 0x00, 0x30, 0x6C, 0x00,
  0x03, 0x06, 0xC0, 0x00, 0x30, 0x66, 0x00, 0x02, 0x06, 0x60, 0x00, 0x60,
  0x66, 0x00, 0x06, 0x04, 0x30, 0x00, 0x60, 0xC3, 0x00, 0x06, 0x0C, 0x30,
  0x00, 0x60, 0xC1, 0x80, 0x04, 0x0C, 0x18, 0x00, 0xC0, 0xC1, 0x80, 0x0C,
  0x08, 0x0C, 0x00, 0xC1, 0x80, 0xC0, 0x0C, 0x18, 0x0C, 0x00, 0xC1, 0x80,
  0x60, 0x08, 0x18, 0x06, 0x01, 0x81, 0x80, 0x60, 0x18, 0x10, 0x02, 0x01,
  0x83, 0x00, 0x30, 0x18, 0x30, 0x03, 0x01, 0x83, 0x00, 0x30, 0x10, 0x30,
  0x01, 0x83, 0x03, 0x00, 0x18, 0x30, 0x30, 0x01, 0x83, 0x06, 0x00, 0x0C,
  0x30, 0x60, 0x00, 0xC3, 0x06, 0x00, 0x0C, 0x20, 0x60, 0x00, 0x66, 0x06,
  0x00, 0x06, 0x60, 0x60, 0x00, 0x66, 0x0C, 0x00, 0x03, 0x60, 0xC0, 0x00,
  0x36, 0x0C, 0x00, 0x03, 0x40, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x03, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x70, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0x0C, 0x18, 0x07, 0x80, 0x60,
  0x80, 0x3C, 0x03, 0x04, 0x03, 0x60, 0x18, 0x20, 0x1B, 0x01, 0x83, 0x01,
  0x98, 0x0C, 0x18, 0x0C, 0xC0, 0x60, 0xC0, 0xC2, 0x02, 0x06, 0x06, 0x10,
  0x30, 0x30, 0x20, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x40,
  0x61, 0x81, 0x86, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x61, 0x80, 0xC6,
  0x03, 0x08, 0x04, 0x60, 0x08, 0xC0, 0x23, 0x00, 0x46, 0x01, 0x10, 0x03,
  0x30, 0x19, 0x80, 0x19, 0x00, 0xCC, 0x00, 0xD8, 0x06, 0xC0, 0x06, 0xC0,
  0x36, 0x00, 0x36, 0x01, 0xE0, 0x01, 0xA0, 0x0F, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x70, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC3, 0x86, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xC3, 0x03, 0xC0, 0xE3, 0x07, 0x00, 0x33, 0x0C, 0x00, 0x0B, 0x1C,
  0x00, 0x0B, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x58, 0x60, 0x00, 0xD0, 0x60,
  0x01, 0xB0, 0x30, 0x03, 0x30, 0x3C, 0x0E, 0x3F, 0x0F, 0xFC, 0x1F, 0x07,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC1, 0xFC, 0x00, 0x43, 0xFF, 0x80, 0x63, 0x81, 0xE0, 0x33, 0x00,
  0x38, 0x1B, 0x00, 0x0C, 0x0D, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x05, 0x80, 0x03, 0x86, 0x60, 0x03,
  0x83, 0x1C, 0x07, 0x81, 0x87, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x38, 0x00, 0xE0, 0xE0,
  0x00, 0xC1, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0x70, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x01, 0xFC, 0x06, 0x01, 0xFF, 0xC3, 0x00, 0xF0, 0x3C, 0xC0,
  0x70, 0x01, 0x30, 0x38, 0x00, 0x2C, 0x1C, 0x00, 0x0B, 0x0E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x03, 0x60, 0x60,
  0x01, 0x90, 0x0C, 0x00, 0xEC, 0x03, 0xC0, 0xF3, 0x00, 0x3F, 0xF0, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x38, 0x60, 0x01, 0xF0, 0x60, 0x3F,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x1C, 0x00,
  0xE0, 0x0E, 0x03, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x30, 0x0F, 0x03, 0xCC, 0x07, 0x00, 0x13,
  0x03, 0x00, 0x02, 0xC1, 0x80, 0x00, 0xB0, 0xE0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x01, 0x60, 0x60, 0x00, 0x58, 0x18, 0x00, 0x2C, 0x03, 0x00, 0x33, 0x00,
  0xF0, 0x38, 0xC0, 0x0F, 0xFC, 0x30, 0x00, 0xFC, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0xF0, 0x01, 0xC0, 0x0F,
  0x01, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x61, 0xFF, 0x80, 0xCE,
  0x07, 0x81, 0x90, 0x03, 0x06, 0x40, 0x07, 0x0D, 0x00, 0x06, 0x1A, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x40, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x10, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x00, 0x40, 0x07,
  0x01, 0x80, 0x1C, 0x03, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00,
  0x10, 0x70, 0x00, 0x61, 0xC0, 0x00, 0xCE, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x06, 0x03, 0xC0, 0x08, 0x01, 0xC0, 0x30, 0x01,
  0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x00, 0x01,
  0xC4, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x03, 0xF0, 0x00, 0x41, 0xFF, 0x80, 0x18, 0xF0, 0x38, 0x03, 0x30,
  0x03, 0x80, 0x6C, 0x00, 0x30, 0x0D, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x08, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x10, 0x00, 0x70, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x3C, 0x00, 0x18, 0x7E, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x03, 0x60,
  0x18, 0x00, 0xCC, 0x01, 0x80, 0x31, 0x80, 0x30, 0x0C, 0x30, 0x03, 0x03,
  0x04, 0x00, 0x60, 0xC1, 0x80, 0x06, 0x30, 0x30, 0x00, 0xDC, 0x06, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x02, 0x06, 0x00, 0x30,
  0x60, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x70, 0x0C, 0x0E, 0x00, 0xC1, 0xC0,
  0x0C, 0x70, 0x00, 0x8E, 0x00, 0x1B, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x67, 0xF8, 0x7F, 0x03, 0x70, 0xC6, 0x1C,
  0x1A, 0x03, 0x60, 0x60, 0xE0, 0x1A, 0x01, 0x87, 0x00, 0xE0, 0x0C, 0x30,
  0x07, 0x00, 0x63, 0x80, 0x30, 0x02, 0x18, 0x01, 0x80, 0x30, 0xC0, 0x0C,
  0x01, 0x86, 0x00, 0x40, 0x0C, 0x30, 0x06, 0x00, 0x61, 0x00, 0x30, 0x03,
  0x18, 0x01, 0x80, 0x10, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x0C, 0x30,
  0x02, 0x00, 0x61, 0x80, 0x30, 0x03, 0x08, 0x01, 0x80, 0x18, 0xC0, 0x0C,
  0x00, 0x86, 0x00, 0x60, 0x0C, 0x30, 0x03, 0x00, 0x61, 0x80, 0x10, 0x03,
  0x0C, 0x01, 0x80, 0x18, 0x40, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x04, 0x30,
  0x03, 0x00, 0x21, 0x80, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x07, 0xE0, 0x0C, 0x3F, 0xF0, 0x19, 0xC0, 0xF0, 0x32, 0x00, 0x60, 0xC8,
  0x00, 0xE1, 0xA0, 0x00, 0xC3, 0x40, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x84,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x02, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x38, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x07,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x21, 0xFF, 0xC0,
  0x0C, 0x70, 0x3C, 0x01, 0x98, 0x01, 0xC0, 0x36, 0x00, 0x18, 0x06, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x18, 0x1C, 0x00, 0x06, 0x02, 0xC0, 0x01, 0xC0, 0xCC, 0x00, 0x70,
  0x18, 0xE0, 0x3C, 0x03, 0x0F, 0xFE, 0x00, 0x60, 0x7F, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xC3, 0x03, 0xC0, 0xF3, 0x07, 0x00, 0x13, 0x0E, 0x00, 0x0B, 0x1C,
  0x00, 0x0B, 0x38, 0x00, 0x07, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x58, 0x60, 0x00, 0xD8, 0x60,
  0x01, 0xB0, 0x30, 0x03, 0x30, 0x3C, 0x0E, 0x30, 0x0F, 0xFC, 0x30, 0x03,
  0xF0, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xF0, 0x06, 0x78, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01,
  0xE0, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x7C, 0x03, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x01, 0xC0, 0x06, 0x01,
  0xE0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0xF0, 0x00, 0x0C,
  0x70, 0x00, 0x03, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x70, 0x00, 0xB0, 0x60, 0x03, 0x60,
  0xE0, 0x0C, 0xC0, 0xE0, 0x71, 0x80, 0xFF, 0xC2, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0x7F, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x40,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x0E, 0x02, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01,
  0x80, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x08, 0x0F, 0x00, 0x0C, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x18, 0x03, 0x01, 0x83, 0x00, 0x60, 0x10, 0x60,
  0x0C, 0x03, 0x08, 0x01, 0x80, 0x63, 0x00, 0x20, 0x0C, 0x60, 0x04, 0x00,
  0x8C, 0x01, 0x80, 0x11, 0x80, 0x30, 0x02, 0x30, 0x06, 0x00, 0x64, 0x00,
  0xC0, 0x0D, 0x80, 0x18, 0x01, 0xB0, 0x02, 0x00, 0x36, 0x00, 0xC0, 0x04,
  0xC0, 0x18, 0x00, 0x98, 0x03, 0x00, 0x32, 0x00, 0x60, 0x06, 0xC0, 0x0C,
  0x00, 0xD8, 0x01, 0x00, 0x1B, 0x00, 0x60, 0x03, 0x60, 0x0C, 0x00, 0xCC,
  0x01, 0x80, 0x19, 0x00, 0x30, 0x03, 0x20, 0x0E, 0x00, 0xC4, 0x01, 0xC0,
  0x18, 0x80, 0x78, 0x06, 0x18, 0x19, 0x01, 0xC3, 0x86, 0x30, 0x70, 0x3F,
  0x83, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0xF0, 0x07, 0xB8, 0x38, 0x70, 0x3C, 0x30, 0xE0, 0x61, 0xC0, 0x61,
  0x80, 0xC6, 0x00, 0x66, 0x00, 0xD0, 0x00, 0xC8, 0x01, 0x80, 0x01, 0xB0,
  0x03, 0x00, 0x01, 0x40, 0x04, 0x00, 0x02, 0x80, 0x08, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x18, 0x01, 0xA0, 0x00, 0x30, 0x02, 0x40, 0x00, 0x60,
  0x04, 0xC0, 0x08, 0xC0, 0x19, 0x80, 0x79, 0x80, 0x63, 0x01, 0xC1, 0x81,
  0x83, 0x0E, 0x03, 0x87, 0x06, 0x70, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x18, 0x00, 0x16, 0x06,
  0x00, 0x07, 0x01, 0xC0, 0x02, 0xC0, 0x30, 0x01, 0xB0, 0x0E, 0x00, 0xCC,
  0x01, 0xC0, 0xE3, 0x00, 0x3F, 0xF0, 0xC0, 0x03, 0xF0, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00,
  0x38, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x30, 0x70, 0x3E, 0x0C, 0x30, 0x01, 0xF3, 0x08,
  0x00, 0x0F, 0xC6, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x10, 0x07, 0x00, 0x04, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x7C, 0x00, 0x06, 0x3F, 0xF0, 0x00, 0x8C, 0x1F,
  0xE0, 0x33, 0x00, 0x7F, 0x8C, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x21, 0xFE, 0x00,
  0x0C, 0x70, 0xE0, 0x01, 0x8C, 0x0E, 0x00, 0x63, 0x00, 0xC0, 0x0C, 0xC0,
  0x0C, 0x03, 0x18, 0x00, 0xC0, 0xE2, 0x00, 0x1C, 0x38, 0xC0, 0x01, 0xFE,
  0x18, 0x00, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 38, 32, 12, -38 },
  { 44, 12, 14, 32, 13, -40 },
  { 65, 32, 38, 32, 1, -38 },
  { 217, 29, 49, 32, 2, -43 },
  { 395, 36, 39, 32, -1, -38 },
  { 571, 31, 39, 32, 1, -38 },
  { 723, 5, 14, 32, 17, -40 },
  { 732, 18, 48, 32, 12, -41 },
  { 840, 17, 48, 32, 4, -41 },
  { 942, 28, 27, 32, 3, -30 },
  { 1037, 26, 26, 32, 4, -29 },
  { 1122, 9, 14, 32, 8, -5 },
  { 1138, 15, 2, 32, 9, -17 },
  { 1142, 5, 4, 32, 12, -4 },
  { 1145, 29, 48, 32, 2, -41 },
  { 1319, 26, 39, 32, 4, -38 },
  { 1446, 24, 38, 32, 3, -38 },
  { 1560, 27, 38, 32, 2, -38 },
  { 1689, 27, 39, 32, 2, -38 },
  { 1821, 28, 38, 32, 1, -38 },
  { 1954, 27, 39, 32, 3, -38 },
  { 2086, 24, 39, 32, 4, -38 },
  { 2203, 26, 38, 32, 6, -38 },
  { 2327, 27, 39, 32, 3, -38 },
  { 2459, 24, 38, 32, 5, -38 },
  { 2573, 9, 28, 32, 12, -28 },
  { 2605, 13, 37, 32, 8, -28 },
  { 2666, 26, 29, 32, 5, -31 },
  { 2761, 27, 11, 32, 3, -22 },
  { 2799, 25, 29, 32, 3, -31 },
  { 2890, 22, 38, 32, 8, -38 },
  { 2995, 25, 44, 32, 4, -38 },
  { 3133, 28, 38, 32, 0, -38 },
  { 3266, 26, 38, 32, 3, -38 },
  { 3390, 25, 39, 32, 5, -38 },
  { 3512, 27, 38, 32, 3, -38 },
  { 3641, 29, 38, 32, 3, -38 },
  { 3779, 29, 38, 32, 3, -38 },
  { 3917, 25, 39, 32, 5, -38 },
  { 4039, 28, 38, 32, 3, -38 },
  { 4172, 28, 38, 32, 3, -38 },
  { 4305, 25, 39, 32, 4, -38 },
  { 4427, 31, 38, 32, 3, -38 },
  { 4575, 22, 38, 32, 5, -38 },
  { 4680, 30, 38, 32, 2, -38 },
  { 4823, 28, 38, 32, 3, -38 },
  { 4956, 26, 39, 32, 4, -38 },
  { 5083, 28, 38, 32, 3, -38 },
  { 5216, 26, 47, 32, 4, -38 },
  { 5369, 28, 38, 32, 3, -38 },
  { 5502, 29, 39, 32, 2, -38 },
  { 5644, 28, 38, 32, 6, -38 },
  { 5777, 26, 39, 32, 5, -38 },
  { 5904, 27, 38, 32, 7, -38 },
  { 6033, 29, 38, 32, 4, -38 },
  { 6171, 34, 38, 32, 0, -38 },
  { 6333, 30, 38, 32, 5, -38 },
  { 6476, 33, 38, 32, 0, -38 },
  { 6633, 22, 48, 32, 10, -41 },
  { 6765, 12, 48, 32, 11, -41 },
  { 6837, 22, 48, 32, 1, -41 },
  { 6969, 26, 21, 32, 4, -38 },
  { 7038, 26, 2, 32, 0, 6 },
  { 7045, 6, 9, 32, 13, -41 },
  { 7052, 24, 30, 32, 4, -29 },
  { 7142, 25, 41, 32, 4, -40 },
  { 7271, 23, 30, 32, 4, -29 },
  { 7358, 26, 41, 32, 4, -40 },
  { 7492, 24, 30, 32, 4, -29 },
  { 7582, 34, 51, 32, -1, -40 },
  { 7799, 26, 40, 32, 2, -29 },
  { 7929, 23, 40, 32, 4, -40 },
  { 8044, 23, 42, 32, 5, -41 },
  { 8165, 23, 52, 32, 5, -41 },
  { 8315, 27, 41, 32, 4, -40 },
  { 8454, 20, 41, 32, 7, -40 },
  { 8557, 29, 29, 32, 2, -29 },
  { 8663, 23, 29, 32, 4, -29 },
  { 8747, 24, 30, 32, 4, -29 },
  { 8837, 27, 40, 32, 2, -29 },
  { 8972, 24, 40, 32, 4, -29 },
  { 9092, 26, 28, 32, 6, -28 },
  { 9183, 26, 30, 32, 3, -29 },
  { 9281, 26, 39, 32, 4, -38 },
  { 9408, 23, 29, 32, 5, -28 },
  { 9492, 25, 28, 32, 4, -28 },
  { 9580, 27, 29, 32, 4, -28 },
  { 9678, 31, 30, 32, 1, -29 },
  { 9795, 26, 39, 32, 2, -28 },
  { 9922, 26, 30, 32, 3, -29 },
  { 10020, 25, 48, 32, 6, -41 },
  { 10170, 10, 48, 32, 12, -41 },
  { 10230, 24, 48, 32, 3, -41 },
  { 10374, 27, 10, 32, 3, -22 },
};

const GFXfont IBMPlexMono_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC54PT7B_H_
