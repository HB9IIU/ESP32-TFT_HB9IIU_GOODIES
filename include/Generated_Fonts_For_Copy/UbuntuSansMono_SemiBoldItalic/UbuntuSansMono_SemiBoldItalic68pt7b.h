#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC68PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xE0,
  0x00, 0x3F, 0xE0, 0x7F, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xF8,
  0x1F, 0xF7, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF,
  0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0x80,
  0x1F, 0xF8, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xE0,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x87,
  0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x7F,
  0x00, 0x00, 0x03, 0xFF, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC7, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x7E, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0x87, 0xFD, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xFE, 0x7F, 0x0F, 0xF0, 0x3F, 0xCF, 0xE3, 0xFC, 0x07, 0xFF, 0xF8,
  0x7F, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0xFF,
  0xF8, 0x7F, 0x80, 0x0F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xC1, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xF1,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0C,
  0x03, 0xF8, 0x04, 0x1E, 0x07, 0xE0, 0x38, 0x3F, 0x0F, 0xC1, 0xF8, 0xFF,
  0x8F, 0x8F, 0xF1, 0xFF, 0x9F, 0x7F, 0xE3, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8,
  0x7F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0x1F, 0xE0, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xE1,
  0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F,
  0xE1, 0xFE, 0x7F, 0x81, 0xF8, 0x3F, 0xCF, 0xF0, 0x0C, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xC1, 0xFF, 0x00, 0x38, 0x0F,
  0xF8, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x1F, 0xF8,
  0x00, 0x40, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x3C,
  0x00, 0x07, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x0E,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x82, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFC, 0x07, 0xFF, 0x06, 0x00, 0x1F, 0xF0, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xFF, 0x8F, 0xE0,
  0x3F, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xFC, 0x3F,
  0xC7, 0xF0, 0x3F, 0xC0, 0xFF, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x7F, 0x07,
  0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0xC0, 0x3F, 0x87, 0xE0, 0xFF, 0x01, 0xFE,
  0x3F, 0x83, 0xF8, 0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x80, 0x7F, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0xEF, 0xF0, 0x3F, 0x83, 0xFF,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x30, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x0F,
  0xFC, 0x00, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x7F, 0xF0,
  0x01, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x0F, 0xFE, 0x00, 0x02, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x00, 0x07, 0xFB,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xBE, 0x03, 0xEF, 0xC0,
  0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x00, 0xFE, 0xF8, 0x1F, 0x7F, 0x00, 0x1F,
  0xDF, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0xF9, 0xF8, 0x00, 0xFE, 0x7E,
  0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xCF, 0xCF, 0xE0, 0x03, 0xF9, 0xF9, 0xF9,
  0xFC, 0x00, 0x7E, 0x3F, 0x7E, 0x3F, 0x80, 0x1F, 0xC3, 0xEF, 0x87, 0xE0,
  0x03, 0xF8, 0x7F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xFF, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xF7, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xDF, 0x80, 0x3F, 0x80, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0x00, 0xFE,
  0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xC7, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x03, 0xFC, 0x07,
  0xE3, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xDF,
  0xC0, 0x03, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x7F, 0x00,
  0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x70, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF1,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xFF, 0x07,
  0xE0, 0x07, 0xF1, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x7D, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0x9F, 0x8F, 0xC0, 0x0F, 0xE7,
  0xE3, 0xE7, 0xF0, 0x03, 0xFB, 0xF0, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x3E,
  0x7E, 0x00, 0x3F, 0x7E, 0x0F, 0x9F, 0x80, 0x0F, 0xDF, 0x83, 0xEF, 0xE0,
  0x07, 0xFF, 0xC0, 0xFB, 0xF0, 0x01, 0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0x7F,
  0xF8, 0x0F, 0xBF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x18, 0x00, 0x78,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x03, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xE0, 0xFE, 0x00,
  0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x06, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFE,
  0x7F, 0x80, 0x0F, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0x81, 0xFF, 0xF0,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x04,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xE0,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xE0,
  0x01, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE3, 0xFF, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xDF,
  0xE0, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE3, 0xF8, 0x03, 0xFE,
  0x00, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x10, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF,
  0xFE, 0x7F, 0x80, 0x1F, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x02, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0xC1,
  0xFC, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0x7F,
  0x0F, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0xF8,
  0xFE, 0x03, 0xF8, 0xFD, 0xF1, 0xFC, 0x07, 0xE3, 0xF3, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE7, 0xCF, 0xE0, 0x1F, 0x9F, 0x8F, 0x9F, 0x80, 0x3F, 0x3F, 0x1F,
  0x3F, 0x00, 0x7E, 0xFC, 0x3E, 0xFE, 0x00, 0xFD, 0xF8, 0x7D, 0xF8, 0x01,
  0xFF, 0xE0, 0xFB, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF3, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0xFF, 0x00, 0x7F,
  0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x87, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0E, 0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 20, 48, 38, 10, -47 },
  { 121, 25, 21, 38, 13, -52 },
  { 187, 40, 47, 38, 0, -47 },
  { 422, 37, 60, 38, 1, -53 },
  { 700, 47, 49, 38, -3, -48 },
  { 988, 35, 49, 38, 1, -48 },
  { 1203, 12, 22, 38, 19, -52 },
  { 1236, 30, 67, 38, 8, -54 },
  { 1488, 30, 67, 38, 1, -54 },
  { 1740, 31, 29, 38, 7, -47 },
  { 1853, 33, 34, 38, 3, -37 },
  { 1994, 18, 23, 38, 5, -12 },
  { 2046, 21, 9, 38, 9, -24 },
  { 2070, 13, 13, 38, 10, -12 },
  { 2092, 45, 66, 38, -4, -53 },
  { 2464, 35, 49, 38, 3, -48 },
  { 2679, 29, 47, 38, 3, -47 },
  { 2850, 36, 48, 38, 1, -48 },
  { 3066, 37, 49, 38, 0, -48 },
  { 3293, 38, 47, 38, 0, -47 },
  { 3517, 39, 48, 38, 0, -47 },
  { 3751, 36, 48, 38, 3, -47 },
  { 3967, 35, 47, 38, 7, -47 },
  { 4173, 36, 49, 38, 2, -48 },
  { 4394, 36, 48, 38, 2, -48 },
  { 4610, 18, 37, 38, 10, -36 },
  { 4694, 23, 47, 38, 5, -36 },
  { 4830, 34, 32, 38, 3, -36 },
  { 4966, 37, 22, 38, 1, -31 },
  { 5068, 35, 32, 38, 1, -36 },
  { 5208, 28, 49, 38, 9, -48 },
  { 5380, 38, 58, 38, 2, -48 },
  { 5656, 36, 47, 38, -3, -47 },
  { 5868, 38, 49, 38, 0, -48 },
  { 6101, 37, 49, 38, 4, -48 },
  { 6328, 37, 49, 38, 0, -48 },
  { 6555, 38, 47, 38, 2, -47 },
  { 6779, 39, 47, 38, 2, -47 },
  { 7009, 37, 49, 38, 3, -48 },
  { 7236, 43, 47, 38, -1, -47 },
  { 7489, 39, 47, 38, 1, -47 },
  { 7719, 39, 48, 38, 1, -47 },
  { 7953, 43, 47, 38, 0, -47 },
  { 8206, 30, 47, 38, 1, -47 },
  { 8383, 43, 47, 38, -2, -47 },
  { 8636, 43, 47, 38, -1, -47 },
  { 8889, 35, 49, 38, 3, -48 },
  { 9104, 39, 48, 38, 0, -48 },
  { 9338, 35, 61, 38, 3, -48 },
  { 9605, 38, 48, 38, 0, -48 },
  { 9833, 39, 49, 38, 0, -48 },
  { 10072, 36, 47, 38, 7, -47 },
  { 10284, 38, 48, 38, 3, -47 },
  { 10512, 37, 47, 38, 7, -47 },
  { 10730, 42, 47, 38, 1, -47 },
  { 10977, 47, 47, 38, -3, -47 },
  { 11254, 36, 47, 38, 8, -47 },
  { 11466, 42, 47, 38, -1, -47 },
  { 11713, 36, 66, 38, 4, -53 },
  { 12010, 14, 66, 38, 13, -53 },
  { 12126, 37, 66, 38, -2, -53 },
  { 12432, 34, 27, 38, 4, -47 },
  { 12547, 36, 8, 38, -5, 5 },
  { 12583, 15, 14, 38, 16, -53 },
  { 12610, 35, 37, 38, 2, -36 },
  { 12772, 34, 54, 38, 1, -53 },
  { 13002, 34, 38, 38, 3, -37 },
  { 13164, 40, 54, 38, 2, -53 },
  { 13434, 33, 38, 38, 3, -37 },
  { 13591, 46, 66, 38, -4, -53 },
  { 13971, 40, 49, 38, -2, -36 },
  { 14216, 35, 53, 38, 0, -53 },
  { 14448, 25, 54, 38, 6, -53 },
  { 14617, 38, 66, 38, -3, -53 },
  { 14931, 39, 53, 38, 1, -53 },
  { 15190, 23, 53, 38, 9, -52 },
  { 15343, 38, 36, 38, -1, -36 },
  { 15514, 34, 36, 38, 1, -36 },
  { 15667, 34, 38, 38, 2, -37 },
  { 15829, 39, 49, 38, -3, -36 },
  { 16068, 35, 49, 38, 3, -36 },
  { 16283, 35, 36, 38, 3, -36 },
  { 16441, 34, 38, 38, 2, -37 },
  { 16603, 31, 47, 38, 6, -46 },
  { 16786, 34, 37, 38, 3, -36 },
  { 16944, 33, 36, 38, 6, -36 },
  { 17093, 39, 36, 38, 2, -36 },
  { 17269, 41, 36, 38, -2, -36 },
  { 17454, 45, 49, 38, -6, -36 },
  { 17730, 36, 36, 38, 1, -36 },
  { 17892, 37, 66, 38, 4, -53 },
  { 18198, 24, 66, 38, 7, -53 },
  { 18396, 37, 66, 38, -3, -53 },
  { 18702, 36, 13, 38, 1, -27 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC68PT7B_H_
