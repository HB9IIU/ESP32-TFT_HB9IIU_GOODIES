#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC57PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xBF, 0xC0, 0x1F, 0xE0, 0x03, 0x80, 0x3F, 0x80, 0x02,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x00,
  0xFE, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x3F,
  0xFC, 0x00, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x07, 0xC3, 0xC0, 0x1F,
  0x00, 0x1F, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x3C, 0x07, 0xE0, 0x03, 0xE0,
  0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xC0, 0xF8, 0x00, 0x3C, 0x1F, 0x07, 0xC0,
  0x00, 0xF0, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xE1, 0xF0, 0x00, 0x0F, 0x0F,
  0x8F, 0xC0, 0x00, 0x3E, 0x7C, 0x7E, 0x00, 0x00, 0xFF, 0xF3, 0xF0, 0x00,
  0x03, 0xFF, 0x8F, 0x80, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0x0F, 0xE3,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0xE0, 0x00, 0x00, 0xF8,
  0xFF, 0xC0, 0x00, 0x07, 0xC7, 0xFF, 0x00, 0x00, 0x3E, 0x3F, 0xFE, 0x00,
  0x01, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x78, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x7C, 0x0F, 0x83, 0xC0, 0x03, 0xF0, 0x3E, 0x1F, 0x00, 0x1F, 0x80, 0xF0,
  0x7C, 0x00, 0x7C, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0xFF, 0xFC,
  0x1F, 0x87, 0xF3, 0xF8, 0xFC, 0x3F, 0x87, 0xF3, 0xF1, 0xFC, 0x1F, 0xDF,
  0x87, 0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0x7F, 0xF0, 0xFE, 0x01, 0xFF, 0xC3,
  0xF0, 0x03, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xF0,
  0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x03, 0xE0, 0x31, 0xF0, 0xF8, 0x7C, 0x7F, 0x3E, 0x3F, 0x1F, 0xE7,
  0xBF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x7C, 0x1F, 0x80, 0x0E, 0x03, 0x80, 0x01,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x81, 0xFE, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x1F,
  0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7,
  0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x60, 0x7E, 0x3F, 0x87,
  0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x3F, 0x9F, 0xC3, 0xF8,
  0xFE, 0x7F, 0x1F, 0xE3, 0xF9, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xF8, 0x7F,
  0x1F, 0x81, 0xC1, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x80, 0x7F, 0x3F, 0xC0, 0x3E, 0x1F,
  0xC0, 0x0C, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0x60, 0x01, 0xFC, 0x02,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0x80, 0x0F, 0x00, 0xFF, 0x80, 0x10,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x60, 0x00, 0x7F, 0xC0, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x3F, 0xE0, 0x0F, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x3F,
  0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0xC7, 0x00,
  0x7F, 0x88, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0x0F, 0xC0, 0x7F, 0xFF, 0x1F,
  0x80, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xFE, 0x1F, 0x03, 0xFF, 0xFE, 0x3F,
  0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xE0, 0xFC, 0x7E,
  0x1F, 0xC0, 0xFC, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x1F, 0x80, 0xFC, 0x7C,
  0x3F, 0x81, 0xFC, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x3F, 0x01, 0xF8, 0x7C,
  0x3F, 0x01, 0xF8, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7C, 0x1F, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0xE0, 0x7E,
  0x07, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x38, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0,
  0x1E, 0x01, 0xFF, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x02, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0xFF, 0xE1,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0x83, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x00,
  0x08, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x00,
  0x7F, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x7F, 0x8F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xDE, 0x0F,
  0x7C, 0x00, 0xF9, 0xE1, 0xF7, 0xC0, 0x0F, 0x9E, 0x1E, 0x7C, 0x01, 0xF9,
  0xE3, 0xE7, 0xC0, 0x1F, 0x9E, 0x3C, 0xFC, 0x01, 0xF1, 0xE7, 0xCF, 0xC0,
  0x1F, 0x1E, 0x78, 0xF8, 0x03, 0xF1, 0xFF, 0x8F, 0x80, 0x3F, 0x1F, 0xF1,
  0xF8, 0x03, 0xF1, 0xFF, 0x1F, 0x80, 0x7E, 0x1F, 0xE1, 0xF8, 0x07, 0xE1,
  0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x07, 0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xF8, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x80,
  0x3F, 0x7E, 0x03, 0xF0, 0x07, 0xE7, 0xC0, 0xFE, 0x00, 0xFC, 0xF8, 0x1F,
  0x80, 0x3F, 0x9F, 0x83, 0xF0, 0x07, 0xE3, 0xF0, 0x7E, 0x00, 0xFC, 0x3E,
  0x1F, 0xC0, 0x1F, 0x87, 0xC3, 0xF8, 0x07, 0xF0, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0x8F, 0xC0, 0x1F, 0x81, 0xF1, 0xF8, 0x03, 0xF0, 0x3E, 0x7F, 0x00,
  0xFE, 0x07, 0xCF, 0xC0, 0x1F, 0xC0, 0xFD, 0xF8, 0x03, 0xF0, 0x0F, 0xBF,
  0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xF8, 0x07,
  0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xFC, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x81, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x03,
  0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0xFE, 0x00, 0x04, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0x1F,
  0xE0, 0x3C, 0x00, 0x3F, 0xE0, 0x3F, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x7E,
  0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF8,
  0x7E, 0x01, 0xF0, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0xE1, 0xF0, 0x0F, 0xC7,
  0xBC, 0x7E, 0x01, 0xF9, 0xF7, 0xCF, 0xC0, 0x3E, 0x7C, 0xF9, 0xF8, 0x07,
  0xCF, 0x9F, 0x3E, 0x01, 0xFB, 0xE3, 0xEF, 0xC0, 0x3F, 0x7C, 0x7D, 0xF8,
  0x07, 0xDF, 0x0F, 0xBE, 0x00, 0xFB, 0xE1, 0xF7, 0xC0, 0x1F, 0xF8, 0x1E,
  0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF1, 0xF8, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFD,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x3C, 0x04,
  0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0xE0, 0x0F, 0x80, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x18,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFE, 0x7F, 0xC1, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xDF, 0xC0, 0x3F, 0xF8, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x08,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x7F,
  0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xFC,
  0x3F, 0x80, 0xFF, 0xC1, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x04, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0x01, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFB, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0xE0, 0x00,
  0xFF, 0xC3, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xF1, 0xFC,
  0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x80, 0x0F,
  0xF8, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x0C, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0xFF,
  0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x20, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x20, 0x03, 0xFC,
  0x00, 0x38, 0x07, 0xFC, 0x00, 0x7F, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x7F,
  0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x07, 0xF7, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x4F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xE1, 0xFC, 0x01, 0xFF, 0xF7, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xF1, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xBC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF, 0x81,
  0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x1F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xEF, 0xE0, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x80,
  0x08, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x07, 0xF0, 0x38,
  0x00, 0x7F, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x08, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xC3, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8,
  0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x07, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0xFC,
  0x7E, 0x0F, 0xE0, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xE1, 0xF8,
  0x7E, 0x1F, 0xE1, 0xF0, 0x7C, 0x3F, 0xE3, 0xF0, 0x7C, 0x3F, 0xE3, 0xF0,
  0x7C, 0x7F, 0xE3, 0xE0, 0x7C, 0x7F, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xC0,
  0xFC, 0xF1, 0xE7, 0xC0, 0xFD, 0xF1, 0xEF, 0xC0, 0xFB, 0xE1, 0xEF, 0x80,
  0xFB, 0xE1, 0xEF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0E, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x70, 0x1F, 0xFC, 0x03, 0xF0, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF,
  0xF8, 0x7E, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFF,
  0xFF, 0x1F, 0x81, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xC0, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 17, 41, 32, 8, -40 },
  { 89, 22, 17, 32, 10, -43 },
  { 136, 34, 40, 32, 0, -40 },
  { 306, 31, 50, 32, 1, -44 },
  { 500, 38, 41, 32, -2, -40 },
  { 695, 30, 41, 32, 1, -40 },
  { 849, 10, 18, 32, 16, -43 },
  { 872, 26, 56, 32, 6, -45 },
  { 1054, 25, 56, 32, 1, -45 },
  { 1229, 26, 25, 32, 6, -40 },
  { 1311, 28, 28, 32, 2, -31 },
  { 1409, 15, 20, 32, 4, -10 },
  { 1447, 18, 7, 32, 7, -20 },
  { 1463, 11, 11, 32, 8, -10 },
  { 1479, 37, 56, 32, -3, -45 },
  { 1738, 30, 41, 32, 2, -40 },
  { 1892, 25, 40, 32, 2, -40 },
  { 2017, 30, 40, 32, 1, -40 },
  { 2167, 31, 41, 32, 0, -40 },
  { 2326, 32, 40, 32, 0, -40 },
  { 2486, 33, 41, 32, 0, -40 },
  { 2656, 30, 41, 32, 3, -40 },
  { 2810, 29, 40, 32, 6, -40 },
  { 2955, 30, 41, 32, 2, -40 },
  { 3109, 31, 40, 32, 1, -40 },
  { 3264, 16, 31, 32, 8, -30 },
  { 3326, 20, 40, 32, 4, -30 },
  { 3426, 28, 27, 32, 3, -30 },
  { 3521, 31, 18, 32, 1, -26 },
  { 3591, 29, 27, 32, 1, -30 },
  { 3689, 23, 41, 32, 8, -40 },
  { 3807, 32, 49, 32, 1, -40 },
  { 4003, 31, 40, 32, -3, -40 },
  { 4158, 32, 40, 32, 0, -40 },
  { 4318, 31, 41, 32, 3, -40 },
  { 4477, 31, 40, 32, 0, -40 },
  { 4632, 33, 40, 32, 1, -40 },
  { 4797, 33, 40, 32, 2, -40 },
  { 4962, 31, 41, 32, 3, -40 },
  { 5121, 36, 40, 32, -1, -40 },
  { 5301, 33, 40, 32, 1, -40 },
  { 5466, 32, 41, 32, 1, -40 },
  { 5630, 36, 40, 32, 0, -40 },
  { 5810, 25, 40, 32, 1, -40 },
  { 5935, 36, 40, 32, -2, -40 },
  { 6115, 35, 40, 32, 0, -40 },
  { 6290, 30, 41, 32, 2, -40 },
  { 6444, 33, 40, 32, 0, -40 },
  { 6609, 30, 51, 32, 2, -40 },
  { 6801, 32, 40, 32, 0, -40 },
  { 6961, 32, 41, 32, 0, -40 },
  { 7125, 30, 40, 32, 6, -40 },
  { 7275, 32, 41, 32, 2, -40 },
  { 7439, 31, 40, 32, 6, -40 },
  { 7594, 35, 40, 32, 1, -40 },
  { 7769, 38, 40, 32, -2, -40 },
  { 7959, 30, 40, 32, 7, -40 },
  { 8109, 34, 40, 32, 0, -40 },
  { 8279, 31, 56, 32, 3, -45 },
  { 8496, 12, 56, 32, 11, -45 },
  { 8580, 30, 56, 32, -1, -45 },
  { 8790, 28, 23, 32, 3, -40 },
  { 8871, 30, 7, 32, -4, 4 },
  { 8898, 13, 12, 32, 13, -44 },
  { 8918, 29, 32, 32, 2, -31 },
  { 9034, 29, 45, 32, 1, -44 },
  { 9198, 29, 32, 32, 2, -31 },
  { 9314, 33, 45, 32, 2, -44 },
  { 9500, 29, 32, 32, 2, -31 },
  { 9616, 39, 55, 32, -4, -44 },
  { 9885, 34, 42, 32, -2, -31 },
  { 10064, 29, 44, 32, 0, -44 },
  { 10224, 21, 46, 32, 5, -45 },
  { 10345, 32, 56, 32, -2, -45 },
  { 10569, 32, 44, 32, 1, -44 },
  { 10745, 19, 45, 32, 7, -44 },
  { 10852, 32, 30, 32, -1, -30 },
  { 10972, 28, 31, 32, 1, -31 },
  { 11081, 28, 32, 32, 2, -31 },
  { 11193, 32, 42, 32, -2, -31 },
  { 11361, 30, 42, 32, 2, -31 },
  { 11519, 30, 31, 32, 2, -31 },
  { 11636, 29, 32, 32, 1, -31 },
  { 11752, 26, 40, 32, 5, -39 },
  { 11882, 28, 31, 32, 3, -30 },
  { 11991, 28, 30, 32, 5, -30 },
  { 12096, 32, 30, 32, 2, -30 },
  { 12216, 35, 30, 32, -2, -30 },
  { 12348, 37, 41, 32, -5, -30 },
  { 12538, 30, 30, 32, 1, -30 },
  { 12651, 30, 56, 32, 4, -45 },
  { 12861, 20, 56, 32, 6, -45 },
  { 13001, 30, 56, 32, -2, -45 },
  { 13211, 30, 11, 32, 1, -22 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC57PT7B_H_
