#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC20PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x70, 0x00, 0x38, 0xE3, 0x80,
  0xE7, 0xDF, 0x3E, 0x6C, 0xD1, 0x00, 0x07, 0x30, 0x66, 0x06, 0x60, 0xCC,
  0x7F, 0xF7, 0xFE, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFC, 0xFF, 0xC6, 0x60,
  0x66, 0x0C, 0xC0, 0x01, 0x80, 0x30, 0x06, 0x07, 0xF1, 0xFE, 0x30, 0x0E,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0xC7, 0x3F, 0xE1,
  0xF0, 0x18, 0x03, 0x00, 0x0E, 0x0C, 0x68, 0x61, 0x23, 0x0C, 0x98, 0x36,
  0xC0, 0xFE, 0x01, 0x90, 0x00, 0xD8, 0x06, 0xF0, 0x36, 0xC1, 0x93, 0x0C,
  0x4C, 0x21, 0x63, 0x87, 0x00, 0x07, 0x81, 0xF8, 0x63, 0x0C, 0x61, 0x98,
  0x36, 0x07, 0x81, 0xF7, 0x66, 0xCC, 0xFB, 0x8E, 0x71, 0xC7, 0xF8, 0xFB,
  0x80, 0xFF, 0x6D, 0x00, 0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x02, 0x00, 0x04, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x08, 0x00, 0x1C, 0x0E, 0x12, 0x5F, 0xF7, 0xF0, 0xE0, 0xD8, 0xEE, 0x22,
  0x00, 0x06, 0x03, 0x80, 0xC0, 0x30, 0xFF, 0xFF, 0xE1, 0x80, 0x60, 0x18,
  0x0E, 0x00, 0x10, 0xF3, 0xCE, 0x19, 0xCE, 0x00, 0xFF, 0xF0, 0x4F, 0xFE,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x87, 0xF3,
  0x9D, 0xC3, 0x60, 0xD9, 0x3E, 0xCF, 0x37, 0xC1, 0xB0, 0x6C, 0x3B, 0x1C,
  0xFE, 0x1F, 0x00, 0x03, 0x83, 0x87, 0xC7, 0xE2, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x06, 0x03, 0x03, 0x8F, 0xF7, 0xF8, 0x0F, 0xC3, 0xFC, 0x63, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x07,
  0xF9, 0xFF, 0x00, 0x0F, 0xC3, 0xF8, 0x43, 0x80, 0x70, 0x0C, 0x03, 0x83,
  0xC0, 0x7C, 0x01, 0xC0, 0x38, 0x07, 0x40, 0xCF, 0xF9, 0xFE, 0x00, 0x00,
  0xE0, 0x3C, 0x0F, 0x83, 0x60, 0xCC, 0x3B, 0x8E, 0x71, 0x8C, 0x61, 0xBF,
  0xFB, 0xFF, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x0F, 0xF0, 0xFE, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x01, 0xC4,
  0x38, 0xFF, 0x8F, 0xF0, 0x01, 0xE1, 0xF8, 0x78, 0x1C, 0x07, 0x00, 0xCC,
  0x3F, 0xE7, 0x1C, 0xC1, 0x98, 0x33, 0x06, 0x71, 0xC7, 0xF0, 0x7C, 0x00,
  0x7F, 0xDF, 0xF0, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0x87, 0xF3, 0x0C, 0xC3, 0x30,
  0xCE, 0x61, 0xF0, 0xFC, 0x63, 0xB0, 0x6C, 0x1B, 0x0E, 0xFF, 0x1F, 0x80,
  0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xD8, 0x37, 0x1D, 0xFF, 0x1D, 0x80,
  0xE0, 0x70, 0x38, 0xFC, 0x3C, 0x00, 0x11, 0xCE, 0x70, 0x00, 0x08, 0xF7,
  0xB8, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x08, 0x3C, 0x78, 0xE0, 0xC7,
  0x1C, 0x00, 0x01, 0xC1, 0xF3, 0xF3, 0xE0, 0xE0, 0x1E, 0x01, 0xF0, 0x1E,
  0x01, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x38,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1C, 0x1F, 0x1F, 0x87, 0x80, 0x40, 0x00,
  0x7E, 0x7F, 0x47, 0x07, 0x06, 0x1E, 0x38, 0x70, 0x60, 0x00, 0x00, 0xE0,
  0xE0, 0xE0, 0x07, 0xE0, 0xFE, 0x18, 0x73, 0x03, 0x31, 0xF6, 0x7E, 0x66,
  0x66, 0xC6, 0x6C, 0xE4, 0xCC, 0xCC, 0xC6, 0xFC, 0x67, 0xC6, 0x00, 0x70,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x19,
  0x83, 0x38, 0xC7, 0x18, 0xE7, 0xFC, 0xFF, 0xB8, 0x76, 0x0F, 0xC1, 0xC0,
  0x1F, 0xC3, 0xFC, 0x63, 0x8C, 0x33, 0x8E, 0x73, 0x8F, 0xE1, 0xFE, 0x70,
  0xCE, 0x19, 0x83, 0x30, 0xEF, 0xF9, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0xF1,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x87, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x67, 0x9C, 0x73, 0x8E, 0x61,
  0xCC, 0x3B, 0x87, 0x70, 0xCC, 0x39, 0x87, 0x71, 0xCF, 0xF1, 0xF8, 0x00,
  0x0F, 0xF1, 0xFF, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3F, 0xC3, 0xF8,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xC3, 0xFC, 0xE1, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x0E, 0xC1, 0x98, 0x73, 0x8E, 0x71, 0x87, 0xF0, 0xFE,
  0x00, 0x1C, 0x31, 0x87, 0x18, 0x73, 0x86, 0x38, 0x63, 0x0E, 0x3F, 0xE7,
  0xFC, 0x70, 0xC6, 0x0C, 0x61, 0xCE, 0x18, 0xE1, 0x8C, 0x38, 0x1F, 0xF1,
  0xFF, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x84,
  0x38, 0xFF, 0x07, 0xE0, 0x1C, 0x78, 0xC3, 0x06, 0x38, 0x73, 0x83, 0xB8,
  0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x77, 0x03, 0xB8, 0x18, 0xE0, 0xC7, 0x0E,
  0x18, 0x70, 0xE0, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x1C, 0x0C, 0x07, 0xFF, 0xFC, 0x0E, 0x38, 0x71, 0xC3, 0x9E,
  0x3C, 0xE1, 0xEF, 0x0D, 0x58, 0xCE, 0xC6, 0x66, 0x33, 0x71, 0x83, 0x1C,
  0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x70, 0x18, 0x31, 0xC3, 0x1C, 0x73, 0xC6,
  0x36, 0x63, 0x66, 0x36, 0x67, 0x6C, 0x63, 0xC6, 0x3C, 0x63, 0xCE, 0x3C,
  0xC1, 0x8C, 0x18, 0x0F, 0x87, 0xF3, 0x9D, 0xC3, 0x60, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0x9C, 0xFF, 0x1F, 0x00, 0x1F, 0xC1, 0xFE,
  0x18, 0xE1, 0x87, 0x38, 0x63, 0x86, 0x30, 0xE3, 0xFC, 0x7F, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0x9D, 0xC3, 0x60,
  0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0x9C, 0xFF, 0x1F, 0x03,
  0x00, 0xE0, 0x1E, 0x01, 0x80, 0x1F, 0x83, 0xF8, 0x63, 0x9C, 0x33, 0x86,
  0x61, 0xCC, 0x71, 0xFC, 0x7F, 0x0E, 0x61, 0x8E, 0x31, 0xCE, 0x19, 0xC3,
  0x80, 0x0F, 0xE3, 0xFC, 0x60, 0x9C, 0x03, 0x80, 0x38, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x20, 0xCF, 0xF8, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x66, 0x1C, 0xC3, 0xB8, 0x67, 0x0C,
  0xC3, 0x98, 0x77, 0x0C, 0xE1, 0x98, 0x73, 0x0E, 0x63, 0x8F, 0xF0, 0xFC,
  0x00, 0xE0, 0xFC, 0x1B, 0x87, 0x70, 0xCE, 0x39, 0xC6, 0x39, 0xC7, 0x30,
  0x66, 0x0D, 0x81, 0xB0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x18, 0x39, 0xC1,
  0x8C, 0x0C, 0x60, 0x63, 0x07, 0x1B, 0x31, 0x99, 0x8D, 0xEC, 0x6B, 0xC3,
  0xDE, 0x14, 0xF0, 0xE7, 0x0E, 0x38, 0x71, 0xC0, 0x0C, 0x1C, 0x38, 0xE0,
  0x67, 0x01, 0x98, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x37, 0x01, 0xCC, 0x0E, 0x30, 0x70, 0xE3, 0x83, 0x80, 0xE0, 0xEC, 0x19,
  0x87, 0x31, 0xC7, 0x30, 0xEC, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0x8F, 0xF8, 0x07, 0xE0, 0xFC, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0xF8, 0x7E, 0x00, 0xCC, 0xCE, 0xEE, 0xEE, 0x66, 0x66,
  0x66, 0x77, 0x77, 0x73, 0x0F, 0xC3, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x0F, 0xC3, 0xF0, 0x07, 0x01, 0xC0, 0xF8, 0x7E, 0x39, 0x9C,
  0x7E, 0x1D, 0x02, 0x7F, 0xFF, 0xFC, 0xCE, 0x71, 0x07, 0x0F, 0xF7, 0x99,
  0x86, 0xE1, 0xB0, 0xEC, 0x3B, 0x0C, 0xC7, 0x3F, 0xC7, 0xF8, 0x02, 0x03,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0xC3, 0xFC, 0xF7, 0x30, 0xCC, 0x37, 0x0D,
  0xC3, 0x61, 0xD8, 0xEF, 0xF3, 0xF8, 0x07, 0x87, 0xF3, 0xC9, 0xC0, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0xC3, 0xF0, 0x00, 0x20, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x0F, 0x87, 0xF3, 0xCE, 0x61, 0x9C, 0x33, 0x0E, 0x61,
  0xCC, 0x31, 0x8E, 0x3F, 0xC3, 0xFC, 0x0F, 0x0F, 0xE7, 0x9D, 0x87, 0xE1,
  0xBF, 0xEF, 0xE3, 0x00, 0xE0, 0x3F, 0xC7, 0xF0, 0x00, 0x20, 0x07, 0xC0,
  0x7E, 0x07, 0x00, 0x38, 0x01, 0x80, 0x7F, 0xC3, 0xFE, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x05,
  0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x7F, 0x1E, 0x71, 0xC6, 0x38,
  0x63, 0x0E, 0x30, 0xE3, 0x0C, 0x3F, 0xC1, 0xFC, 0x01, 0xC0, 0x18, 0x67,
  0x8F, 0xF0, 0x3C, 0x00, 0x02, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x07, 0xC3,
  0xFC, 0xE7, 0x30, 0xCC, 0x37, 0x1D, 0xC7, 0x61, 0x98, 0x66, 0x3B, 0x8E,
  0x0C, 0x38, 0x70, 0x40, 0x00, 0xBE, 0x7C, 0x18, 0x70, 0xE1, 0x83, 0x06,
  0x0F, 0x9F, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x0D, 0xE3, 0xF8, 0x1E, 0x00, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x81, 0x18, 0xE3, 0x9C, 0x3B, 0x83, 0x70, 0x3E, 0x03, 0x60,
  0x77, 0x07, 0x38, 0x63, 0x8E, 0x1C, 0xFF, 0xE3, 0x8E, 0x30, 0xC7, 0x1C,
  0x61, 0x8E, 0x38, 0xE3, 0xF7, 0xC0, 0x0C, 0xC7, 0xFC, 0xD9, 0x9B, 0x36,
  0x66, 0xCD, 0x9B, 0x33, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0x00, 0x07, 0x07,
  0xF3, 0x9C, 0xE3, 0x30, 0xCC, 0x77, 0x1D, 0xC6, 0x61, 0x98, 0x6E, 0x38,
  0x0E, 0x1F, 0xDE, 0xEC, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xE7, 0x7F, 0x9F,
  0x00, 0x07, 0x81, 0xFE, 0x1C, 0xE1, 0x86, 0x18, 0x73, 0x86, 0x38, 0x63,
  0x0E, 0x31, 0xC3, 0xF8, 0x7F, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x87, 0xF3, 0x9D, 0xC6, 0xE1, 0xB8, 0xEC, 0x3B, 0x0C, 0xE3, 0x3F,
  0xC7, 0xF0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x07, 0x8F, 0xF3, 0xF8, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x07, 0x87, 0xF1,
  0xCC, 0xE0, 0x1C, 0x07, 0xC0, 0x78, 0x06, 0x41, 0x9F, 0xEF, 0xF0, 0x04,
  0x0C, 0x06, 0x07, 0x0F, 0xFF, 0xF8, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x07, 0xE1, 0xF0, 0x71, 0xD8, 0x66, 0x19, 0x8E, 0xE3, 0xB8, 0xCC, 0x33,
  0x9C, 0xFF, 0x1E, 0xE0, 0xC3, 0xE1, 0xF0, 0xDC, 0xEE, 0x67, 0x73, 0xF0,
  0xF0, 0x78, 0x38, 0x00, 0xE0, 0x78, 0x1B, 0x33, 0x66, 0x6D, 0xD9, 0xAB,
  0x3D, 0x67, 0x38, 0xE7, 0x18, 0xC0, 0x1C, 0x70, 0xCE, 0x0F, 0xC0, 0x78,
  0x07, 0x00, 0x78, 0x0F, 0x81, 0x9C, 0x39, 0xCF, 0x0E, 0x0C, 0x38, 0x71,
  0xC3, 0x8C, 0x1C, 0xE0, 0xE6, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x9C, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0xE3, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0x9F, 0xF0, 0x01, 0xE0,
  0x7C, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x0F, 0x03,
  0xC0, 0x1C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xF8,
  0x0F, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0xE1,
  0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x00, 0x07, 0x01, 0xF0, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3C, 0x07, 0x81,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x81, 0xF0, 0x78, 0x00,
  0x18, 0x4F, 0xDD, 0xBF, 0x61, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 14, 11, 3, -14 },
  { 12, 7, 6, 11, 4, -15 },
  { 18, 12, 14, 11, 0, -14 },
  { 39, 11, 18, 11, 0, -16 },
  { 64, 14, 14, 11, -1, -14 },
  { 89, 11, 14, 11, 0, -14 },
  { 109, 3, 6, 11, 6, -15 },
  { 112, 9, 20, 11, 2, -16 },
  { 135, 9, 20, 11, 0, -16 },
  { 158, 9, 9, 11, 2, -14 },
  { 169, 10, 10, 11, 1, -11 },
  { 182, 6, 7, 11, 1, -4 },
  { 188, 6, 2, 11, 3, -7 },
  { 190, 4, 4, 11, 3, -4 },
  { 192, 13, 20, 11, -1, -16 },
  { 225, 10, 14, 11, 1, -14 },
  { 243, 9, 14, 11, 1, -14 },
  { 259, 11, 14, 11, 0, -14 },
  { 279, 11, 14, 11, 0, -14 },
  { 299, 11, 14, 11, 0, -14 },
  { 319, 12, 14, 11, 0, -14 },
  { 340, 11, 14, 11, 1, -14 },
  { 360, 10, 14, 11, 2, -14 },
  { 378, 10, 14, 11, 1, -14 },
  { 396, 10, 14, 11, 1, -14 },
  { 414, 5, 11, 11, 3, -11 },
  { 421, 7, 14, 11, 1, -11 },
  { 434, 10, 9, 11, 1, -10 },
  { 446, 11, 6, 11, 0, -9 },
  { 455, 11, 9, 11, 0, -10 },
  { 468, 8, 14, 11, 3, -14 },
  { 482, 12, 17, 11, 0, -14 },
  { 508, 11, 14, 11, -1, -14 },
  { 528, 11, 14, 11, 0, -14 },
  { 548, 11, 14, 11, 1, -14 },
  { 568, 11, 14, 11, 0, -14 },
  { 588, 12, 14, 11, 0, -14 },
  { 609, 11, 14, 11, 1, -14 },
  { 629, 11, 14, 11, 1, -14 },
  { 649, 12, 14, 11, 0, -14 },
  { 670, 12, 14, 11, 0, -14 },
  { 691, 12, 14, 11, 0, -14 },
  { 712, 13, 14, 11, 0, -14 },
  { 735, 9, 14, 11, 0, -14 },
  { 751, 13, 14, 11, -1, -14 },
  { 774, 12, 14, 11, 0, -14 },
  { 795, 10, 14, 11, 1, -14 },
  { 813, 12, 14, 11, 0, -14 },
  { 834, 10, 18, 11, 1, -14 },
  { 857, 11, 14, 11, 0, -14 },
  { 877, 11, 14, 11, 0, -14 },
  { 897, 11, 14, 11, 2, -14 },
  { 917, 11, 14, 11, 1, -14 },
  { 937, 11, 14, 11, 2, -14 },
  { 957, 13, 14, 11, 0, -14 },
  { 980, 14, 14, 11, -1, -14 },
  { 1005, 11, 14, 11, 2, -14 },
  { 1025, 12, 14, 11, 0, -14 },
  { 1046, 11, 20, 11, 1, -16 },
  { 1074, 4, 20, 11, 4, -16 },
  { 1084, 10, 20, 11, 0, -16 },
  { 1109, 10, 8, 11, 1, -14 },
  { 1119, 11, 2, 11, -2, 2 },
  { 1122, 4, 4, 11, 5, -15 },
  { 1124, 10, 11, 11, 1, -11 },
  { 1138, 10, 16, 11, 0, -16 },
  { 1158, 10, 11, 11, 1, -11 },
  { 1172, 11, 16, 11, 1, -16 },
  { 1194, 10, 11, 11, 1, -11 },
  { 1208, 13, 20, 11, -1, -16 },
  { 1241, 12, 15, 11, -1, -11 },
  { 1264, 10, 16, 11, 0, -16 },
  { 1284, 7, 16, 11, 2, -16 },
  { 1298, 11, 20, 11, -1, -16 },
  { 1326, 12, 16, 11, 0, -16 },
  { 1350, 6, 15, 11, 3, -15 },
  { 1362, 11, 11, 11, 0, -11 },
  { 1378, 10, 11, 11, 0, -11 },
  { 1392, 9, 11, 11, 1, -11 },
  { 1405, 12, 15, 11, -1, -11 },
  { 1428, 10, 15, 11, 1, -11 },
  { 1447, 10, 11, 11, 1, -11 },
  { 1461, 10, 11, 11, 0, -11 },
  { 1475, 9, 14, 11, 2, -14 },
  { 1491, 10, 10, 11, 1, -10 },
  { 1504, 9, 10, 11, 2, -10 },
  { 1516, 11, 10, 11, 1, -10 },
  { 1530, 12, 10, 11, -1, -10 },
  { 1545, 13, 14, 11, -2, -10 },
  { 1568, 11, 10, 11, 0, -10 },
  { 1582, 11, 20, 11, 1, -16 },
  { 1610, 7, 20, 11, 2, -16 },
  { 1628, 11, 20, 11, -1, -16 },
  { 1656, 11, 4, 11, 0, -8 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC20PT7B_H_
