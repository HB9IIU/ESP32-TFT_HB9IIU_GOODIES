#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC59PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F,
  0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE, 0x1F, 0xE7,
  0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x10, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE1,
  0xFC, 0x01, 0xFF, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x08, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x18, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x7E,
  0x00, 0x03, 0xE1, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x03,
  0xE1, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE3, 0xF0, 0x00, 0x03, 0xFF, 0xE7,
  0xE0, 0x00, 0x03, 0xFF, 0xCF, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x00,
  0x00, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x00, 0x01, 0xF8, 0xFF,
  0x00, 0x00, 0x01, 0xF1, 0xFF, 0x80, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x00,
  0x07, 0xC7, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0xCF, 0xC0, 0x00, 0x1F, 0x8F,
  0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x01, 0xF8,
  0x1E, 0x07, 0x80, 0x03, 0xF0, 0x1E, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x07, 0xA0, 0x3F, 0xF0,
  0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xF0, 0x7E, 0x1F, 0xEF, 0xE1,
  0xF8, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x1F, 0xEF, 0xE3, 0xF8, 0x1F, 0xDF,
  0x87, 0xE0, 0x1F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0xF0,
  0x7F, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xE7, 0xF0, 0x1F,
  0xFF, 0x87, 0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x0E, 0x0F, 0xC0, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F,
  0x1F, 0x3F, 0x8F, 0xFB, 0xCF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xCF, 0xF0,
  0x07, 0xF8, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x20,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFC, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x04, 0x07, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x80, 0xFE, 0x7F, 0x07, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC,
  0x7F, 0x8F, 0xE3, 0xF8, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x9F, 0xC3,
  0xF8, 0x7F, 0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x07, 0x83, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF3, 0xF8, 0x01,
  0xF0, 0xFE, 0x00, 0x70, 0x3F, 0x80, 0x10, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0x87, 0xFE, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x20, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x3F, 0xE0, 0x3F, 0x81,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x04, 0x00, 0x07, 0xFC, 0x03, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x60, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0xC0, 0x0F, 0xF0,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFB,
  0xF8, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0x0C, 0x00, 0xFF,
  0x10, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x03, 0xFF, 0xE0, 0xFC, 0x03, 0xFF,
  0xF8, 0x7F, 0x03, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xFF, 0x87, 0xE0, 0xFF,
  0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0xF0, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F, 0x0F,
  0xE0, 0x7F, 0x0F, 0x83, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x07, 0xE1, 0xF8,
  0x7F, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x3F, 0x81, 0xFC,
  0x1F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF8, 0xFE, 0x07, 0xC1, 0xFF,
  0xFF, 0x01, 0xF8, 0x3F, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0x80,
  0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xEF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x1C, 0x03, 0xFF, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3C, 0x03, 0xFE, 0x00, 0x08, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xFB,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x00, 0x7F, 0x80, 0x1C,
  0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xEF, 0x80,
  0x1F, 0x7C, 0x1F, 0xFC, 0x00, 0xFB, 0xE1, 0xF7, 0xE0, 0x0F, 0xDF, 0x0F,
  0xBE, 0x00, 0x7E, 0xF8, 0xF9, 0xF0, 0x03, 0xE7, 0xC7, 0xDF, 0x80, 0x3F,
  0x3E, 0x7C, 0xFC, 0x01, 0xF9, 0xF3, 0xE7, 0xE0, 0x0F, 0xCF, 0xBE, 0x3F,
  0x00, 0xFC, 0x3D, 0xF3, 0xF0, 0x07, 0xE1, 0xFF, 0x1F, 0x80, 0x3F, 0x0F,
  0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x87, 0xE0, 0x1F, 0x83, 0xF8, 0x7F, 0x00,
  0xFC, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xC0, 0x1F, 0xBE, 0x01, 0xF8, 0x03, 0xFB, 0xE0, 0x1F, 0x80, 0x3F, 0xBF,
  0x03, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0x80, 0x3F, 0x1F, 0x03, 0xF0, 0x07,
  0xF1, 0xF0, 0x3F, 0x00, 0x7F, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x7F,
  0x00, 0x7E, 0x0F, 0x87, 0xE0, 0x0F, 0xE0, 0xF8, 0x7E, 0x00, 0xFE, 0x0F,
  0xCF, 0xE0, 0x0F, 0xC0, 0xFC, 0xFE, 0x00, 0xFC, 0x07, 0xCF, 0xC0, 0x1F,
  0xC0, 0x7C, 0xFC, 0x01, 0xFC, 0x07, 0xCF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x03, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x38,
  0x00, 0xFF, 0x00, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0x80, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xA0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0xC1, 0xF8, 0x07, 0xE1, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xF0, 0xFC, 0x01,
  0xF8, 0xFF, 0x87, 0xE0, 0x0F, 0xC7, 0xFC, 0x3F, 0x00, 0xFC, 0x7D, 0xE3,
  0xF0, 0x07, 0xE3, 0xEF, 0x1F, 0x80, 0x3F, 0x3E, 0x78, 0xFC, 0x01, 0xF9,
  0xE3, 0xC7, 0xC0, 0x0F, 0x9F, 0x1E, 0x7E, 0x00, 0xFC, 0xF0, 0xFB, 0xF0,
  0x07, 0xEF, 0x87, 0xDF, 0x80, 0x3F, 0x78, 0x3E, 0xF8, 0x01, 0xF7, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x9F, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x0F, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x80, 0x10, 0x00, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F,
  0xC3, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0x83, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x00,
  0x7F, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x87, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x04, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x0E, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xDF, 0xC0, 0x01, 0xFF, 0xC3, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xFF, 0x1F, 0xDF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xE8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x06, 0x03, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x03, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE1, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x01, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x18, 0x01, 0xFE, 0x00, 0x0F,
  0x83, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x19, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xF9, 0xFC,
  0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x01, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD,
  0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0x80, 0x00, 0x60, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x38, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0x00, 0x7F, 0x80, 0x08, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x00,
  0x3F, 0xC0, 0x70, 0x01, 0xFF, 0x03, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x01, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x9F, 0xC0, 0x7F, 0xF0, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x0F,
  0x81, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0xE0, 0xFC, 0x1F,
  0x87, 0xF8, 0x7E, 0x07, 0xE3, 0xFF, 0x1F, 0x81, 0xF0, 0xFF, 0xC7, 0xC0,
  0x7C, 0x7D, 0xF3, 0xF0, 0x1F, 0x1F, 0x7C, 0xFC, 0x07, 0xCF, 0x9F, 0x3E,
  0x03, 0xF3, 0xE7, 0xDF, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0x7C, 0x7D,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0x83, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x30, 0x07, 0xFE, 0x00, 0x7C, 0x1F, 0xFE, 0x01,
  0xF8, 0x7F, 0xFF, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xE1,
  0xF8, 0x03, 0xFF, 0x80, 0x70, 0x01, 0xFC, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 17, 42, 33, 9, -41 },
  { 91, 22, 18, 33, 11, -45 },
  { 141, 35, 41, 33, 0, -41 },
  { 321, 32, 52, 33, 1, -46 },
  { 529, 40, 43, 33, -2, -42 },
  { 744, 31, 43, 33, 1, -42 },
  { 911, 11, 19, 33, 16, -45 },
  { 938, 26, 58, 33, 7, -47 },
  { 1127, 26, 58, 33, 1, -47 },
  { 1316, 27, 26, 33, 6, -41 },
  { 1404, 29, 29, 33, 2, -32 },
  { 1510, 16, 21, 33, 4, -11 },
  { 1552, 19, 7, 33, 7, -20 },
  { 1569, 11, 12, 33, 9, -11 },
  { 1586, 38, 57, 33, -3, -46 },
  { 1857, 31, 43, 33, 2, -42 },
  { 2024, 26, 41, 33, 2, -41 },
  { 2158, 32, 42, 33, 1, -42 },
  { 2326, 32, 43, 33, 0, -42 },
  { 2498, 33, 41, 33, 0, -41 },
  { 2668, 34, 42, 33, 0, -41 },
  { 2847, 31, 42, 33, 3, -41 },
  { 3010, 31, 41, 33, 6, -41 },
  { 3169, 31, 43, 33, 2, -42 },
  { 3336, 31, 42, 33, 2, -42 },
  { 3499, 15, 32, 33, 9, -31 },
  { 3559, 20, 41, 33, 4, -31 },
  { 3662, 30, 28, 33, 3, -31 },
  { 3767, 32, 19, 33, 1, -27 },
  { 3843, 30, 28, 33, 1, -31 },
  { 3948, 24, 43, 33, 8, -42 },
  { 4077, 34, 51, 33, 1, -42 },
  { 4294, 32, 41, 33, -3, -41 },
  { 4458, 33, 41, 33, 0, -41 },
  { 4628, 32, 43, 33, 3, -42 },
  { 4800, 32, 41, 33, 0, -41 },
  { 4964, 34, 41, 33, 1, -41 },
  { 5139, 34, 41, 33, 2, -41 },
  { 5314, 32, 43, 33, 3, -42 },
  { 5486, 37, 41, 33, -1, -41 },
  { 5676, 34, 41, 33, 1, -41 },
  { 5851, 33, 42, 33, 1, -41 },
  { 6025, 37, 41, 33, 0, -41 },
  { 6215, 26, 41, 33, 1, -41 },
  { 6349, 37, 41, 33, -2, -41 },
  { 6539, 36, 41, 33, 0, -41 },
  { 6724, 31, 43, 33, 2, -42 },
  { 6891, 34, 41, 33, 0, -41 },
  { 7066, 31, 53, 33, 2, -42 },
  { 7272, 33, 41, 33, 0, -41 },
  { 7442, 34, 43, 33, 0, -42 },
  { 7625, 31, 41, 33, 6, -41 },
  { 7784, 34, 42, 33, 2, -41 },
  { 7963, 32, 41, 33, 6, -41 },
  { 8127, 37, 41, 33, 1, -41 },
  { 8317, 40, 41, 33, -2, -41 },
  { 8522, 31, 41, 33, 7, -41 },
  { 8681, 35, 41, 33, 0, -41 },
  { 8861, 31, 57, 33, 4, -46 },
  { 9082, 13, 57, 33, 11, -46 },
  { 9175, 31, 57, 33, -1, -46 },
  { 9396, 30, 23, 33, 3, -41 },
  { 9483, 31, 6, 33, -5, 5 },
  { 9507, 13, 12, 33, 14, -46 },
  { 9527, 30, 33, 33, 2, -32 },
  { 9651, 30, 47, 33, 1, -46 },
  { 9828, 30, 33, 33, 2, -32 },
  { 9952, 34, 47, 33, 2, -46 },
  { 10152, 30, 33, 33, 2, -32 },
  { 10276, 41, 57, 33, -4, -46 },
  { 10569, 35, 43, 33, -2, -32 },
  { 10758, 30, 46, 33, 0, -46 },
  { 10931, 22, 47, 33, 5, -46 },
  { 11061, 33, 57, 33, -2, -46 },
  { 11297, 34, 46, 33, 1, -46 },
  { 11493, 19, 46, 33, 8, -45 },
  { 11603, 33, 31, 33, -1, -31 },
  { 11731, 29, 32, 33, 1, -32 },
  { 11847, 29, 33, 33, 2, -32 },
  { 11967, 33, 43, 33, -2, -32 },
  { 12145, 31, 43, 33, 2, -32 },
  { 12312, 31, 32, 33, 2, -32 },
  { 12436, 30, 33, 33, 1, -32 },
  { 12560, 27, 41, 33, 5, -40 },
  { 12699, 29, 32, 33, 3, -31 },
  { 12815, 29, 31, 33, 5, -31 },
  { 12928, 34, 31, 33, 2, -31 },
  { 13060, 36, 31, 33, -2, -31 },
  { 13200, 39, 42, 33, -5, -31 },
  { 13405, 31, 31, 33, 1, -31 },
  { 13526, 32, 57, 33, 4, -46 },
  { 13754, 21, 57, 33, 6, -46 },
  { 13904, 31, 57, 33, -2, -46 },
  { 14125, 31, 11, 33, 1, -23 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic59pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC59PT7B_H_
