#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC38PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x80, 0x00, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x7B,
  0xE3, 0xEF, 0x8F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E, 0x38, 0x38,
  0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x00, 0x1E, 0x1E, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x1E, 0x0F,
  0x80, 0x20, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x86, 0x00, 0xF8, 0x7C, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xC1, 0xFE, 0x03, 0xC0,
  0xE7, 0x03, 0xC0, 0xE3, 0x81, 0xC0, 0x71, 0xC1, 0xC0, 0x38, 0xE1, 0xC0,
  0x3C, 0x71, 0xE0, 0x1C, 0x79, 0xE0, 0x0F, 0x39, 0xE0, 0x03, 0xFD, 0xE0,
  0x01, 0xFC, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF1,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xF8, 0x00, 0x73, 0xDC, 0x00, 0x73,
  0xCF, 0x00, 0x71, 0xC7, 0x00, 0x78, 0xE3, 0x80, 0x78, 0x71, 0xC0, 0x78,
  0x38, 0xE0, 0x38, 0x1C, 0xF0, 0x38, 0x0F, 0xF0, 0x38, 0x07, 0xF0, 0x3C,
  0x01, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xC0,
  0x78, 0x3C, 0x07, 0x87, 0xC0, 0x7C, 0x78, 0x03, 0xDF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x0F, 0x0F, 0xF0, 0xF1, 0xFF, 0x8F, 0x3E, 0x7D,
  0xE3, 0xC3, 0xDE, 0x78, 0x3F, 0xC7, 0x81, 0xFC, 0xF8, 0x1F, 0x8F, 0x80,
  0xF8, 0xF8, 0x1F, 0x87, 0xC7, 0xFC, 0x7F, 0xFB, 0xC3, 0xFF, 0x3C, 0x1F,
  0xC3, 0xE0, 0x7D, 0xF7, 0xDF, 0xFB, 0xEF, 0xBC, 0xF3, 0xCE, 0x38, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x08, 0x38, 0x27, 0x1C, 0x77,
  0xEE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xDE,
  0x03, 0xEF, 0x83, 0xE7, 0xE1, 0xF1, 0xF0, 0x70, 0xF0, 0x08, 0x20, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x03, 0xE1,
  0xF8, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x1E, 0x0F, 0x07, 0xCF, 0xE3, 0xE0,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x38, 0xFB, 0xFF, 0xFF,
  0xDF, 0xBE, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x3E,
  0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xF0,
  0x0F, 0xBC, 0x79, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xF7, 0x8F,
  0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x01,
  0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0x78, 0x1E, 0x7C, 0x04,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3E, 0x1F, 0x81, 0xC0, 0x7C, 0x08, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1C, 0x1F, 0x00, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE1, 0x80,
  0x3F, 0x0F, 0x8F, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3C,
  0x01, 0xF1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x3F,
  0x07, 0xEF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xDF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0xFE, 0x1F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x1F,
  0x87, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7E, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF3, 0xF8, 0x3E, 0x0F,
  0x87, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xC3, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F,
  0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x01,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xF3, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3,
  0xE0, 0x20, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00,
  0x78, 0x07, 0x80, 0x7C, 0x1F, 0xC0, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFF, 0x38, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x07, 0xF9, 0xE0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF0, 0xFF, 0xE7, 0x8F, 0x8F,
  0x3C, 0xF8, 0x79, 0xC7, 0x83, 0xDE, 0x3C, 0x3C, 0xF1, 0xE1, 0xE7, 0x9E,
  0x0F, 0x3C, 0xF0, 0x79, 0xE7, 0x87, 0xCF, 0x1E, 0x3C, 0x78, 0xF9, 0xE3,
  0xC7, 0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0x7F, 0x87, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xF3, 0xC0,
  0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1,
  0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xE0, 0x0F,
  0x1F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xC0, 0xFC, 0x1E, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x0E, 0x07, 0xE0, 0x10, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x08, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7E, 0xFF, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x8F, 0x00, 0xF8, 0x78, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07,
  0xE1, 0xF0, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xF0, 0xE0, 0xFC, 0x02, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0,
  0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F,
  0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x7C,
  0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0x81,
  0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x20, 0x0F,
  0x80, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7C,
  0x03, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0xEE, 0x07, 0xF0, 0xFE, 0x07, 0xF1, 0xDE, 0x07, 0x71, 0xDC, 0x0F,
  0x3B, 0x9C, 0x0F, 0x3B, 0xBC, 0x0F, 0x3F, 0x3C, 0x0E, 0x3F, 0x3C, 0x1E,
  0x3E, 0x38, 0x1E, 0x3E, 0x78, 0x1E, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3C, 0x1F, 0x80, 0xF8, 0x3F,
  0x01, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x83, 0xFC, 0x1F, 0x07, 0xB8,
  0x3C, 0x0F, 0x78, 0x78, 0x1E, 0xF0, 0xF0, 0x7C, 0xE3, 0xE0, 0xF1, 0xC7,
  0x81, 0xE3, 0xCF, 0x03, 0xC7, 0x9E, 0x0F, 0x87, 0x3C, 0x1E, 0x0E, 0xF0,
  0x3C, 0x1F, 0xE0, 0x78, 0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xC0, 0x7E, 0x07,
  0x80, 0xFC, 0x0F, 0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0xF0,
  0x07, 0x81, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF1, 0xF0,
  0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8,
  0x7C, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xE7, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E,
  0x0F, 0x01, 0xF8, 0x7C, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF1,
  0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0,
  0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x1E, 0x03, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x03,
  0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x78, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0x70, 0x1F, 0x00, 0x40, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0x00, 0xFC, 0x1F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x07,
  0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80,
  0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07,
  0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x1F, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x3C, 0x78, 0x1E, 0x3C,
  0x78, 0x1E, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0xFC, 0xF0, 0x3C, 0xFC,
  0xF0, 0x3D, 0xDC, 0xF0, 0x39, 0xDC, 0xE0, 0x3B, 0x8E, 0xE0, 0x7B, 0x8F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xFB, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xF7, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xFF, 0x00,
  0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x78,
  0x3E, 0x07, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x3C, 0xF8, 0x03,
  0xDF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F,
  0x87, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xFF, 0x80, 0x3E, 0x70,
  0x07, 0x84, 0x00, 0x40, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x20, 0x3C, 0x3F, 0x1F, 0xC3, 0xF8, 0x78, 0x18, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xE3, 0xF0,
  0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0xF8,
  0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0xC1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x78,
  0x00, 0x10, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x83, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x7C,
  0x3C, 0x07, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x10, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0x3E, 0x0F,
  0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x01,
  0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xF7, 0x80, 0x7F, 0x9E, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0x3F, 0x3F, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x08, 0xFF, 0xBE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x02, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0,
  0x1F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1E, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x06, 0x03, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x3E, 0x00, 0x00, 0x60,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xC3, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7E, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3C, 0x7E,
  0x03, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC0, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0B, 0xFF, 0x9F, 0xFC,
  0x7F, 0xF1, 0xFF, 0x00, 0x03, 0xF9, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC3, 0xEF, 0xDF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xC7, 0x87,
  0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x3E,
  0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0,
  0x78, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x7C,
  0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x7D, 0xE0,
  0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xE0,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x81, 0xF8, 0x78, 0x1F, 0x87, 0xC1, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC1, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xE1, 0xF8, 0x08, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0xF8, 0x04, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xC3, 0x00, 0xF8, 0x7E, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1F, 0xE7, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x03, 0xCF,
  0x80, 0x7B, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x78, 0x79, 0xE1, 0xE3, 0xC7, 0x8F,
  0x8F, 0x1E, 0x3E, 0x3C, 0x79, 0xF9, 0xE1, 0xE7, 0xE7, 0x87, 0x3F, 0x9C,
  0x1C, 0xEE, 0xF0, 0x77, 0xBB, 0xC1, 0xDC, 0xEE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0x80, 0x1E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x01,
  0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0x07, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0xC1, 0xFC, 0x0F, 0x3F, 0xF1, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 11, 27, 21, 6, -26 },
  { 39, 14, 12, 21, 7, -29 },
  { 60, 23, 26, 21, 0, -26 },
  { 135, 20, 33, 21, 1, -29 },
  { 218, 25, 28, 21, -1, -27 },
  { 306, 20, 27, 21, 0, -27 },
  { 374, 6, 12, 21, 11, -29 },
  { 383, 17, 37, 21, 4, -30 },
  { 462, 17, 37, 21, 0, -30 },
  { 541, 17, 16, 21, 4, -26 },
  { 575, 19, 19, 21, 1, -21 },
  { 621, 10, 13, 21, 3, -7 },
  { 638, 12, 4, 21, 5, -13 },
  { 644, 7, 8, 21, 6, -7 },
  { 651, 25, 37, 21, -2, -30 },
  { 767, 19, 28, 21, 2, -27 },
  { 834, 17, 26, 21, 1, -26 },
  { 890, 21, 27, 21, 0, -27 },
  { 961, 21, 28, 21, 0, -27 },
  { 1035, 21, 26, 21, 0, -26 },
  { 1104, 22, 27, 21, 0, -26 },
  { 1179, 20, 28, 21, 2, -27 },
  { 1249, 20, 26, 21, 4, -26 },
  { 1314, 20, 28, 21, 1, -27 },
  { 1384, 20, 27, 21, 1, -27 },
  { 1452, 10, 21, 21, 6, -20 },
  { 1479, 13, 26, 21, 3, -20 },
  { 1522, 19, 18, 21, 2, -20 },
  { 1565, 20, 12, 21, 1, -17 },
  { 1595, 19, 18, 21, 1, -20 },
  { 1638, 16, 28, 21, 5, -27 },
  { 1694, 21, 33, 21, 1, -27 },
  { 1781, 21, 26, 21, -2, -26 },
  { 1850, 21, 27, 21, 0, -27 },
  { 1921, 21, 28, 21, 2, -27 },
  { 1995, 21, 27, 21, 0, -27 },
  { 2066, 22, 26, 21, 1, -26 },
  { 2138, 22, 26, 21, 1, -26 },
  { 2210, 20, 28, 21, 2, -27 },
  { 2280, 23, 26, 21, 0, -26 },
  { 2355, 22, 26, 21, 0, -26 },
  { 2427, 22, 27, 21, 0, -26 },
  { 2502, 24, 26, 21, 0, -26 },
  { 2580, 17, 26, 21, 0, -26 },
  { 2636, 24, 26, 21, -1, -26 },
  { 2714, 23, 26, 21, 0, -26 },
  { 2789, 20, 28, 21, 1, -27 },
  { 2859, 22, 27, 21, 0, -27 },
  { 2934, 20, 34, 21, 1, -27 },
  { 3019, 21, 27, 21, 0, -27 },
  { 3090, 22, 28, 21, 0, -27 },
  { 3167, 20, 26, 21, 4, -26 },
  { 3232, 22, 27, 21, 1, -26 },
  { 3307, 21, 26, 21, 4, -26 },
  { 3376, 24, 26, 21, 0, -26 },
  { 3454, 25, 26, 21, -1, -26 },
  { 3536, 20, 26, 21, 5, -26 },
  { 3601, 23, 26, 21, 0, -26 },
  { 3676, 21, 37, 21, 2, -30 },
  { 3774, 8, 37, 21, 7, -30 },
  { 3811, 20, 37, 21, -1, -30 },
  { 3904, 19, 15, 21, 2, -26 },
  { 3940, 20, 4, 21, -3, 3 },
  { 3950, 9, 7, 21, 9, -29 },
  { 3958, 20, 20, 21, 1, -20 },
  { 4008, 20, 31, 21, 0, -30 },
  { 4086, 19, 20, 21, 2, -20 },
  { 4134, 22, 30, 21, 1, -30 },
  { 4217, 18, 21, 21, 2, -20 },
  { 4265, 27, 36, 21, -3, -29 },
  { 4387, 22, 27, 21, -1, -20 },
  { 4462, 19, 30, 21, 0, -30 },
  { 4534, 14, 30, 21, 3, -30 },
  { 4587, 22, 37, 21, -2, -30 },
  { 4689, 21, 30, 21, 1, -30 },
  { 4768, 13, 29, 21, 5, -29 },
  { 4816, 22, 20, 21, -1, -20 },
  { 4871, 19, 20, 21, 1, -20 },
  { 4919, 19, 21, 21, 1, -20 },
  { 4969, 21, 27, 21, -1, -20 },
  { 5040, 19, 27, 21, 2, -20 },
  { 5105, 19, 20, 21, 2, -20 },
  { 5153, 19, 21, 21, 1, -20 },
  { 5203, 18, 26, 21, 3, -26 },
  { 5262, 19, 20, 21, 2, -20 },
  { 5310, 19, 20, 21, 3, -20 },
  { 5358, 22, 20, 21, 1, -20 },
  { 5413, 23, 20, 21, -1, -20 },
  { 5471, 25, 27, 21, -3, -20 },
  { 5556, 20, 20, 21, 1, -20 },
  { 5606, 20, 37, 21, 3, -30 },
  { 5699, 14, 37, 21, 4, -30 },
  { 5764, 20, 37, 21, -1, -30 },
  { 5857, 20, 7, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC38PT7B_H_
