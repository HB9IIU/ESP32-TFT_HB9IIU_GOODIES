#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC54PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8,
  0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0x06,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0x00, 0x01, 0xFC, 0x0E, 0x00, 0x1F, 0xE0, 0x7E, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x08,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x0F,
  0x87, 0x80, 0xFC, 0x00, 0x7C, 0x3C, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x7C,
  0x00, 0x1E, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC7, 0xC0, 0x00, 0x7C, 0x3C, 0x7E, 0x00, 0x03, 0xE3, 0xE3, 0xE0, 0x00,
  0x0F, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0x3E,
  0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xFE,
  0x00, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0x01, 0xF1, 0xFF, 0xC0, 0x00, 0x1F,
  0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x87, 0x80,
  0x00, 0xF8, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC1, 0xE0, 0x00, 0xF8, 0x3E,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0xFC, 0x0F, 0x07, 0x80, 0x07,
  0xC0, 0x78, 0x7C, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF8,
  0x7E, 0x1F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFE, 0x7C, 0x7E, 0x07, 0xEF, 0xC7,
  0xE0, 0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xF0, 0xFC, 0x01,
  0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xF9, 0xF8, 0x3F, 0xFE, 0x1F, 0x80, 0xFF, 0xC1, 0xFC, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x01, 0xC1, 0xF0, 0x30, 0xF8, 0xF8, 0x78, 0xFF, 0x3C, 0xFE,
  0x7F, 0xDD, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF,
  0xC0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xF8,
  0x3F, 0x80, 0x7C, 0x1F, 0x00, 0x0C, 0x07, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x0F, 0xE0, 0x7F,
  0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x03, 0xF0, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0x0C, 0x0F, 0xE7, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0xC1, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xF7, 0xF1, 0xFC,
  0x7E, 0x7F, 0x1F, 0xC7, 0xE7, 0xE1, 0xFC, 0x7E, 0x7E, 0x1F, 0x8F, 0xE7,
  0xE1, 0xF0, 0xFE, 0x7E, 0x06, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF9, 0xF8, 0x03, 0xF3, 0xF8,
  0x03, 0xC3, 0xF8, 0x02, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x1C, 0x00, 0xFF, 0x00,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0xC0,
  0x1F, 0xE0, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x04, 0x00, 0x0F, 0xF0, 0x3C, 0x01, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8,
  0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x0C, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x01, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0x80, 0x03, 0xE1,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x07, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xF0, 0xFF, 0x83, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x33, 0xE0, 0xF8, 0x07, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0x87, 0xC0, 0xFF,
  0xFF, 0x1F, 0x83, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0xF8, 0x7C, 0x1F, 0xC3,
  0xF0, 0xF8, 0x7F, 0x07, 0xE3, 0xF0, 0xFC, 0x0F, 0xC7, 0xC3, 0xF0, 0x1F,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x0F, 0xC0, 0xFC, 0x3E, 0x1F, 0x01, 0xF8,
  0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x87,
  0xE1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3F,
  0x0F, 0xFF, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xF8,
  0x1F, 0xFF, 0x01, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFE,
  0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80,
  0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0x7F, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0x80, 0xFF, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x01,
  0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x03, 0x80, 0x7F, 0x80, 0x04, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x80,
  0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xC0, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xC0, 0x7F, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0x00, 0xFF, 0x00, 0x04, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x00, 0x1F, 0xE0, 0x07, 0x00,
  0x7F, 0x80, 0x1F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF1, 0xFE,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03,
  0xF3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFB, 0xC1,
  0xFF, 0x80, 0x3E, 0xF0, 0x7B, 0xE0, 0x0F, 0xBC, 0x3E, 0xF8, 0x03, 0xEF,
  0x0F, 0x7C, 0x01, 0xF3, 0xC7, 0xDF, 0x00, 0x7C, 0xF1, 0xE7, 0xC0, 0x1F,
  0x3C, 0xF9, 0xF0, 0x0F, 0xCF, 0xBC, 0xFC, 0x03, 0xE3, 0xFF, 0x3F, 0x00,
  0xF8, 0xFF, 0x8F, 0x80, 0x7E, 0x1F, 0xC3, 0xE0, 0x1F, 0x87, 0xF1, 0xF8,
  0x07, 0xE1, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x07,
  0xC0, 0x3F, 0x07, 0xC3, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x0F, 0xF8,
  0x01, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFD, 0xF0, 0x3F, 0x00, 0x7E,
  0xF8, 0x1F, 0x80, 0x7E, 0x7C, 0x0F, 0xC0, 0x3F, 0x3E, 0x07, 0xE0, 0x1F,
  0x8F, 0x87, 0xE0, 0x0F, 0xC7, 0xC3, 0xF0, 0x0F, 0xC3, 0xE1, 0xF8, 0x07,
  0xE1, 0xF0, 0xFC, 0x03, 0xF0, 0x7C, 0x7C, 0x01, 0xF8, 0x3E, 0x7E, 0x00,
  0xF8, 0x1F, 0x3F, 0x00, 0xFC, 0x0F, 0x9F, 0x80, 0x7E, 0x03, 0xCF, 0xC0,
  0x3F, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0,
  0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xFC,
  0x03, 0xF0, 0x03, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x87, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0xFE, 0x00,
  0x08, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x08, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x7C, 0x1F, 0x80, 0xFC, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xF0, 0xFC, 0x03, 0xE3, 0xFC, 0x3E, 0x01,
  0xF8, 0xFF, 0x0F, 0x80, 0x7E, 0x7F, 0xC7, 0xE0, 0x1F, 0x1E, 0xF1, 0xF8,
  0x07, 0xCF, 0xBC, 0x7C, 0x01, 0xF3, 0xCF, 0x1F, 0x00, 0xFD, 0xF3, 0xEF,
  0xC0, 0x3E, 0x78, 0xFB, 0xE0, 0x0F, 0xBE, 0x3E, 0xF8, 0x03, 0xEF, 0x07,
  0xBE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3D, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF0, 0x00,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x8E, 0x00, 0x07, 0x80, 0x80, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x10, 0x03, 0x80, 0x7C, 0x07, 0xE0, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xE0, 0x3E, 0x00, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x87, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0x80, 0xFF, 0xC3, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x87, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0x20, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x83, 0xFF,
  0x81, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x7F, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xFC, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x20, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x70, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x20, 0x03, 0xF8, 0x00, 0xE0, 0x3F, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x40, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0x83, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC3, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xC0, 0x17, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0x8F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7E, 0x7F, 0x9F, 0xC0, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC3, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF0, 0x3F,
  0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x3F, 0x80,
  0xFF, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF,
  0xF0, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFE, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFD, 0xF8, 0x00, 0x1E,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xC0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x60, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x3F, 0xC1, 0xF0, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x10, 0x1F, 0xE0, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x07,
  0xFE, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F,
  0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x7E, 0x1F, 0x83, 0xF0,
  0xF8, 0x3F, 0x87, 0xC1, 0xF0, 0x7F, 0x0F, 0x83, 0xE1, 0xFE, 0x3F, 0x07,
  0xC3, 0xFC, 0x7C, 0x0F, 0x8F, 0xF8, 0xF8, 0x3F, 0x3F, 0xF3, 0xF0, 0x7E,
  0x7D, 0xE7, 0xC0, 0xF9, 0xF3, 0xCF, 0x81, 0xF3, 0xE7, 0xBE, 0x03, 0xEF,
  0x8F, 0x7C, 0x07, 0xDE, 0x1E, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0, 0x7C, 0x3F, 0xFF, 0x87, 0xE3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xF8, 0x7F, 0xFF, 0x0F, 0x81,
  0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xC0, 0x0F, 0xE0, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 16, 38, 30, 8, -37 },
  { 77, 20, 16, 30, 10, -41 },
  { 117, 32, 37, 30, 0, -37 },
  { 265, 29, 48, 30, 1, -42 },
  { 439, 37, 39, 30, -2, -38 },
  { 620, 28, 39, 30, 1, -38 },
  { 757, 10, 17, 30, 15, -41 },
  { 779, 24, 53, 30, 6, -43 },
  { 938, 23, 53, 30, 1, -43 },
  { 1091, 25, 23, 30, 5, -37 },
  { 1163, 27, 27, 30, 2, -29 },
  { 1255, 14, 19, 30, 4, -10 },
  { 1289, 17, 7, 30, 7, -19 },
  { 1304, 10, 11, 30, 8, -10 },
  { 1318, 35, 52, 30, -3, -42 },
  { 1546, 28, 39, 30, 2, -38 },
  { 1683, 24, 37, 30, 2, -37 },
  { 1794, 29, 38, 30, 1, -38 },
  { 1932, 29, 39, 30, 0, -38 },
  { 2074, 30, 37, 30, 0, -37 },
  { 2213, 31, 38, 30, 0, -37 },
  { 2361, 28, 39, 30, 3, -38 },
  { 2498, 29, 37, 30, 5, -37 },
  { 2633, 28, 39, 30, 2, -38 },
  { 2770, 29, 38, 30, 1, -38 },
  { 2908, 14, 30, 30, 8, -29 },
  { 2961, 18, 38, 30, 4, -29 },
  { 3047, 28, 25, 30, 2, -28 },
  { 3135, 29, 18, 30, 1, -25 },
  { 3201, 27, 25, 30, 1, -28 },
  { 3286, 23, 39, 30, 7, -38 },
  { 3399, 31, 46, 30, 1, -38 },
  { 3578, 29, 37, 30, -3, -37 },
  { 3713, 30, 38, 30, 0, -38 },
  { 3856, 29, 39, 30, 3, -38 },
  { 3998, 30, 38, 30, 0, -38 },
  { 4141, 31, 37, 30, 1, -37 },
  { 4285, 32, 37, 30, 1, -37 },
  { 4433, 30, 39, 30, 2, -38 },
  { 4580, 34, 37, 30, -1, -37 },
  { 4738, 32, 37, 30, 0, -37 },
  { 4886, 31, 38, 30, 0, -37 },
  { 5034, 34, 37, 30, 0, -37 },
  { 5192, 24, 37, 30, 1, -37 },
  { 5303, 34, 37, 30, -2, -37 },
  { 5461, 33, 37, 30, 0, -37 },
  { 5614, 28, 39, 30, 2, -38 },
  { 5751, 31, 38, 30, 0, -38 },
  { 5899, 28, 48, 30, 2, -38 },
  { 6067, 30, 38, 30, 0, -38 },
  { 6210, 31, 39, 30, 0, -38 },
  { 6362, 28, 37, 30, 6, -37 },
  { 6492, 31, 38, 30, 2, -37 },
  { 6640, 29, 37, 30, 6, -37 },
  { 6775, 34, 37, 30, 0, -37 },
  { 6933, 37, 37, 30, -2, -37 },
  { 7105, 29, 37, 30, 6, -37 },
  { 7240, 32, 37, 30, 0, -37 },
  { 7388, 29, 52, 30, 3, -42 },
  { 7577, 12, 52, 30, 10, -42 },
  { 7655, 29, 52, 30, -1, -42 },
  { 7844, 27, 21, 30, 3, -37 },
  { 7915, 28, 6, 30, -4, 4 },
  { 7936, 12, 11, 30, 13, -42 },
  { 7953, 27, 30, 30, 2, -29 },
  { 8055, 27, 43, 30, 1, -42 },
  { 8201, 27, 30, 30, 2, -29 },
  { 8303, 31, 43, 30, 2, -42 },
  { 8470, 27, 30, 30, 2, -29 },
  { 8572, 38, 52, 30, -4, -42 },
  { 8819, 32, 39, 30, -2, -29 },
  { 8975, 27, 42, 30, 0, -42 },
  { 9117, 20, 42, 30, 5, -42 },
  { 9222, 30, 52, 30, -2, -42 },
  { 9417, 31, 42, 30, 1, -42 },
  { 9580, 18, 43, 30, 7, -42 },
  { 9677, 31, 29, 30, -1, -29 },
  { 9790, 27, 29, 30, 1, -29 },
  { 9888, 26, 30, 30, 2, -29 },
  { 9986, 30, 39, 30, -2, -29 },
  { 10133, 28, 39, 30, 2, -29 },
  { 10270, 28, 29, 30, 2, -29 },
  { 10372, 27, 30, 30, 1, -29 },
  { 10474, 24, 38, 30, 5, -37 },
  { 10588, 27, 29, 30, 2, -28 },
  { 10686, 26, 28, 30, 5, -28 },
  { 10777, 31, 28, 30, 2, -28 },
  { 10886, 33, 28, 30, -2, -28 },
  { 11002, 35, 38, 30, -4, -28 },
  { 11169, 28, 28, 30, 1, -28 },
  { 11267, 29, 52, 30, 4, -42 },
  { 11456, 19, 52, 30, 6, -42 },
  { 11580, 29, 52, 30, -2, -42 },
  { 11769, 29, 10, 30, 1, -21 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC54PT7B_H_
