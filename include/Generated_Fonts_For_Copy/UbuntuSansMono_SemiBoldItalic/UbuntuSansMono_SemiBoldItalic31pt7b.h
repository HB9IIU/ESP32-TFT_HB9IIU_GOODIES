#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC31PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x3E, 0x1F, 0x0F,
  0x00, 0x79, 0xEF, 0x3D, 0xC7, 0xF8, 0xFF, 0x1D, 0xE3, 0xB8, 0xF7, 0x1C,
  0xC3, 0x98, 0x70, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x1E, 0x38, 0x07, 0x1E,
  0x01, 0xC7, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x1E, 0x01,
  0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00,
  0xE3, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0x8E, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x40, 0x3C, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x08,
  0x3F, 0x03, 0x83, 0xF8, 0x38, 0x18, 0xC3, 0x81, 0xC6, 0x1C, 0x0E, 0x71,
  0xC0, 0x63, 0x9C, 0x03, 0x99, 0xC0, 0x1F, 0xDC, 0x00, 0xFD, 0xC0, 0x01,
  0x8C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xF8, 0x00, 0xEF, 0xC0, 0x0E, 0x77,
  0x00, 0xE7, 0x38, 0x0E, 0x31, 0xC0, 0x71, 0x8C, 0x07, 0x0C, 0x60, 0x70,
  0x67, 0x07, 0x03, 0xF0, 0x70, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C,
  0x78, 0x1E, 0x78, 0x07, 0x78, 0x03, 0xF8, 0x01, 0xF9, 0x21, 0xF8, 0xE1,
  0xFE, 0x71, 0xCF, 0x39, 0xE3, 0xF8, 0xE0, 0xFC, 0xF0, 0x7C, 0x78, 0x1E,
  0x3C, 0x1F, 0x0F, 0xFF, 0x87, 0xFD, 0xE1, 0xFC, 0x70, 0x7B, 0xDF, 0xEF,
  0x7B, 0x9C, 0xE6, 0x00, 0x00, 0x10, 0x01, 0x80, 0x1E, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x01, 0xC0, 0x04,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x04, 0x38, 0x9C, 0xC6, 0x7B, 0x7F, 0xFF,
  0xF3, 0xFF, 0x01, 0xF0, 0x0F, 0xE0, 0x7B, 0xC3, 0xCF, 0x87, 0x18, 0x08,
  0x40, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x04, 0x1F, 0x1F, 0x3F, 0x1F,
  0x1F, 0x07, 0x0E, 0x7C, 0xF8, 0xE0, 0x7F, 0xFF, 0xEF, 0xFB, 0xFE, 0x11,
  0xF7, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C,
  0x07, 0x3C, 0x07, 0x78, 0x0F, 0x79, 0xCF, 0x7B, 0xCF, 0x73, 0xCF, 0x71,
  0xCE, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x78, 0x78,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x3F,
  0x83, 0xFE, 0x1F, 0xF8, 0x7B, 0xC0, 0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x17, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0xC0, 0xFB, 0xF0, 0x60, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xE3, 0xF0, 0x40, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x10, 0x0F, 0x0F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x1C, 0x0F,
  0x1E, 0x07, 0x0F, 0x07, 0x07, 0x87, 0x03, 0x87, 0x83, 0xC3, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x18, 0x1F, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x77, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F,
  0x8F, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x1F, 0x1E, 0x0F,
  0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x3E, 0xF8, 0x78, 0x3C, 0x70, 0x3C, 0xF0,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x3C, 0x0F, 0x3E, 0x1F, 0x3F,
  0xFF, 0x1F, 0xFE, 0x07, 0x9E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x02, 0x07, 0x87,
  0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xC3,
  0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x80, 0x78, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0xF0, 0x3E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xE0, 0x38, 0x3E, 0x0F, 0x81, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x78, 0x00, 0x18, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFF, 0x00, 0x18, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x03, 0xFE, 0x1F, 0xE1, 0xFF, 0x07, 0xF0,
  0x0F, 0x80, 0x18, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x8F, 0xFE, 0x71, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1,
  0xE0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0xFF, 0x70, 0xFF,
  0xB8, 0xFF, 0x9C, 0xF1, 0xDC, 0x70, 0xEE, 0x78, 0xF7, 0x38, 0x7B, 0x9C,
  0x39, 0xCE, 0x1C, 0xE7, 0x9E, 0x73, 0xCF, 0x38, 0xFF, 0x1C, 0x7F, 0x8E,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x20, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0x70, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3,
  0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x78,
  0x01, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0xC3, 0xC3, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF9, 0xE1, 0xF0, 0x21, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x04, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x3E,
  0x1C, 0x3F, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFC, 0xE0, 0xF0, 0x10, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x78, 0xF8, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x81, 0xE1, 0xE0, 0x38, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0E, 0x03, 0xC3,
  0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x20, 0x3C, 0x1C, 0x1E, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0xE0, 0xF8,
  0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x00,
  0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03,
  0xDF, 0x00, 0x79, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x03, 0xC1,
  0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0xEC,
  0x6E, 0x0E, 0xCE, 0xC0, 0xEC, 0xDC, 0x0E, 0xDD, 0xC1, 0xCF, 0x9C, 0x1C,
  0xF9, 0xC1, 0xCF, 0x3C, 0x3C, 0xF3, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x70, 0x70, 0x07, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE1, 0xF0, 0x38, 0x3E, 0x07, 0x07, 0xC0,
  0xE0, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xE0, 0xE7, 0x1C, 0x1C, 0xE7,
  0x87, 0x9C, 0xF0, 0xF3, 0x9C, 0x1C, 0x3B, 0x83, 0x87, 0xF0, 0x70, 0xFE,
  0x1E, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x3E, 0x0E, 0x07, 0xC3, 0xC0, 0xF0,
  0x78, 0x1E, 0x0E, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F,
  0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x78, 0x07, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x07,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1,
  0xE0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x9F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x60, 0x01,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x9F, 0xC7, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x78, 0x78, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0x1E, 0x0F, 0x01, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x86, 0x03, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3E,
  0x1E, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xF0, 0x07, 0xF8,
  0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xC0, 0xF0,
  0xE0, 0xF0, 0x70, 0x78, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1E,
  0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF7, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0xE0, 0x0E, 0x0E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0xC3,
  0xCE, 0x3C, 0x3C, 0xE3, 0x83, 0x9F, 0x38, 0x39, 0xF3, 0x83, 0xBF, 0x70,
  0x3B, 0x77, 0x07, 0x77, 0x70, 0x76, 0x77, 0x07, 0xE3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x78, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78,
  0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00,
  0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0x70, 0x0F, 0x03,
  0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x70, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x7B,
  0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x43, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x1C, 0x70, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0xF7, 0x83, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x78, 0x1F, 0xE0,
  0x3D, 0xC0, 0x79, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x20, 0xE3, 0xE3, 0xE1, 0xE1, 0x80, 0x00, 0x70, 0x03, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xBC, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x30, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x1E, 0x78, 0x3E, 0x78, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xBC, 0x03, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0xE0,
  0xF8, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFE, 0xF0, 0x00, 0x70, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x3E, 0x0F, 0x3C, 0x0F, 0x78, 0x1E, 0x70,
  0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x20, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F,
  0x83, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x04, 0x07, 0xC1, 0xE7, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x70, 0x0F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF3, 0xFC, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xE2, 0x3F,
  0xC7, 0xF8, 0x7F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x20, 0x78, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x03, 0xCF, 0x01, 0xEF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0x7F, 0xBF,
  0xEF, 0xF8, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x5F, 0xF3, 0xFC, 0xFF, 0x1F, 0xDF, 0x0F, 0xFF, 0xC7, 0x7D, 0xE3, 0x9C,
  0x73, 0x8E, 0x39, 0xC7, 0x3C, 0xE3, 0x9C, 0x73, 0x8E, 0x79, 0xC7, 0x38,
  0xE7, 0x9C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x38, 0x00, 0x60, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x38,
  0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x83, 0xDE,
  0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x07,
  0xDF, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x70, 0x03, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1C,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x81, 0xE3, 0xC1, 0xF1,
  0xE3, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x03,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x78,
  0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x88, 0x0F, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x87, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1E, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xBC, 0xF0, 0x3F,
  0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78,
  0xF0, 0xF1, 0xE0, 0xE7, 0x81, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC7,
  0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xC7, 0x3C, 0xE3, 0xDF, 0x38, 0xE7, 0xCE,
  0x3B, 0xB7, 0x0E, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x0F, 0x03, 0x83, 0xC0, 0x0F, 0x03, 0xE0, 0xF0, 0xF0, 0x1E, 0x1E, 0x01,
  0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x01, 0xF3, 0xC0, 0x7C,
  0x3C, 0x1F, 0x07, 0x87, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0x7B, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x88, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00,
  0x1F, 0x06, 0x3F, 0x8F, 0x7F, 0xFE, 0xF7, 0xFE, 0xE1, 0xFC, 0x40, 0x70,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 21, 17, 5, -21 },
  { 25, 11, 10, 17, 6, -24 },
  { 39, 18, 21, 17, 0, -21 },
  { 87, 16, 27, 17, 1, -24 },
  { 141, 21, 23, 17, -1, -22 },
  { 202, 17, 22, 17, 0, -22 },
  { 249, 5, 10, 17, 9, -24 },
  { 256, 13, 31, 17, 4, -25 },
  { 307, 14, 31, 17, 0, -25 },
  { 362, 14, 13, 17, 3, -21 },
  { 385, 15, 16, 17, 1, -17 },
  { 415, 8, 11, 17, 2, -6 },
  { 426, 10, 4, 17, 4, -11 },
  { 431, 6, 6, 17, 4, -6 },
  { 436, 21, 30, 17, -2, -24 },
  { 515, 16, 22, 17, 1, -22 },
  { 559, 14, 21, 17, 1, -21 },
  { 596, 17, 22, 17, 0, -22 },
  { 643, 17, 22, 17, 0, -22 },
  { 690, 17, 21, 17, 0, -21 },
  { 735, 18, 21, 17, 0, -21 },
  { 783, 16, 22, 17, 2, -22 },
  { 827, 16, 21, 17, 3, -21 },
  { 869, 16, 22, 17, 1, -22 },
  { 913, 16, 22, 17, 1, -22 },
  { 957, 9, 17, 17, 4, -17 },
  { 977, 11, 22, 17, 2, -17 },
  { 1008, 16, 14, 17, 1, -16 },
  { 1036, 17, 10, 17, 0, -14 },
  { 1058, 15, 14, 17, 1, -16 },
  { 1085, 13, 22, 17, 4, -22 },
  { 1121, 17, 27, 17, 1, -22 },
  { 1179, 17, 21, 17, -2, -21 },
  { 1224, 17, 22, 17, 0, -22 },
  { 1271, 17, 22, 17, 2, -22 },
  { 1318, 17, 22, 17, 0, -22 },
  { 1365, 17, 21, 17, 1, -21 },
  { 1410, 18, 21, 17, 1, -21 },
  { 1458, 17, 22, 17, 1, -22 },
  { 1505, 19, 21, 17, 0, -21 },
  { 1555, 18, 21, 17, 0, -21 },
  { 1603, 18, 21, 17, 0, -21 },
  { 1651, 19, 21, 17, 0, -21 },
  { 1701, 14, 21, 17, 0, -21 },
  { 1738, 20, 21, 17, -1, -21 },
  { 1791, 19, 21, 17, 0, -21 },
  { 1841, 16, 22, 17, 1, -22 },
  { 1885, 18, 22, 17, 0, -22 },
  { 1935, 16, 28, 17, 1, -22 },
  { 1991, 17, 22, 17, 0, -22 },
  { 2038, 18, 22, 17, 0, -22 },
  { 2088, 17, 21, 17, 3, -21 },
  { 2133, 18, 21, 17, 1, -21 },
  { 2181, 17, 21, 17, 3, -21 },
  { 2226, 20, 21, 17, 0, -21 },
  { 2279, 21, 21, 17, -1, -21 },
  { 2335, 16, 21, 17, 4, -21 },
  { 2377, 19, 21, 17, 0, -21 },
  { 2427, 16, 30, 17, 2, -24 },
  { 2487, 6, 30, 17, 6, -24 },
  { 2510, 17, 30, 17, -1, -24 },
  { 2574, 15, 12, 17, 2, -21 },
  { 2597, 16, 4, 17, -2, 2 },
  { 2605, 7, 6, 17, 7, -24 },
  { 2611, 16, 17, 17, 1, -17 },
  { 2645, 16, 24, 17, 0, -24 },
  { 2693, 16, 17, 17, 1, -17 },
  { 2727, 18, 24, 17, 1, -24 },
  { 2781, 16, 17, 17, 1, -17 },
  { 2815, 21, 30, 17, -2, -24 },
  { 2894, 18, 23, 17, -1, -17 },
  { 2946, 16, 24, 17, 0, -24 },
  { 2994, 11, 24, 17, 3, -24 },
  { 3027, 17, 30, 17, -1, -24 },
  { 3091, 17, 24, 17, 1, -24 },
  { 3142, 10, 24, 17, 4, -24 },
  { 3172, 17, 16, 17, 0, -16 },
  { 3206, 16, 17, 17, 0, -17 },
  { 3240, 15, 17, 17, 1, -17 },
  { 3272, 17, 23, 17, -1, -17 },
  { 3321, 16, 23, 17, 1, -17 },
  { 3367, 16, 17, 17, 1, -17 },
  { 3401, 15, 17, 17, 1, -17 },
  { 3433, 14, 21, 17, 3, -21 },
  { 3470, 16, 16, 17, 1, -16 },
  { 3502, 15, 16, 17, 3, -16 },
  { 3532, 18, 16, 17, 1, -16 },
  { 3568, 19, 16, 17, -1, -16 },
  { 3606, 21, 22, 17, -3, -16 },
  { 3664, 17, 16, 17, 0, -16 },
  { 3698, 17, 30, 17, 2, -24 },
  { 3762, 11, 30, 17, 3, -24 },
  { 3804, 16, 30, 17, -1, -24 },
  { 3864, 16, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC31PT7B_H_
