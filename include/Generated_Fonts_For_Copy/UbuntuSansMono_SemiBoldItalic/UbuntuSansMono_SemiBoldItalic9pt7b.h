#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC9PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x21, 0x80, 0xB7, 0x00, 0x2B, 0xD5, 0xB6, 0x50, 0x11, 0xD0,
  0xC1, 0x0B, 0xC8, 0x6E, 0xC5, 0x0E, 0x6A, 0x40, 0x32, 0x88, 0xD9, 0x78,
  0xE0, 0x12, 0x48, 0x88, 0x84, 0x40, 0x21, 0x11, 0x13, 0x24, 0x80, 0x4F,
  0xF6, 0x11, 0x3E, 0x42, 0x00, 0x76, 0xE0, 0x70, 0x04, 0x30, 0x84, 0x10,
  0x82, 0x10, 0xC0, 0x3A, 0x5B, 0x19, 0x38, 0x35, 0x12, 0x2F, 0x78, 0x44,
  0x44, 0x78, 0x78, 0x4C, 0x21, 0x78, 0x19, 0x55, 0x27, 0x98, 0x3A, 0x1C,
  0x21, 0x78, 0x3A, 0x1D, 0x9D, 0xB8, 0xF9, 0x88, 0x8C, 0x40, 0x3A, 0x4C,
  0xA9, 0xB8, 0x7A, 0x52, 0x71, 0x70, 0x4C, 0x2C, 0x4C, 0x2C, 0xA0, 0x09,
  0xB0, 0x61, 0x00, 0x78, 0x7C, 0x43, 0x87, 0xC8, 0x00, 0x71, 0x64, 0x0C,
  0x3A, 0x6F, 0x5A, 0xC9, 0xC0, 0x33, 0x55, 0xF9, 0x7A, 0x5C, 0xB9, 0xF8,
  0x78, 0x88, 0x8E, 0x7A, 0x52, 0x99, 0x70, 0x3A, 0x1C, 0x84, 0x78, 0x3A,
  0x1E, 0x84, 0x40, 0x3A, 0x11, 0xBD, 0x38, 0x6D, 0x27, 0x96, 0x92, 0x40,
  0x79, 0x88, 0x42, 0x78, 0x38, 0x46, 0x21, 0x78, 0x6D, 0x46, 0x18, 0x92,
  0x40, 0x64, 0x44, 0xCF, 0x6B, 0xDF, 0x58, 0xC8, 0x6D, 0xA6, 0x9A, 0x92,
  0x40, 0x3A, 0x53, 0x19, 0x38, 0x7A, 0x52, 0xEC, 0x40, 0x3A, 0x53, 0x19,
  0x39, 0x82, 0x7A, 0x56, 0xC9, 0x48, 0x7A, 0x18, 0x21, 0x78, 0xFB, 0x10,
  0x84, 0x60, 0x6A, 0x53, 0xB9, 0x38, 0x9C, 0xAD, 0x4C, 0x60, 0x45, 0x26,
  0xAA, 0xD2, 0x40, 0x6C, 0xC3, 0x0C, 0x52, 0x40, 0x9C, 0x98, 0x84, 0x60,
  0x78, 0x8C, 0xC4, 0x78, 0x34, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0xAA, 0xC0,
  0x38, 0x84, 0x23, 0x10, 0x84, 0xE0, 0x31, 0xF2, 0xF8, 0x90, 0x3A, 0x65,
  0x27, 0x00, 0x22, 0x1C, 0xB4, 0xEB, 0xC0, 0x3A, 0x31, 0x87, 0x00, 0x0C,
  0x23, 0x92, 0xD2, 0x47, 0x00, 0x32, 0x7D, 0x07, 0x00, 0x0E, 0x20, 0xF0,
  0x81, 0x02, 0x08, 0x10, 0xC0, 0x3A, 0x75, 0xA7, 0x5B, 0x80, 0x22, 0x1C,
  0xB5, 0x6A, 0x40, 0x63, 0x24, 0x98, 0x18, 0x1C, 0x21, 0x08, 0x94, 0xC0,
  0x21, 0x12, 0xA6, 0x3A, 0x40, 0xED, 0x25, 0x98, 0x7B, 0x6B, 0x29, 0x00,
  0x72, 0xD5, 0xA9, 0x00, 0x32, 0xF3, 0x27, 0x00, 0x72, 0x53, 0xAF, 0x42,
  0x00, 0x3A, 0x75, 0xA7, 0x08, 0xC0, 0x3A, 0x10, 0x8C, 0x00, 0x3A, 0x1C,
  0x2F, 0x00, 0x4F, 0x4C, 0x8E, 0x4A, 0xD5, 0xA7, 0x00, 0x9B, 0xAE, 0xC0,
  0x4D, 0x6B, 0xAD, 0x00, 0x4B, 0x88, 0xA9, 0x00, 0x24, 0x92, 0x8A, 0x30,
  0x8C, 0x00, 0x78, 0x88, 0x8F, 0x00, 0x32, 0x44, 0x84, 0x88, 0x60, 0x25,
  0xA4, 0xB4, 0x80, 0x71, 0x13, 0x12, 0x24, 0xC0, 0x4F, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 3, 3, 5, 2, -7 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 1, 3, 5, 3, -7 },
  { 25, 4, 9, 5, 1, -7 },
  { 30, 4, 9, 5, 0, -7 },
  { 35, 4, 4, 5, 1, -6 },
  { 37, 5, 5, 5, 0, -5 },
  { 41, 2, 4, 5, 1, -2 },
  { 42, 3, 1, 5, 1, -3 },
  { 43, 2, 2, 5, 1, -2 },
  { 44, 6, 9, 5, -1, -7 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 5, 6, 5, 1, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 3, 5, 5, 1, -5 },
  { 92, 3, 7, 5, 1, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 5, 3, 5, 0, -4 },
  { 101, 5, 5, 5, 0, -5 },
  { 105, 4, 6, 5, 1, -6 },
  { 108, 5, 7, 5, 0, -6 },
  { 113, 4, 6, 5, 0, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 6, 6, 5, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 6, 6, 5, 0, -6 },
  { 157, 4, 6, 5, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 6, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 5, 8, 5, 0, -6 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 5, 6, 5, 0, -6 },
  { 190, 5, 6, 5, 1, -6 },
  { 194, 5, 6, 5, 0, -6 },
  { 198, 5, 6, 5, 1, -6 },
  { 202, 6, 6, 5, 0, -6 },
  { 207, 6, 6, 5, 0, -6 },
  { 212, 5, 6, 5, 1, -6 },
  { 216, 5, 6, 5, 0, -6 },
  { 220, 4, 9, 5, 1, -7 },
  { 225, 2, 9, 5, 2, -7 },
  { 228, 5, 9, 5, 0, -7 },
  { 234, 5, 3, 5, 0, -6 },
  { 236, 5, 1, 5, -1, 1 },
  { 237, 2, 2, 5, 2, -7 },
  { 238, 5, 5, 5, 0, -5 },
  { 242, 5, 7, 5, 0, -7 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 6, 7, 5, 0, -7 },
  { 257, 5, 5, 5, 0, -5 },
  { 261, 7, 9, 5, -1, -7 },
  { 269, 5, 7, 5, 0, -5 },
  { 274, 5, 7, 5, 0, -7 },
  { 279, 3, 7, 5, 1, -7 },
  { 282, 5, 9, 5, 0, -7 },
  { 288, 5, 7, 5, 0, -7 },
  { 293, 3, 7, 5, 1, -7 },
  { 296, 5, 5, 5, 0, -5 },
  { 300, 5, 5, 5, 0, -5 },
  { 304, 5, 5, 5, 0, -5 },
  { 308, 5, 7, 5, 0, -5 },
  { 313, 5, 7, 5, 0, -5 },
  { 318, 5, 5, 5, 0, -5 },
  { 322, 5, 5, 5, 0, -5 },
  { 326, 4, 6, 5, 1, -6 },
  { 329, 5, 5, 5, 0, -5 },
  { 333, 4, 5, 5, 1, -5 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 5, 5, 5, 0, -5 },
  { 344, 6, 7, 5, -1, -5 },
  { 350, 5, 5, 5, 0, -5 },
  { 354, 4, 9, 5, 1, -7 },
  { 359, 3, 9, 5, 1, -7 },
  { 363, 4, 9, 5, 0, -7 },
  { 368, 5, 2, 5, 0, -4 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC9PT7B_H_
