#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC32PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x0F,
  0x87, 0x80, 0x78, 0xF7, 0x8F, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1,
  0xCE, 0x1C, 0xC1, 0x80, 0x00, 0x71, 0xE0, 0x1E, 0x38, 0x03, 0x8F, 0x00,
  0xF1, 0xC0, 0x1C, 0x38, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x38, 0x70, 0x07, 0x1E, 0x01, 0xE3,
  0x80, 0x38, 0xF0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3E, 0x04, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x07, 0x84, 0x03, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0x01, 0xC3, 0xF8, 0x1C, 0x1C, 0xC1, 0xC0, 0xC6, 0x1C, 0x0E, 0x30,
  0xE0, 0x73, 0x8E, 0x03, 0x9C, 0xE0, 0x1D, 0xCE, 0x00, 0xFE, 0xE0, 0x03,
  0xEE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x30, 0x00, 0x77, 0xE0, 0x07, 0x7F,
  0x00, 0x73, 0x98, 0x07, 0x38, 0xC0, 0x71, 0xC6, 0x03, 0x8E, 0x70, 0x38,
  0x63, 0x83, 0x83, 0xB8, 0x38, 0x1F, 0xC3, 0x80, 0x7C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0x78, 0xF0, 0x38,
  0x78, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x3C, 0x03, 0xBC, 0x01, 0xFC, 0x00,
  0xF8, 0x71, 0xFC, 0x39, 0xFF, 0x3C, 0xE3, 0xDC, 0xF1, 0xFE, 0x70, 0x7E,
  0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE3, 0xFF, 0x70, 0xFE,
  0x3C, 0x7D, 0xE7, 0x9E, 0xF3, 0xCF, 0x38, 0xE3, 0x80, 0x00, 0x18, 0x01,
  0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x03, 0x1C, 0x67, 0xBB, 0xCF, 0xFF, 0xBF, 0xFF,
  0x81, 0xC0, 0x0F, 0xE0, 0x3D, 0xE0, 0xFB, 0xE1, 0xE3, 0xC1, 0xC7, 0x01,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x06, 0x0F,
  0x87, 0xE3, 0xF1, 0xF8, 0xF8, 0x1C, 0x1C, 0x7E, 0x7E, 0x3C, 0x00, 0x7F,
  0xDF, 0xFF, 0xFF, 0xFE, 0x33, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xE0, 0xF0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0xBC, 0x63, 0xDE, 0x79, 0xCF, 0x3C, 0xE7, 0x1C, 0xF3, 0x8C,
  0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x0F,
  0x1F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x1F, 0xC1, 0xFE, 0x1F, 0xF8, 0x7D, 0xE0, 0xE7, 0x82, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0x07, 0xC1, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x8C, 0x07, 0xC7, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0x8F,
  0x03, 0xC3, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1E, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC1, 0x81, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x79, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F,
  0x8F, 0x03, 0xC7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x38, 0xF0, 0x3C, 0x78,
  0x1E, 0x3E, 0x1E, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x81, 0xE3, 0xE1, 0xE0, 0xF8, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9F, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xF0,
  0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x04, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x0E,
  0x1F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF8,
  0xFC, 0xFC, 0xF8, 0xF8, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x00, 0xE0, 0x38, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x60, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x10, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x7E, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xF8, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x20, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xE0,
  0x7F, 0x78, 0x7F, 0x9C, 0x7F, 0xE7, 0x1F, 0x7B, 0xCF, 0x1E, 0xE3, 0x87,
  0x38, 0xE1, 0xCE, 0x78, 0xF3, 0x9E, 0x3C, 0xE7, 0x8E, 0x39, 0xE3, 0x8E,
  0x3D, 0xE3, 0x8F, 0xF8, 0xE1, 0xFE, 0x3C, 0x1C, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x10, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1D, 0xE0,
  0x0F, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x1E,
  0x0E, 0x07, 0x83, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x1F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x38, 0x78, 0x1E, 0x1E, 0x1F, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0xE0, 0x1C,
  0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8,
  0x10, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x83, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x3E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x81, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0,
  0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0x8F, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x81, 0x87, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x1E,
  0x07, 0x87, 0x83, 0xC1, 0xF0, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x04, 0x07, 0x81, 0xC1, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x07,
  0x87, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x3D, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF8, 0x07, 0x87, 0x80, 0x78, 0x7C,
  0x07, 0x83, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x0B, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0x7E, 0x7E, 0x0E, 0xE7,
  0xE0, 0xEE, 0xEE, 0x0E, 0xEC, 0xE1, 0xEF, 0xDE, 0x1C, 0xF9, 0xC1, 0xCF,
  0x9C, 0x1C, 0x71, 0xC3, 0xC7, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x78,
  0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x0F, 0x81, 0xE0, 0xFC, 0x1E,
  0x0F, 0xC1, 0xC0, 0xFC, 0x1C, 0x1F, 0xE3, 0xC1, 0xEE, 0x3C, 0x1E, 0xE3,
  0x81, 0xCE, 0x38, 0x3C, 0xE7, 0x83, 0xC7, 0x78, 0x3C, 0x77, 0x83, 0x87,
  0x70, 0x38, 0x77, 0x07, 0x83, 0xF0, 0x78, 0x3F, 0x07, 0x03, 0xE0, 0x70,
  0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E, 0x78, 0x1F, 0x3E,
  0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1E, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE1, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF8, 0xF0,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E,
  0x78, 0x1F, 0x3E, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xC7, 0x80,
  0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC1, 0xE0, 0x78, 0xF0,
  0x1E, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0x80, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE1, 0xC0,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F,
  0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0x81, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xE7, 0x80,
  0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x70, 0xF0,
  0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C,
  0x01, 0xE1, 0xC0, 0x1C, 0x3C, 0xF1, 0xC3, 0xCF, 0x3C, 0x39, 0xF3, 0x83,
  0x9F, 0x38, 0x3B, 0xB3, 0x83, 0xB3, 0x78, 0x77, 0x37, 0x07, 0x63, 0x70,
  0x7E, 0x37, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x03,
  0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x0E, 0x00,
  0xF8, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x03,
  0xC0, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9E, 0x07, 0xC7, 0x03, 0xC3,
  0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x39, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xF1,
  0xE3, 0xC7, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1,
  0xE3, 0xC7, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xBC, 0x0F, 0x3C, 0x1F, 0x3C, 0x3E,
  0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0x60, 0x0C, 0x00, 0x08, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x30, 0x78, 0xFC,
  0x1F, 0x0E, 0x02, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x8F, 0x3E,
  0x0E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F,
  0x9C, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x7C, 0x07, 0xFF, 0x03, 0xFF,
  0xC3, 0xF3, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x03, 0xE7, 0x83, 0xE3, 0xC3, 0xE1,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0x82, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x08, 0x7F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xC7, 0x83, 0xE0, 0xF0,
  0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0x9C, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x08, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xF3, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3E, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC1,
  0x00, 0xF0, 0x3C, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE1, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x04, 0x0F, 0x01, 0xEF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xF8, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0xC7, 0x83,
  0xE1, 0xE1, 0xF0, 0x78, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF8, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x7F,
  0xCF, 0xF3, 0xFE, 0x7F, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x5F, 0xF9, 0xFF, 0x1F, 0xC0, 0x07, 0xCF,
  0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x73, 0xCF, 0x1C, 0xF3, 0x8F, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x9E, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC0,
  0x3C, 0x70, 0x0F, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E,
  0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0x03,
  0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0x3E, 0x3C, 0x1F, 0x7C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8,
  0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x3E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3E,
  0x3C, 0x1F, 0x0F, 0x1F, 0x83, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF1, 0xE3, 0xE0, 0xF1,
  0xE0, 0x79, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x83, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x04, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x60, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xE0, 0x01, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC1, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0xF0, 0x3C, 0xF8, 0x3C, 0x78, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xBC, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDE,
  0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x0E, 0x71, 0xC3, 0x9C, 0x79, 0xE7,
  0x3E, 0x71, 0xCF, 0x9C, 0xF7, 0xEF, 0x39, 0xFB, 0x8E, 0xEE, 0xE3, 0xBB,
  0xF0, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xE3, 0xC0, 0x3C,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x3E, 0x3C, 0x0F, 0x87,
  0x83, 0xE0, 0x78, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xCF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x1F, 0x83, 0xDF, 0xF1, 0xCF, 0xFF,
  0xEF, 0x3F, 0xE7, 0x07, 0xE0, 0x80, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 22, 18, 5, -22 },
  { 26, 12, 9, 18, 6, -24 },
  { 40, 19, 22, 18, 0, -22 },
  { 93, 17, 28, 18, 1, -25 },
  { 153, 21, 24, 18, -1, -23 },
  { 216, 17, 23, 18, 0, -23 },
  { 265, 6, 10, 18, 9, -24 },
  { 273, 14, 31, 18, 4, -25 },
  { 328, 14, 31, 18, 0, -25 },
  { 383, 15, 14, 18, 3, -22 },
  { 410, 16, 16, 18, 1, -17 },
  { 442, 9, 11, 18, 2, -6 },
  { 455, 10, 4, 18, 4, -11 },
  { 460, 6, 6, 18, 5, -6 },
  { 465, 21, 31, 18, -2, -25 },
  { 547, 17, 23, 18, 1, -23 },
  { 596, 14, 22, 18, 1, -22 },
  { 635, 18, 23, 18, 0, -23 },
  { 687, 17, 23, 18, 0, -23 },
  { 736, 18, 22, 18, 0, -22 },
  { 786, 19, 22, 18, 0, -22 },
  { 839, 17, 22, 18, 2, -22 },
  { 886, 17, 22, 18, 3, -22 },
  { 933, 17, 23, 18, 1, -23 },
  { 982, 17, 23, 18, 1, -23 },
  { 1031, 8, 17, 18, 5, -17 },
  { 1048, 11, 22, 18, 2, -17 },
  { 1079, 17, 15, 18, 1, -17 },
  { 1111, 18, 11, 18, 0, -15 },
  { 1136, 16, 15, 18, 1, -17 },
  { 1166, 14, 23, 18, 4, -23 },
  { 1207, 18, 28, 18, 1, -23 },
  { 1270, 18, 22, 18, -2, -22 },
  { 1320, 18, 22, 18, 0, -22 },
  { 1370, 17, 23, 18, 2, -23 },
  { 1419, 18, 22, 18, 0, -22 },
  { 1469, 18, 22, 18, 1, -22 },
  { 1519, 18, 22, 18, 1, -22 },
  { 1569, 18, 23, 18, 1, -23 },
  { 1621, 20, 22, 18, 0, -22 },
  { 1676, 19, 22, 18, 0, -22 },
  { 1729, 19, 22, 18, 0, -22 },
  { 1782, 20, 22, 18, 0, -22 },
  { 1837, 15, 22, 18, 0, -22 },
  { 1879, 20, 22, 18, -1, -22 },
  { 1934, 20, 22, 18, 0, -22 },
  { 1989, 17, 23, 18, 1, -23 },
  { 2038, 18, 22, 18, 0, -22 },
  { 2088, 17, 29, 18, 1, -23 },
  { 2150, 18, 22, 18, 0, -22 },
  { 2200, 18, 23, 18, 0, -23 },
  { 2252, 16, 22, 18, 4, -22 },
  { 2296, 18, 22, 18, 1, -22 },
  { 2346, 18, 22, 18, 3, -22 },
  { 2396, 20, 22, 18, 0, -22 },
  { 2451, 21, 22, 18, -1, -22 },
  { 2509, 17, 22, 18, 4, -22 },
  { 2556, 19, 22, 18, 0, -22 },
  { 2609, 17, 31, 18, 2, -25 },
  { 2675, 7, 31, 18, 6, -25 },
  { 2703, 17, 31, 18, -1, -25 },
  { 2769, 16, 13, 18, 2, -22 },
  { 2795, 17, 4, 18, -3, 2 },
  { 2804, 8, 7, 18, 7, -25 },
  { 2811, 16, 17, 18, 1, -17 },
  { 2845, 17, 25, 18, 0, -25 },
  { 2899, 16, 17, 18, 1, -17 },
  { 2933, 19, 25, 18, 1, -25 },
  { 2993, 16, 17, 18, 1, -17 },
  { 3027, 22, 31, 18, -2, -25 },
  { 3113, 19, 23, 18, -1, -17 },
  { 3168, 16, 25, 18, 0, -25 },
  { 3218, 12, 25, 18, 3, -25 },
  { 3256, 18, 31, 18, -1, -25 },
  { 3326, 18, 25, 18, 1, -25 },
  { 3383, 11, 25, 18, 4, -25 },
  { 3418, 18, 17, 18, 0, -17 },
  { 3457, 16, 17, 18, 0, -17 },
  { 3491, 16, 17, 18, 1, -17 },
  { 3525, 18, 23, 18, -1, -17 },
  { 3577, 17, 23, 18, 1, -17 },
  { 3626, 17, 17, 18, 1, -17 },
  { 3663, 16, 17, 18, 1, -17 },
  { 3697, 14, 22, 18, 3, -22 },
  { 3736, 16, 17, 18, 1, -17 },
  { 3770, 15, 17, 18, 3, -17 },
  { 3802, 18, 17, 18, 1, -17 },
  { 3841, 19, 17, 18, -1, -17 },
  { 3882, 21, 23, 18, -3, -17 },
  { 3943, 16, 17, 18, 1, -17 },
  { 3977, 17, 31, 18, 2, -25 },
  { 4043, 12, 31, 18, 3, -25 },
  { 4090, 17, 31, 18, -1, -25 },
  { 4156, 17, 7, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC32PT7B_H_
