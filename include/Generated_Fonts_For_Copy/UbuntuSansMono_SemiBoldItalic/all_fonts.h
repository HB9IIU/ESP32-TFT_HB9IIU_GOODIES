#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/UbuntuSansMono_SemiBoldItalic
// Headers: 67

#include "UbuntuSansMono_SemiBoldItalic6pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic7pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic8pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic9pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic10pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic11pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic12pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic13pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic14pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic15pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic16pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic17pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic18pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic19pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic20pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic21pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic22pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic23pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic24pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic25pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic26pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic27pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic28pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic29pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic30pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic31pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic32pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic33pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic34pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic35pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic36pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic37pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic38pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic39pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic40pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic41pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic42pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic43pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic44pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic45pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic46pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic47pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic48pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic49pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic50pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic51pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic52pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic53pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic54pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic55pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic56pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic57pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic58pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic59pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic60pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic61pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic62pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic63pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic64pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic65pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic66pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic67pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic68pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic69pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic70pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic71pt7b.h"
#include "UbuntuSansMono_SemiBoldItalic72pt7b.h"
