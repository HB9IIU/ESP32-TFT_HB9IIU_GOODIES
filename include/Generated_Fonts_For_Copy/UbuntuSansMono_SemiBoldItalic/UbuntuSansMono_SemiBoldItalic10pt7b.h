#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC10PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0xB0, 0xFA, 0xA0, 0x14, 0xA7, 0xD6, 0xF9, 0x4A, 0x00,
  0x18, 0xF6, 0x98, 0x30, 0x69, 0xBC, 0x60, 0x65, 0xA7, 0x04, 0x39, 0x69,
  0x80, 0x3B, 0x5C, 0xDD, 0xCB, 0xA0, 0xEA, 0x19, 0x98, 0x8C, 0x42, 0x18,
  0x43, 0x00, 0x20, 0x84, 0x31, 0x08, 0x44, 0x44, 0x00, 0x27, 0x8B, 0xA0,
  0x11, 0xBE, 0x42, 0x00, 0x76, 0xE0, 0x70, 0x02, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x41, 0x80, 0x39, 0xB4, 0xDE, 0xCB, 0x67, 0x00, 0x1B, 0x94,
  0x23, 0x13, 0xE0, 0x39, 0x30, 0x86, 0x21, 0x0F, 0x80, 0x38, 0x42, 0x60,
  0x8F, 0xC0, 0x0C, 0x62, 0x92, 0xF8, 0x41, 0x00, 0x3C, 0x82, 0x1C, 0x08,
  0x6F, 0x00, 0x1C, 0x84, 0x1E, 0xC9, 0x27, 0x00, 0xF8, 0x8C, 0x44, 0x22,
  0x00, 0x39, 0xB6, 0x8C, 0x4B, 0x27, 0x00, 0x39, 0x24, 0xDE, 0x08, 0x4E,
  0x00, 0x2C, 0x2C, 0x2C, 0x2C, 0xA0, 0x0D, 0xCE, 0x0E, 0x7C, 0x00, 0x3E,
  0x60, 0xC7, 0xC0, 0x71, 0x16, 0x44, 0xC0, 0x3D, 0x15, 0xEB, 0xAA, 0xA9,
  0x14, 0x20, 0x0C, 0x51, 0x49, 0x3D, 0x1C, 0x40, 0x39, 0xB4, 0x9E, 0x4B,
  0x2F, 0x00, 0x7E, 0x21, 0x08, 0x43, 0xC0, 0x7A, 0x52, 0x94, 0xEF, 0xC0,
  0x3C, 0x86, 0x1E, 0x41, 0x0F, 0x80, 0x3C, 0x86, 0x1E, 0x41, 0x0C, 0x00,
  0x3D, 0x84, 0x12, 0xC9, 0x27, 0x80, 0x65, 0x14, 0xDE, 0x4B, 0x29, 0x80,
  0x3C, 0x41, 0x0C, 0x20, 0xAF, 0x00, 0x3C, 0x20, 0x82, 0x08, 0x4F, 0x00,
  0x2D, 0xA5, 0x18, 0x53, 0x49, 0x80, 0x23, 0x10, 0x84, 0x63, 0xE0, 0x25,
  0xB7, 0x5E, 0xAA, 0x28, 0x80, 0x65, 0x96, 0xD6, 0x5A, 0x69, 0x80, 0x39,
  0xB4, 0xD2, 0xCB, 0x67, 0x00, 0x39, 0xB4, 0xD6, 0x63, 0x08, 0x00, 0x39,
  0xB4, 0xD2, 0xCB, 0x67, 0x08, 0x30, 0x39, 0xB4, 0x9E, 0x53, 0x49, 0x80,
  0x3D, 0x86, 0x0C, 0x18, 0x2F, 0x00, 0xF9, 0x08, 0xC4, 0x21, 0x00, 0x65,
  0x34, 0x92, 0xCB, 0x67, 0x00, 0x8C, 0x65, 0x2A, 0x53, 0x00, 0x65, 0x14,
  0x5E, 0xBB, 0x69, 0x00, 0x64, 0xA3, 0x8C, 0x31, 0x68, 0x80, 0x8F, 0x65,
  0x18, 0x41, 0x04, 0x00, 0x7C, 0x21, 0x0C, 0x61, 0x0F, 0x80, 0x39, 0x18,
  0x84, 0x23, 0x10, 0x87, 0x00, 0xAA, 0xFD, 0x50, 0x38, 0x46, 0x21, 0x08,
  0xC4, 0x27, 0x00, 0x33, 0xB5, 0x30, 0xF8, 0x5C, 0x7A, 0x73, 0xB7, 0x80,
  0x21, 0x18, 0xF4, 0xA7, 0x7E, 0x7A, 0x31, 0x87, 0x80, 0x04, 0x10, 0xDE,
  0x4B, 0x2D, 0x9E, 0x7A, 0x7F, 0x87, 0x80, 0x06, 0x10, 0x61, 0xF1, 0x02,
  0x04, 0x18, 0x21, 0xC0, 0x7D, 0x2C, 0x96, 0x72, 0x4E, 0x00, 0x21, 0x18,
  0xF4, 0xA7, 0x72, 0x22, 0x0E, 0x44, 0x47, 0x08, 0x40, 0xF1, 0x08, 0x42,
  0xA7, 0x00, 0x20, 0x82, 0x5A, 0x51, 0xC5, 0x36, 0xE2, 0x26, 0x44, 0x47,
  0x7A, 0xEB, 0x18, 0x80, 0x7A, 0x53, 0xB9, 0x00, 0x7A, 0x73, 0xB7, 0x00,
  0x7A, 0x53, 0xBF, 0x42, 0x00, 0x3D, 0x2C, 0xB6, 0x70, 0x41, 0x00, 0x7D,
  0x84, 0x10, 0xC0, 0x7B, 0x0C, 0x3F, 0x00, 0x26, 0xF4, 0x4C, 0x70, 0x4A,
  0x53, 0xB7, 0x80, 0x9C, 0xA9, 0x4C, 0x00, 0x45, 0xEB, 0xB6, 0xD0, 0x6C,
  0xC3, 0x14, 0xD8, 0x26, 0x48, 0xB1, 0xC1, 0x06, 0x38, 0x00, 0x78, 0x88,
  0x8F, 0x80, 0x19, 0x08, 0xC4, 0x61, 0x18, 0x83, 0x00, 0x32, 0x22, 0x64,
  0x44, 0xC8, 0x30, 0x84, 0x21, 0x0C, 0x84, 0x26, 0x00, 0x6C, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 1, -7 },
  { 4, 4, 3, 6, 2, -8 },
  { 6, 6, 7, 6, 0, -7 },
  { 12, 6, 9, 6, 0, -8 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 5, 7, 6, 0, -7 },
  { 30, 2, 4, 6, 3, -8 },
  { 31, 5, 10, 6, 1, -8 },
  { 38, 5, 10, 6, 0, -8 },
  { 45, 5, 4, 6, 1, -7 },
  { 48, 5, 5, 6, 0, -5 },
  { 52, 2, 4, 6, 1, -2 },
  { 53, 3, 1, 6, 1, -3 },
  { 54, 2, 2, 6, 1, -2 },
  { 55, 7, 10, 6, -1, -8 },
  { 64, 6, 7, 6, 0, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 6, 7, 6, 0, -7 },
  { 81, 5, 7, 6, 0, -7 },
  { 86, 6, 7, 6, 0, -7 },
  { 92, 6, 7, 6, 0, -7 },
  { 98, 6, 7, 6, 0, -7 },
  { 104, 5, 7, 6, 1, -7 },
  { 109, 6, 7, 6, 0, -7 },
  { 115, 6, 7, 6, 0, -7 },
  { 121, 3, 5, 6, 1, -5 },
  { 123, 3, 7, 6, 1, -5 },
  { 126, 6, 4, 6, 0, -5 },
  { 129, 6, 4, 6, 0, -5 },
  { 132, 5, 4, 6, 0, -5 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 6, 9, 6, 0, -7 },
  { 146, 6, 7, 6, -1, -7 },
  { 152, 6, 7, 6, 0, -7 },
  { 158, 5, 7, 6, 1, -7 },
  { 163, 5, 7, 6, 0, -7 },
  { 168, 6, 7, 6, 0, -7 },
  { 174, 6, 7, 6, 0, -7 },
  { 180, 6, 7, 6, 0, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 6, 7, 6, 0, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 5, 7, 6, 0, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 6, 7, 6, 0, -7 },
  { 239, 6, 9, 6, 0, -7 },
  { 246, 6, 7, 6, 0, -7 },
  { 252, 6, 7, 6, 0, -7 },
  { 258, 5, 7, 6, 1, -7 },
  { 263, 6, 7, 6, 0, -7 },
  { 269, 5, 7, 6, 1, -7 },
  { 274, 6, 7, 6, 0, -7 },
  { 280, 6, 7, 6, 0, -7 },
  { 286, 6, 7, 6, 1, -7 },
  { 292, 6, 7, 6, 0, -7 },
  { 298, 5, 10, 6, 1, -8 },
  { 305, 2, 10, 6, 2, -8 },
  { 308, 5, 10, 6, 0, -8 },
  { 315, 5, 4, 6, 1, -7 },
  { 318, 5, 1, 6, -1, 1 },
  { 319, 3, 2, 6, 2, -8 },
  { 320, 5, 5, 6, 0, -5 },
  { 324, 5, 8, 6, 0, -8 },
  { 329, 5, 5, 6, 0, -5 },
  { 333, 6, 8, 6, 0, -8 },
  { 339, 5, 5, 6, 0, -5 },
  { 343, 7, 10, 6, -1, -8 },
  { 352, 6, 7, 6, 0, -5 },
  { 358, 5, 8, 6, 0, -8 },
  { 363, 4, 8, 6, 1, -8 },
  { 367, 5, 10, 6, 0, -8 },
  { 374, 6, 8, 6, 0, -8 },
  { 380, 4, 8, 6, 1, -8 },
  { 384, 5, 5, 6, 0, -5 },
  { 388, 5, 5, 6, 0, -5 },
  { 392, 5, 5, 6, 0, -5 },
  { 396, 5, 7, 6, 0, -5 },
  { 401, 6, 7, 6, 0, -5 },
  { 407, 6, 5, 6, 0, -5 },
  { 411, 5, 5, 6, 0, -5 },
  { 415, 4, 7, 6, 1, -7 },
  { 419, 5, 5, 6, 0, -5 },
  { 423, 5, 5, 6, 1, -5 },
  { 427, 6, 5, 6, 0, -5 },
  { 431, 6, 5, 6, 0, -5 },
  { 435, 7, 7, 6, -1, -5 },
  { 442, 5, 5, 6, 0, -5 },
  { 446, 5, 10, 6, 1, -8 },
  { 453, 4, 10, 6, 1, -8 },
  { 458, 5, 10, 6, 0, -8 },
  { 465, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC10PT7B_H_
