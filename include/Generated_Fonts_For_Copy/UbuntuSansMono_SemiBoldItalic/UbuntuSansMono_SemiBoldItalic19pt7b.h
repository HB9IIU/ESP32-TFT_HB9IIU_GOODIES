#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC19PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x19, 0xCC, 0x00, 0x39, 0xCE, 0x00, 0x77, 0x66,
  0x66, 0x66, 0xCC, 0x06, 0x60, 0xCC, 0x33, 0x3F, 0xF7, 0xFE, 0x33, 0x06,
  0x41, 0x98, 0xFF, 0xDF, 0xF9, 0x98, 0x36, 0x0C, 0xC0, 0x01, 0x80, 0x60,
  0x1E, 0x0F, 0xF1, 0x84, 0x70, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0xC4, 0x39, 0xFE, 0x0F, 0x00, 0xC0, 0x18, 0x00, 0x1E, 0x18, 0x91,
  0x8C, 0x98, 0x6D, 0x83, 0x78, 0x0E, 0x80, 0x0C, 0x00, 0xDC, 0x0D, 0xA0,
  0xC9, 0x0C, 0xD8, 0x46, 0xCC, 0x1C, 0x00, 0x0F, 0x87, 0x61, 0x98, 0x66,
  0x1B, 0x07, 0x83, 0xCD, 0xFB, 0x67, 0xB0, 0xEC, 0x33, 0xFE, 0x7D, 0x80,
  0x76, 0x6E, 0xCC, 0x01, 0x03, 0xC3, 0x83, 0x81, 0x81, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x04,
  0x00, 0x04, 0x07, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x10, 0x00, 0x18,
  0x0C, 0x3E, 0xDF, 0xF1, 0x81, 0xF1, 0xDC, 0x48, 0x0E, 0x06, 0x03, 0x1F,
  0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x39, 0xCE, 0x37, 0x70, 0x7D,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x1F, 0x8F, 0xE3,
  0x19, 0x87, 0x61, 0xBB, 0x6D, 0xDB, 0x26, 0xC3, 0xB0, 0xCC, 0x73, 0xF8,
  0x7C, 0x00, 0x07, 0x0F, 0x7E, 0x36, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x18, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0x0C, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0x87, 0xF0, 0x0C,
  0x03, 0x01, 0xC3, 0xE0, 0xF0, 0x0E, 0x01, 0x80, 0x60, 0x3B, 0xFC, 0xFE,
  0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xE1, 0xD8, 0x33, 0x0C, 0x63, 0x1C,
  0xFF, 0xDF, 0xF8, 0x0C, 0x01, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x30, 0x0C,
  0x01, 0x80, 0x3C, 0x0F, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x0E, 0x7F, 0x8F,
  0xE0, 0x07, 0xC3, 0xF3, 0xC0, 0xC0, 0x60, 0x1F, 0xCF, 0xFB, 0x0E, 0xC1,
  0xB0, 0xEE, 0x31, 0xFC, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x1C, 0x0E,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x1F,
  0x8E, 0xE3, 0x1D, 0xC7, 0x31, 0x8F, 0xC3, 0xE1, 0x9C, 0xC3, 0x30, 0xEC,
  0x33, 0xFC, 0x7E, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x18, 0x73, 0x0E, 0x61,
  0x8F, 0xF0, 0xF6, 0x01, 0x80, 0x70, 0x1C, 0x3F, 0x0F, 0x80, 0x3B, 0xCC,
  0x00, 0x00, 0x1C, 0xE7, 0x00, 0x0E, 0x3C, 0x30, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x70, 0x63, 0x8E, 0x00, 0x00, 0x81, 0xC7, 0xFF, 0x8E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xC3, 0xF7, 0xE3, 0xC0, 0xC0,
  0x00, 0x7E, 0xDC, 0x18, 0x30, 0xE7, 0x1C, 0x30, 0x00, 0x03, 0x87, 0x0C,
  0x00, 0x0F, 0xC3, 0x9C, 0xE1, 0x98, 0x36, 0x3E, 0xCF, 0xDB, 0x33, 0x66,
  0x4C, 0xD9, 0x9B, 0x3E, 0x33, 0xC6, 0x00, 0xE0, 0x0F, 0xC0, 0xF8, 0x01,
  0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x3F, 0xCF, 0xF7,
  0x0D, 0x83, 0xE0, 0xC0, 0x1F, 0xC3, 0xF8, 0x63, 0x9C, 0x63, 0x0C, 0x7F,
  0x0F, 0xE3, 0x8E, 0x61, 0xCC, 0x39, 0x86, 0x7F, 0xCF, 0xE0, 0x0F, 0xC7,
  0xF3, 0x81, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x11,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF3, 0x8C, 0xC3, 0x30, 0xCC, 0x37, 0x0D,
  0xC3, 0x61, 0xD8, 0x6E, 0x7B, 0xFC, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x60,
  0x0C, 0x03, 0x80, 0x7F, 0x0F, 0xE1, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x3F,
  0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0x1F, 0xC3,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0xC7, 0xF3, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x1B, 0x0E, 0xC3, 0xB0, 0xCE, 0x31, 0xFC, 0x7F,
  0x00, 0x18, 0x71, 0x86, 0x38, 0x63, 0x0E, 0x30, 0xC3, 0xFC, 0x7F, 0xC6,
  0x1C, 0x61, 0xC6, 0x18, 0xE1, 0x8E, 0x38, 0xC3, 0x80, 0x1F, 0xE3, 0xFC,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x3F, 0xCF, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x71, 0x0C, 0x7F, 0x87, 0xE0, 0x18, 0x71, 0x8E,
  0x39, 0xC3, 0xB8, 0x37, 0x03, 0xE0, 0x3C, 0x07, 0xE0, 0x67, 0x06, 0x30,
  0x63, 0x8E, 0x38, 0xC1, 0x80, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0F, 0xFF, 0xF0, 0x0C, 0x30, 0xE7, 0x1E,
  0x71, 0xEF, 0x1E, 0xB1, 0x7A, 0x37, 0x63, 0x76, 0x30, 0x66, 0x06, 0x60,
  0xC6, 0x0C, 0xE0, 0xC0, 0x18, 0x71, 0xC6, 0x3C, 0x63, 0xC6, 0x34, 0xC3,
  0x6C, 0x76, 0xC6, 0x6C, 0x63, 0xC6, 0x38, 0xE3, 0x8C, 0x38, 0xC3, 0x80,
  0x1F, 0x8F, 0xE7, 0x1D, 0x87, 0x61, 0xF8, 0x7C, 0x1B, 0x06, 0xC3, 0xB0,
  0xCC, 0x73, 0xF8, 0x7C, 0x00, 0x1F, 0xC3, 0xFC, 0x63, 0x9C, 0x33, 0x8E,
  0x61, 0x8F, 0xF3, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x1F,
  0x8F, 0xE7, 0x1D, 0x87, 0x61, 0xF8, 0x7C, 0x1B, 0x06, 0xC3, 0xB0, 0xCC,
  0x73, 0xF8, 0x7C, 0x0C, 0x03, 0x80, 0x78, 0x02, 0x00, 0x1F, 0x83, 0xF8,
  0xE3, 0x1C, 0x73, 0x0C, 0x63, 0x8F, 0xE3, 0xF0, 0x67, 0x0C, 0x61, 0x8C,
  0x71, 0xCC, 0x18, 0x0F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0x80, 0x31, 0x0E, 0x7F, 0x87, 0xE0, 0xFF, 0xFF, 0xF1,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x00, 0x30, 0xCC, 0x37, 0x1D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x0E,
  0xC3, 0x30, 0xCC, 0x73, 0xF8, 0x7C, 0x00, 0xE0, 0xF8, 0x7E, 0x1B, 0x8E,
  0xE3, 0x39, 0xCE, 0x63, 0xB8, 0xEC, 0x1F, 0x07, 0x81, 0xC0, 0x70, 0x00,
  0x38, 0x33, 0x03, 0x30, 0x63, 0x06, 0x30, 0x66, 0x66, 0x6E, 0xC6, 0xAC,
  0x7A, 0xC5, 0x28, 0x73, 0x8E, 0x38, 0xE3, 0x00, 0x0C, 0x38, 0x73, 0x81,
  0x98, 0x0D, 0x80, 0x7C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0xEE,
  0x0E, 0x70, 0xE1, 0x8E, 0x0C, 0x00, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x66,
  0x1F, 0x83, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x00, 0x1F,
  0xE3, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x3F, 0x0F, 0xC0, 0xCC, 0xCC, 0xCC, 0xEE, 0xEE, 0x66, 0x66,
  0x66, 0x66, 0x70, 0x0F, 0xC3, 0xE0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x3F, 0x0F, 0x80, 0x07, 0x07, 0x87, 0xC7, 0x77, 0x3B, 0x0F, 0x06, 0xFF,
  0xFF, 0xEF, 0xF8, 0x47, 0x1C, 0x30, 0x1F, 0x9F, 0xDC, 0xFC, 0x7C, 0x36,
  0x1B, 0x0D, 0x8E, 0xFF, 0x3D, 0x80, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0F, 0xE3, 0xFC, 0xC7, 0x30, 0xDC, 0x37, 0x1D, 0x86, 0x63, 0xBF, 0xCF,
  0xE0, 0x1F, 0x9F, 0xDC, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xFF, 0x3F,
  0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x3F, 0x0F, 0xE3, 0x8C,
  0xE3, 0x98, 0x63, 0x0C, 0x61, 0x8C, 0x71, 0xFE, 0x1E, 0xC0, 0x1F, 0x1F,
  0xD8, 0x7C, 0x3C, 0x7F, 0xF3, 0x01, 0x80, 0xFF, 0x3F, 0x80, 0x00, 0x78,
  0x0F, 0x80, 0xE4, 0x06, 0x00, 0x30, 0x0F, 0xF8, 0x7F, 0x80, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0xF8, 0x07, 0xC0, 0x18, 0x00, 0x07, 0xF0, 0xFE, 0x1C, 0x63, 0x8E, 0x30,
  0xE3, 0x0C, 0x30, 0xC3, 0xFC, 0x1F, 0xC0, 0x18, 0x01, 0x86, 0x70, 0xFF,
  0x01, 0x80, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0F, 0xE3, 0xF8, 0xC7,
  0x31, 0xDC, 0x67, 0x19, 0x86, 0x63, 0x98, 0xCE, 0x30, 0x0C, 0x38, 0x70,
  0x00, 0x1F, 0x3E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x07, 0xCF, 0x80, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x6E, 0x1F, 0xC0,
  0xE0, 0x00, 0x04, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x31, 0xCE, 0x71,
  0xDC, 0x37, 0x07, 0x81, 0xF8, 0x3B, 0x86, 0x30, 0xC7, 0x38, 0xE0, 0x7C,
  0xFA, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0F, 0xCF,
  0x80, 0x3D, 0xCF, 0xF2, 0x6D, 0x9B, 0x64, 0xDB, 0x36, 0x1B, 0x06, 0xC1,
  0xB0, 0x60, 0x1F, 0x8F, 0xF3, 0x1C, 0xC7, 0x31, 0xDC, 0x66, 0x19, 0x8E,
  0x63, 0xB8, 0xC0, 0x1F, 0x1F, 0xD8, 0xFC, 0x3C, 0x1E, 0x1F, 0x0D, 0x8E,
  0xFE, 0x3E, 0x00, 0x1F, 0xC3, 0xFC, 0x63, 0x8C, 0x33, 0x86, 0x71, 0xCC,
  0x31, 0x8E, 0x3F, 0x8F, 0xE1, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x00, 0x1F,
  0xCF, 0xE7, 0x1B, 0x8E, 0xC3, 0xB0, 0xCC, 0x33, 0x1C, 0xFF, 0x1F, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0x3F, 0xCF, 0xE3, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x0F, 0xC7, 0xE3, 0x80, 0xE0, 0x1E,
  0x03, 0xC0, 0x39, 0x0E, 0x7F, 0x3F, 0x80, 0x18, 0x18, 0x38, 0xFF, 0xFF,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x7E, 0x7E, 0x71, 0xB0, 0xD8, 0xEC,
  0x6E, 0x36, 0x1B, 0x1D, 0x8E, 0xFF, 0x3D, 0x80, 0xC3, 0xE1, 0xB1, 0xD8,
  0xCC, 0xE6, 0x63, 0xF1, 0xF0, 0x70, 0x38, 0x00, 0xE0, 0xF8, 0x1B, 0x33,
  0x66, 0xCD, 0xD9, 0xBB, 0x3D, 0xC7, 0x38, 0xC6, 0x18, 0xC0, 0x18, 0x71,
  0xCE, 0x0D, 0xC0, 0xF8, 0x07, 0x00, 0x70, 0x0F, 0x81, 0x98, 0x31, 0xCF,
  0x1C, 0x0C, 0x38, 0x61, 0x83, 0x1C, 0x18, 0xC0, 0xE6, 0x07, 0x70, 0x1B,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0x80, 0xBC, 0x07, 0x80, 0x70, 0x00,
  0x1F, 0xCF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0xBF,
  0xC0, 0x03, 0xC1, 0xF0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x78,
  0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x0F, 0x80,
  0xC0, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x87,
  0x0E, 0x18, 0x30, 0x61, 0xC3, 0x00, 0x0F, 0x03, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x01, 0xC0, 0x70, 0x30, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x1E, 0x0E, 0x00, 0x3C, 0xDF, 0xFC, 0x78,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 8, 5, 11, 3, -14 },
  { 15, 11, 13, 11, 0, -13 },
  { 33, 11, 17, 11, 0, -15 },
  { 57, 13, 13, 11, -1, -13 },
  { 79, 10, 13, 11, 0, -13 },
  { 96, 4, 6, 11, 5, -14 },
  { 99, 9, 19, 11, 2, -15 },
  { 121, 9, 19, 11, 0, -15 },
  { 143, 9, 8, 11, 2, -13 },
  { 152, 9, 9, 11, 1, -10 },
  { 163, 5, 6, 11, 1, -3 },
  { 167, 6, 3, 11, 2, -7 },
  { 170, 3, 3, 11, 3, -3 },
  { 172, 12, 19, 11, -1, -15 },
  { 201, 10, 13, 11, 1, -13 },
  { 218, 8, 13, 11, 1, -13 },
  { 231, 10, 13, 11, 0, -13 },
  { 248, 10, 13, 11, 0, -13 },
  { 265, 11, 13, 11, 0, -13 },
  { 283, 11, 13, 11, 0, -13 },
  { 301, 10, 13, 11, 1, -13 },
  { 318, 10, 13, 11, 2, -13 },
  { 335, 10, 13, 11, 1, -13 },
  { 352, 11, 13, 11, 0, -13 },
  { 370, 5, 10, 11, 3, -10 },
  { 377, 7, 13, 11, 1, -10 },
  { 389, 9, 9, 11, 1, -10 },
  { 400, 11, 6, 11, 0, -9 },
  { 409, 10, 9, 11, 0, -10 },
  { 421, 7, 13, 11, 3, -13 },
  { 433, 11, 16, 11, 0, -13 },
  { 455, 10, 13, 11, -1, -13 },
  { 472, 11, 13, 11, 0, -13 },
  { 490, 10, 13, 11, 1, -13 },
  { 507, 10, 13, 11, 0, -13 },
  { 524, 11, 13, 11, 0, -13 },
  { 542, 11, 13, 11, 1, -13 },
  { 560, 10, 13, 11, 1, -13 },
  { 577, 12, 13, 11, 0, -13 },
  { 597, 11, 13, 11, 0, -13 },
  { 615, 11, 13, 11, 0, -13 },
  { 633, 12, 13, 11, 0, -13 },
  { 653, 9, 13, 11, 0, -13 },
  { 668, 12, 13, 11, -1, -13 },
  { 688, 12, 13, 11, 0, -13 },
  { 708, 10, 13, 11, 1, -13 },
  { 725, 11, 13, 11, 0, -13 },
  { 743, 10, 17, 11, 1, -13 },
  { 765, 11, 13, 11, 0, -13 },
  { 783, 11, 13, 11, 0, -13 },
  { 801, 10, 13, 11, 2, -13 },
  { 818, 10, 13, 11, 1, -13 },
  { 835, 10, 13, 11, 2, -13 },
  { 852, 12, 13, 11, 0, -13 },
  { 872, 13, 13, 11, -1, -13 },
  { 894, 10, 13, 11, 2, -13 },
  { 911, 11, 13, 11, 0, -13 },
  { 929, 10, 19, 11, 1, -15 },
  { 953, 4, 19, 11, 4, -15 },
  { 963, 10, 19, 11, 0, -15 },
  { 987, 9, 7, 11, 1, -13 },
  { 995, 10, 3, 11, -1, 1 },
  { 999, 5, 4, 11, 4, -15 },
  { 1002, 9, 10, 11, 1, -10 },
  { 1014, 10, 15, 11, 0, -15 },
  { 1033, 9, 10, 11, 1, -10 },
  { 1045, 11, 15, 11, 1, -15 },
  { 1066, 9, 10, 11, 1, -10 },
  { 1078, 13, 19, 11, -1, -15 },
  { 1109, 12, 14, 11, -1, -10 },
  { 1130, 10, 15, 11, 0, -15 },
  { 1149, 7, 15, 11, 2, -15 },
  { 1163, 11, 19, 11, -1, -15 },
  { 1190, 11, 15, 11, 0, -15 },
  { 1211, 7, 15, 11, 2, -15 },
  { 1225, 10, 10, 11, 0, -10 },
  { 1238, 10, 10, 11, 0, -10 },
  { 1251, 9, 10, 11, 1, -10 },
  { 1263, 11, 14, 11, -1, -10 },
  { 1283, 10, 14, 11, 1, -10 },
  { 1301, 10, 10, 11, 1, -10 },
  { 1314, 10, 10, 11, 0, -10 },
  { 1327, 8, 13, 11, 2, -13 },
  { 1340, 9, 10, 11, 1, -10 },
  { 1352, 9, 10, 11, 2, -10 },
  { 1364, 11, 10, 11, 1, -10 },
  { 1378, 12, 10, 11, -1, -10 },
  { 1393, 13, 14, 11, -2, -10 },
  { 1416, 10, 10, 11, 0, -10 },
  { 1429, 10, 19, 11, 1, -15 },
  { 1453, 7, 19, 11, 2, -15 },
  { 1470, 10, 19, 11, -1, -15 },
  { 1494, 10, 3, 11, 0, -7 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC19PT7B_H_
