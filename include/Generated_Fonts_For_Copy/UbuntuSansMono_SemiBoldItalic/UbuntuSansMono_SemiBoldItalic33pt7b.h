#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC33PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0xFC, 0x3E, 0x0F, 0x80, 0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0xC7, 0x0C, 0x00, 0x00,
  0x78, 0xF0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0,
  0x1E, 0x39, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x78, 0xF0,
  0x07, 0x0E, 0x00, 0x71, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x8F,
  0x00, 0x70, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1F, 0x06, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0x01, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x1C, 0x1F, 0x80, 0xE0, 0xE7, 0x07, 0x03, 0x9C, 0x38,
  0x1C, 0x71, 0xC0, 0x71, 0x8F, 0x01, 0xC6, 0x38, 0x07, 0x39, 0xC0, 0x1F,
  0xCE, 0x00, 0x3F, 0x70, 0x00, 0xFB, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x73,
  0x80, 0x03, 0xBF, 0x00, 0x1C, 0xFE, 0x00, 0xE7, 0x38, 0x07, 0x18, 0xE0,
  0x3C, 0xE3, 0x80, 0xE3, 0x8C, 0x07, 0x0E, 0x70, 0x38, 0x39, 0xC1, 0xC0,
  0xFE, 0x0E, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x1C,
  0x78, 0x07, 0x3C, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0x1F, 0xE3,
  0x8F, 0x3D, 0xE7, 0x8F, 0x71, 0xE1, 0xFC, 0x70, 0x7E, 0x3C, 0x0F, 0x8F,
  0x03, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFB, 0xC3, 0xF8, 0xF0, 0x3D,
  0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x08, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x1E, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0x1C, 0x27,
  0xB9, 0xCF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7B,
  0xC1, 0xF3, 0xE1, 0xC7, 0x81, 0x86, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x1C, 0x1E, 0x3E, 0x7E, 0x3C, 0x10, 0x00, 0x7F, 0xEF, 0xFB, 0xFF, 0x7F,
  0xE0, 0x3B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x73, 0xDE, 0x79, 0xEF, 0x3C, 0xF7,
  0x9E, 0x7B, 0x84, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F,
  0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x04,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x03, 0xDE, 0x06, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x17, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1E, 0x1F, 0x06, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x04, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0C, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF1, 0x80, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0E, 0x78, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0E, 0x07, 0x87, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x30, 0x1F, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3D, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x83, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x1F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x04, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E,
  0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03,
  0xE7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0x0F, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xE0, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF8, 0x7F, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x01, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x0E, 0x0F,
  0x87, 0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x70, 0x0F, 0x03, 0xE0,
  0xFC, 0x0F, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x00,
  0x30, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x18, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xC6, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x1F, 0x01,
  0xC7, 0x80, 0x73, 0xC0, 0x1C, 0xE0, 0xFF, 0x78, 0xFF, 0xDC, 0x7F, 0xF7,
  0x1E, 0x3B, 0xCF, 0x0E, 0xF3, 0x87, 0xB8, 0xE1, 0xEE, 0x78, 0x73, 0x9E,
  0x1C, 0xE7, 0x8F, 0x38, 0xE3, 0xCE, 0x3F, 0xE3, 0x8F, 0xF8, 0xE1, 0xFE,
  0x3C, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x08, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE3,
  0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3C, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1E, 0x3F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1F, 0x07, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x0F, 0x03, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x03,
  0xE7, 0x80, 0xF1, 0xE0, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x0E, 0x1F, 0x00, 0x8F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x60, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3E, 0x7E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x07, 0xCF,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x83,
  0xE1, 0xE7, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x20, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x0C, 0x1F, 0x01, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xF1, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x08, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1,
  0xF0, 0x3C, 0x1E, 0x03, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x80, 0xF8, 0x3C,
  0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x07,
  0xC0, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8,
  0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x78, 0x1E,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8D, 0xC1, 0xFC, 0xEE, 0x0E, 0xEE, 0xE0, 0x73, 0x77, 0x07, 0x9F,
  0x38, 0x3C, 0xF9, 0xC1, 0xC7, 0x9E, 0x0E, 0x3C, 0xF0, 0xF1, 0xC7, 0x07,
  0x80, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0xC0, 0xF0, 0xFC, 0x0E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E,
  0x0E, 0xE1, 0xE1, 0xEE, 0x1C, 0x1E, 0xE1, 0xC1, 0xEE, 0x3C, 0x1C, 0x73,
  0xC3, 0xC7, 0x38, 0x3C, 0x73, 0x83, 0xC7, 0x78, 0x38, 0x3F, 0x83, 0x83,
  0xF0, 0x78, 0x3F, 0x07, 0x83, 0xF0, 0x70, 0x3F, 0x07, 0x01, 0xF0, 0xF0,
  0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0xBE, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F,
  0x83, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x08,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xCF, 0xF0, 0x78,
  0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE3, 0xE0,
  0x78, 0x78, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x7C,
  0xF0, 0x1F, 0x3C, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0xBE, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1E, 0x3F, 0x0F,
  0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x81,
  0xE1, 0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x3C, 0x07, 0x8F, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xE0, 0xE0, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE1, 0x00, 0x7C, 0x38, 0x1F, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1C, 0x01,
  0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0x83, 0x80, 0x3C, 0x1C,
  0x71, 0xE1, 0xE7, 0x8E, 0x0F, 0x3C, 0x70, 0x73, 0xE7, 0x83, 0x9F, 0x3C,
  0x1D, 0xD9, 0xC0, 0xEE, 0xEE, 0x0F, 0xE7, 0x70, 0x77, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xC0, 0x70, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0x00,
  0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x07,
  0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF,
  0x00, 0xF3, 0xC0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE3,
  0xE0, 0x38, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF1, 0xE1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xBC, 0x0F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0x20, 0x0C, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF8, 0x40, 0xC3,
  0xC7, 0xC7, 0xE3, 0xC3, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xE3, 0xF0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xE1,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xCF, 0x00, 0x00, 0x20, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x98, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0xF8,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x81, 0xE3, 0xC1, 0xF3, 0xC0, 0xF1, 0xE1, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF8, 0x11, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x30,
  0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x37, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x81,
  0xF0, 0xF0, 0x7C, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3E,
  0x1F, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF3, 0xC0, 0x00, 0x78, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x3C,
  0xF0, 0x3E, 0x78, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x10, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x08, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x87, 0xC0,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0xF8, 0x3E, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xCF,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x07, 0x0F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xB8,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78,
  0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x11,
  0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x81, 0x03, 0xE0, 0x71, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x1E, 0x3E, 0x07, 0x9E, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE, 0x01, 0xE7,
  0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x80, 0x7F, 0xCF, 0xFB, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x4F, 0xF9, 0xFF,
  0x1F, 0xE0, 0x00, 0x81, 0x81, 0xFE, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xE3, 0x8E, 0x3C, 0x73, 0xC7, 0x9E, 0x78, 0xE3, 0x8E, 0x1C, 0x71, 0xC3,
  0x8E, 0x38, 0xF3, 0xCF, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xF1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3E, 0x7C, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x3E, 0xFC, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0x78, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x87, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x07, 0xC3, 0xC7, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78,
  0x1F, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE3, 0xC1, 0xE1,
  0xF1, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x03,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF8, 0x10, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x60, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x41,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF1, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0x3C, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0,
  0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x07, 0x38, 0x71, 0xE7,
  0x0E, 0x38, 0xE3, 0xC7, 0x1C, 0x79, 0xE3, 0x9F, 0x38, 0x73, 0xE7, 0x1E,
  0xED, 0xE3, 0xB9, 0xB8, 0x77, 0x37, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x78, 0x3E,
  0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0x9E, 0x01, 0xF1, 0xE0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8,
  0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8,
  0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x19, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x7C, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0x02, 0x1F, 0xC1, 0xDF, 0xFB, 0xCF, 0xFF, 0xEF, 0x1F, 0xE7, 0x07, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 10, 23, 18, 5, -23 },
  { 30, 13, 10, 18, 6, -25 },
  { 47, 20, 23, 18, 0, -23 },
  { 105, 17, 30, 18, 1, -26 },
  { 169, 22, 24, 18, -1, -23 },
  { 235, 18, 23, 18, 0, -23 },
  { 287, 6, 11, 18, 9, -25 },
  { 296, 14, 32, 18, 4, -26 },
  { 352, 15, 32, 18, 0, -26 },
  { 412, 15, 14, 18, 3, -23 },
  { 439, 16, 17, 18, 1, -18 },
  { 473, 9, 12, 18, 2, -6 },
  { 487, 11, 4, 18, 4, -11 },
  { 493, 6, 6, 18, 5, -6 },
  { 498, 22, 32, 18, -2, -26 },
  { 586, 17, 24, 18, 1, -23 },
  { 637, 15, 23, 18, 1, -23 },
  { 681, 18, 23, 18, 0, -23 },
  { 733, 18, 24, 18, 0, -23 },
  { 787, 18, 23, 18, 0, -23 },
  { 839, 19, 24, 18, 0, -23 },
  { 896, 17, 24, 18, 2, -23 },
  { 947, 18, 23, 18, 3, -23 },
  { 999, 18, 24, 18, 1, -23 },
  { 1053, 17, 23, 18, 1, -23 },
  { 1102, 9, 17, 18, 5, -17 },
  { 1122, 12, 23, 18, 2, -17 },
  { 1157, 17, 15, 18, 1, -17 },
  { 1189, 18, 11, 18, 0, -15 },
  { 1214, 16, 15, 18, 1, -17 },
  { 1244, 14, 23, 18, 4, -23 },
  { 1285, 18, 28, 18, 1, -23 },
  { 1348, 18, 23, 18, -2, -23 },
  { 1400, 18, 23, 18, 0, -23 },
  { 1452, 18, 24, 18, 2, -23 },
  { 1506, 18, 23, 18, 0, -23 },
  { 1558, 19, 23, 18, 1, -23 },
  { 1613, 19, 23, 18, 1, -23 },
  { 1668, 18, 24, 18, 2, -23 },
  { 1722, 20, 23, 18, 0, -23 },
  { 1780, 20, 23, 18, 0, -23 },
  { 1838, 19, 24, 18, 0, -23 },
  { 1895, 21, 23, 18, 0, -23 },
  { 1956, 15, 23, 18, 0, -23 },
  { 2000, 21, 23, 18, -1, -23 },
  { 2061, 20, 23, 18, 0, -23 },
  { 2119, 18, 24, 18, 1, -23 },
  { 2173, 19, 23, 18, 0, -23 },
  { 2228, 18, 29, 18, 1, -23 },
  { 2294, 18, 23, 18, 0, -23 },
  { 2346, 19, 24, 18, 0, -23 },
  { 2403, 17, 23, 18, 4, -23 },
  { 2452, 19, 24, 18, 1, -23 },
  { 2509, 17, 23, 18, 4, -23 },
  { 2558, 21, 23, 18, 0, -23 },
  { 2619, 22, 23, 18, -1, -23 },
  { 2683, 18, 23, 18, 4, -23 },
  { 2735, 20, 23, 18, 0, -23 },
  { 2793, 18, 32, 18, 2, -26 },
  { 2865, 7, 32, 18, 6, -26 },
  { 2893, 18, 32, 18, -1, -26 },
  { 2965, 16, 13, 18, 2, -23 },
  { 2991, 18, 3, 18, -3, 3 },
  { 2998, 7, 7, 18, 8, -26 },
  { 3005, 17, 18, 18, 1, -18 },
  { 3044, 17, 26, 18, 0, -26 },
  { 3100, 17, 18, 18, 1, -18 },
  { 3139, 19, 26, 18, 1, -26 },
  { 3201, 17, 18, 18, 1, -18 },
  { 3240, 23, 32, 18, -2, -26 },
  { 3332, 19, 24, 18, -1, -18 },
  { 3389, 17, 26, 18, 0, -26 },
  { 3445, 12, 26, 18, 3, -26 },
  { 3484, 18, 32, 18, -1, -26 },
  { 3556, 18, 26, 18, 1, -26 },
  { 3615, 11, 25, 18, 4, -25 },
  { 3650, 19, 18, 18, -1, -18 },
  { 3693, 17, 18, 18, 0, -18 },
  { 3732, 16, 18, 18, 1, -18 },
  { 3768, 18, 24, 18, -1, -18 },
  { 3822, 17, 24, 18, 1, -18 },
  { 3873, 17, 18, 18, 1, -18 },
  { 3912, 16, 18, 18, 1, -18 },
  { 3948, 15, 22, 18, 3, -22 },
  { 3990, 16, 17, 18, 2, -17 },
  { 4024, 16, 17, 18, 3, -17 },
  { 4058, 19, 17, 18, 1, -17 },
  { 4099, 20, 17, 18, -1, -17 },
  { 4142, 22, 23, 18, -3, -17 },
  { 4206, 17, 17, 18, 1, -17 },
  { 4243, 18, 32, 18, 2, -26 },
  { 4315, 11, 32, 18, 4, -26 },
  { 4359, 17, 32, 18, -1, -26 },
  { 4427, 17, 6, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC33PT7B_H_
