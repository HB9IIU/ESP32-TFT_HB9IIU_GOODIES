#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC18PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x67, 0x31, 0x8C, 0x06, 0x39, 0x80, 0x66, 0xCD, 0xBE,
  0x6C, 0xD9, 0x00, 0x06, 0xE1, 0x98, 0x32, 0xBF, 0xE1, 0x98, 0x26, 0x0C,
  0xC7, 0xFE, 0xFF, 0x8C, 0xC1, 0x30, 0x66, 0x00, 0x03, 0x00, 0xC0, 0xFC,
  0x7F, 0x38, 0x0E, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x19, 0x0E, 0xFF,
  0x0F, 0x01, 0x80, 0x60, 0x0C, 0x08, 0xF1, 0x8D, 0x98, 0x6D, 0x83, 0x58,
  0x1E, 0x80, 0x48, 0x00, 0xD8, 0x0D, 0x60, 0xDB, 0x0C, 0xD8, 0x46, 0x8C,
  0x3C, 0x00, 0x07, 0x07, 0xE1, 0x98, 0x46, 0x13, 0x07, 0x81, 0xCC, 0xF6,
  0x67, 0xB1, 0xCC, 0x33, 0xFC, 0x7D, 0x80, 0x6F, 0xED, 0x80, 0x03, 0x07,
  0x0C, 0x18, 0x38, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0xF0, 0x40, 0x18, 0x9A, 0xF7, 0x7E,
  0x3C, 0x6E, 0x64, 0x0C, 0x06, 0x03, 0x03, 0x1F, 0xF7, 0xF8, 0x60, 0x60,
  0x30, 0x00, 0x39, 0xCE, 0x2F, 0x60, 0x7F, 0xF0, 0xFF, 0x80, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x00,
  0x0E, 0x0F, 0x8C, 0xEC, 0x36, 0x1E, 0x4F, 0x77, 0xB7, 0xC3, 0x61, 0xB1,
  0x9F, 0xC7, 0xC0, 0x07, 0x1E, 0x7E, 0x2E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0xFE, 0xFE, 0x07, 0x0F, 0xE1, 0x9C, 0x03, 0x01, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0x07, 0xE1, 0x1C,
  0x07, 0x01, 0x81, 0xE0, 0xE0, 0x5C, 0x01, 0x80, 0x60, 0x3B, 0xFC, 0xFE,
  0x00, 0x01, 0xC0, 0xF0, 0x78, 0x36, 0x19, 0x8C, 0xE6, 0x33, 0xFF, 0xFF,
  0x81, 0xC0, 0x60, 0x18, 0x0F, 0xC2, 0x01, 0x80, 0x60, 0x1C, 0x0F, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0xEF, 0xF3, 0xF8, 0x00, 0x87, 0xC7, 0x86, 0x06,
  0x03, 0xF3, 0xFD, 0x86, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x7F, 0xC1,
  0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x00,
  0x0E, 0x1F, 0xCC, 0x6E, 0x37, 0x19, 0x98, 0xF8, 0xDC, 0xC3, 0x61, 0xB0,
  0xDF, 0xC7, 0xC0, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x30, 0xCC, 0x33, 0xBC,
  0x7F, 0x01, 0x80, 0xE0, 0x71, 0xF8, 0xF8, 0x00, 0x37, 0x70, 0x00, 0xEE,
  0xE0, 0x0C, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x38, 0x4F, 0x30, 0x03, 0x87,
  0xDF, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x04, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0x7F, 0xBF, 0xE0, 0x30, 0x1E, 0x03, 0xE0, 0x70, 0x79, 0xF3, 0xE1, 0x80,
  0x1C, 0x7F, 0x47, 0x07, 0x06, 0x0C, 0x38, 0x30, 0x70, 0x00, 0x60, 0xF0,
  0x60, 0x07, 0x81, 0xF8, 0x63, 0x18, 0x32, 0x3C, 0xCF, 0x9B, 0x32, 0x66,
  0x48, 0x99, 0x33, 0x3E, 0x27, 0xC6, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x03,
  0x81, 0xE0, 0x78, 0x32, 0x0C, 0xC6, 0x31, 0x8C, 0xFF, 0x3F, 0xD8, 0x36,
  0x0F, 0x83, 0x0F, 0x07, 0xE1, 0x9C, 0xC3, 0x30, 0xCC, 0xE3, 0xF1, 0xCE,
  0x61, 0x98, 0x66, 0x3B, 0xFC, 0xFE, 0x00, 0x07, 0x07, 0xF3, 0x89, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xF8, 0x7E, 0x00,
  0x0E, 0x07, 0xE3, 0xB8, 0xC7, 0x30, 0xCC, 0x37, 0x1D, 0x87, 0x61, 0x98,
  0xEE, 0x73, 0xF8, 0xFC, 0x00, 0x1F, 0xE3, 0x00, 0x60, 0x1C, 0x03, 0xF8,
  0x7F, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x7F, 0x0F, 0xE1, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0x00, 0x07, 0x07, 0xF3, 0x89, 0xC0, 0x60, 0x38, 0x0C, 0x0B,
  0x0C, 0xC3, 0x30, 0xCE, 0x73, 0xF8, 0x7E, 0x00, 0x18, 0x67, 0x1C, 0xC3,
  0x18, 0x63, 0x0C, 0xFF, 0x98, 0x63, 0x0C, 0x61, 0x9C, 0x73, 0x0C, 0x61,
  0x80, 0x1F, 0xE0, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x81, 0xFC, 0x7F, 0x80, 0x0F, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x11, 0xCF, 0xE1, 0xF0, 0x18, 0xE7, 0x38,
  0xCE, 0x1B, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0x30, 0x67, 0x0C, 0x63, 0x8C,
  0x61, 0xC0, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x7F, 0xFF, 0x0C, 0x71, 0xC6, 0x1C, 0xE1, 0xCE, 0x15, 0xE3, 0x76, 0x36,
  0x63, 0x64, 0x60, 0xC6, 0x0C, 0x60, 0xCE, 0x1C, 0x18, 0x67, 0x0C, 0xF3,
  0x1E, 0x63, 0x4C, 0xC9, 0x99, 0xE3, 0x3C, 0x67, 0x98, 0x73, 0x0C, 0x61,
  0x80, 0x0E, 0x0F, 0x8C, 0xEC, 0x36, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0x61,
  0xB1, 0xDF, 0xC7, 0xC0, 0x0F, 0x07, 0xF1, 0x9C, 0xE3, 0x30, 0xCC, 0x33,
  0x3D, 0xFE, 0x7C, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x0F, 0x8C,
  0xEC, 0x36, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0x61, 0xB1, 0x9F, 0xC7, 0xC1,
  0x80, 0xE8, 0x38, 0x0E, 0x07, 0xE3, 0x9C, 0xC3, 0x30, 0xCC, 0x73, 0xF9,
  0xFC, 0x66, 0x19, 0xC6, 0x33, 0x8C, 0xC3, 0x80, 0x07, 0x87, 0xF1, 0x84,
  0xC0, 0x38, 0x0F, 0x01, 0xF0, 0x1C, 0x03, 0x80, 0x68, 0x3B, 0xFC, 0xFE,
  0x00, 0xFF, 0x8E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x00, 0x31, 0xDC, 0x66, 0x19, 0x86, 0x63, 0xB8, 0xCC, 0x33,
  0x0C, 0xC7, 0x31, 0x8F, 0xE1, 0xF0, 0xC1, 0xF0, 0xEC, 0x33, 0x0C, 0xC6,
  0x31, 0x8C, 0xC3, 0x30, 0xD8, 0x36, 0x07, 0x01, 0x80, 0x38, 0x66, 0x0C,
  0xC1, 0x98, 0x66, 0x6C, 0xDD, 0x9B, 0xB3, 0xFC, 0x53, 0x8E, 0x73, 0x8C,
  0x61, 0x80, 0x1C, 0x78, 0x63, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xB0, 0x19, 0x81, 0xCC, 0x1C, 0x71, 0xC3, 0x80, 0xC1, 0xF8,
  0xC6, 0x71, 0x98, 0x6C, 0x1F, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x1F, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xC3, 0xE0, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xFC, 0x00, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x77, 0x33, 0x33,
  0x30, 0x0F, 0x8F, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0xF8, 0x00, 0x0E, 0x0F, 0x86,
  0xC6, 0x66, 0x3F, 0x0D, 0x04, 0xFF, 0xFF, 0xC0, 0x4E, 0x71, 0x0E, 0x1F,
  0xDC, 0xDC, 0x6C, 0x36, 0x3B, 0x19, 0x8C, 0xFE, 0x3F, 0x80, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0xE1, 0xFC, 0xE6, 0x63, 0x71, 0xB0, 0xD8, 0x6C, 0x6F,
  0xF7, 0xE0, 0x0F, 0x1F, 0xDE, 0x5C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFE,
  0x3F, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x07, 0x8F, 0xE7, 0x33, 0x8C,
  0xC3, 0x31, 0xCC, 0x63, 0x18, 0xFE, 0x1F, 0xC0, 0x0E, 0x1F, 0x9C, 0xFC,
  0x7C, 0x77, 0xF3, 0x81, 0x80, 0xFE, 0x3F, 0x00, 0x00, 0xF0, 0x3F, 0x03,
  0x00, 0x30, 0x07, 0x01, 0xFE, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC1,
  0xFC, 0x73, 0x9C, 0x63, 0x0C, 0x61, 0x8C, 0x71, 0xDC, 0x1F, 0x80, 0x30,
  0x0E, 0x3F, 0x8F, 0xE0, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0xE1, 0xFC, 0xCE,
  0x63, 0x71, 0xB0, 0xD8, 0xEC, 0x6E, 0x36, 0x38, 0x18, 0x71, 0x80, 0x03,
  0xE3, 0x8C, 0x30, 0xC7, 0x1C, 0x7C, 0xF0, 0x00, 0xC0, 0x70, 0x0C, 0x00,
  0x00, 0x03, 0xF1, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x61, 0xF8, 0xFC, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x82,
  0x73, 0x8C, 0xE1, 0xB8, 0x3C, 0x0F, 0x81, 0x98, 0x33, 0x86, 0x31, 0xC7,
  0x00, 0x7F, 0xE1, 0x86, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x7D, 0xF0,
  0x09, 0x8F, 0xF2, 0x6D, 0x93, 0x6C, 0x9B, 0x64, 0x1B, 0x06, 0xC1, 0xB0,
  0xC0, 0x0E, 0x1F, 0xCC, 0xE6, 0x33, 0x1B, 0x8D, 0x8E, 0xC6, 0x63, 0x71,
  0x80, 0x0C, 0x3F, 0x73, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0x07,
  0x07, 0xF1, 0x8C, 0x63, 0x38, 0xCC, 0x33, 0x0C, 0xC6, 0x7F, 0x9F, 0x86,
  0x01, 0x80, 0xE0, 0x00, 0x0E, 0x1F, 0xDC, 0xFC, 0x6C, 0x36, 0x1B, 0x1D,
  0x8C, 0xFE, 0x3F, 0x03, 0x81, 0x80, 0xC0, 0x0F, 0x1F, 0xCE, 0x4E, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x07, 0x0F, 0xCE, 0x26, 0x03,
  0xC0, 0xF8, 0x0C, 0x06, 0x7F, 0x7F, 0x00, 0x38, 0x30, 0x30, 0xFF, 0x30,
  0x70, 0x60, 0x60, 0x60, 0xE0, 0x7C, 0x7C, 0x63, 0xB1, 0x98, 0xDC, 0x6C,
  0x76, 0x33, 0x19, 0xFC, 0x7F, 0x00, 0xC3, 0xC7, 0xC6, 0xCE, 0xCC, 0xD8,
  0xF8, 0x70, 0x60, 0xC0, 0xF0, 0x6C, 0x9B, 0x76, 0xDF, 0x2F, 0xCE, 0xE3,
  0x38, 0xCE, 0x00, 0x18, 0xE1, 0xB8, 0x36, 0x03, 0x80, 0x70, 0x1E, 0x06,
  0xE1, 0x8C, 0xE1, 0xC0, 0x18, 0x63, 0x1C, 0x63, 0x0C, 0xE1, 0x98, 0x3F,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0x83, 0xE0, 0x78, 0x00, 0x3F, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xC1, 0xE0,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0xF0, 0x3C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0xC0, 0x3C, 0x00, 0x0C, 0x31, 0xC6, 0x18, 0x61,
  0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38, 0xC0, 0x0F, 0x03, 0xE0, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0xF0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0xF8, 0x00, 0x38, 0xDF, 0xEC, 0x78,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 7, 6, 10, 3, -14 },
  { 15, 11, 12, 10, 0, -12 },
  { 32, 10, 16, 10, 0, -14 },
  { 52, 13, 13, 10, -1, -13 },
  { 74, 10, 13, 10, 0, -13 },
  { 91, 3, 6, 10, 5, -14 },
  { 94, 8, 17, 10, 2, -14 },
  { 111, 8, 17, 10, 0, -14 },
  { 128, 8, 7, 10, 2, -12 },
  { 135, 9, 9, 10, 1, -10 },
  { 146, 5, 6, 10, 1, -3 },
  { 150, 6, 2, 10, 2, -6 },
  { 152, 3, 3, 10, 3, -3 },
  { 154, 12, 17, 10, -1, -14 },
  { 180, 9, 13, 10, 1, -13 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 10, 13, 10, 0, -13 },
  { 224, 10, 13, 10, 0, -13 },
  { 241, 10, 12, 10, 0, -12 },
  { 256, 10, 12, 10, 0, -12 },
  { 271, 9, 13, 10, 1, -13 },
  { 286, 9, 12, 10, 2, -12 },
  { 300, 9, 13, 10, 1, -13 },
  { 315, 10, 13, 10, 0, -13 },
  { 332, 4, 9, 10, 3, -9 },
  { 337, 6, 12, 10, 1, -9 },
  { 346, 9, 8, 10, 1, -9 },
  { 355, 10, 6, 10, 0, -8 },
  { 363, 9, 8, 10, 0, -9 },
  { 372, 8, 13, 10, 2, -13 },
  { 385, 11, 16, 10, 0, -13 },
  { 407, 10, 12, 10, -1, -12 },
  { 422, 10, 13, 10, 0, -13 },
  { 439, 10, 13, 10, 1, -13 },
  { 456, 10, 13, 10, 0, -13 },
  { 473, 11, 12, 10, 0, -12 },
  { 490, 11, 12, 10, 0, -12 },
  { 507, 10, 13, 10, 1, -13 },
  { 524, 11, 12, 10, 0, -12 },
  { 541, 11, 12, 10, 0, -12 },
  { 558, 10, 12, 10, 0, -12 },
  { 573, 11, 12, 10, 0, -12 },
  { 590, 8, 12, 10, 0, -12 },
  { 602, 12, 12, 10, -1, -12 },
  { 620, 11, 12, 10, 0, -12 },
  { 637, 9, 13, 10, 1, -13 },
  { 652, 10, 13, 10, 0, -13 },
  { 669, 9, 16, 10, 1, -13 },
  { 687, 10, 13, 10, 0, -13 },
  { 704, 10, 13, 10, 0, -13 },
  { 721, 9, 12, 10, 2, -12 },
  { 735, 10, 12, 10, 1, -12 },
  { 750, 10, 12, 10, 2, -12 },
  { 765, 11, 12, 10, 0, -12 },
  { 782, 13, 12, 10, -1, -12 },
  { 802, 10, 12, 10, 2, -12 },
  { 817, 11, 12, 10, 0, -12 },
  { 834, 10, 17, 10, 1, -14 },
  { 856, 4, 17, 10, 3, -14 },
  { 865, 9, 17, 10, 0, -14 },
  { 885, 9, 7, 10, 1, -12 },
  { 893, 9, 2, 10, -1, 1 },
  { 896, 4, 4, 10, 4, -14 },
  { 898, 9, 10, 10, 1, -10 },
  { 910, 9, 14, 10, 0, -14 },
  { 926, 9, 10, 10, 1, -10 },
  { 938, 10, 14, 10, 1, -14 },
  { 956, 9, 10, 10, 1, -10 },
  { 968, 12, 17, 10, -1, -14 },
  { 994, 11, 13, 10, -1, -10 },
  { 1012, 9, 14, 10, 0, -14 },
  { 1028, 6, 14, 10, 2, -14 },
  { 1039, 10, 17, 10, -1, -14 },
  { 1061, 11, 14, 10, 0, -14 },
  { 1081, 6, 14, 10, 2, -14 },
  { 1092, 10, 10, 10, 0, -10 },
  { 1105, 9, 10, 10, 0, -10 },
  { 1117, 8, 10, 10, 1, -10 },
  { 1127, 10, 13, 10, -1, -10 },
  { 1144, 9, 13, 10, 1, -10 },
  { 1159, 9, 10, 10, 1, -10 },
  { 1171, 9, 10, 10, 0, -10 },
  { 1183, 8, 12, 10, 2, -12 },
  { 1195, 9, 9, 10, 1, -9 },
  { 1206, 8, 9, 10, 2, -9 },
  { 1215, 10, 9, 10, 1, -9 },
  { 1227, 11, 9, 10, -1, -9 },
  { 1240, 11, 12, 10, -1, -9 },
  { 1257, 10, 9, 10, 0, -9 },
  { 1269, 10, 17, 10, 1, -14 },
  { 1291, 6, 17, 10, 2, -14 },
  { 1304, 10, 17, 10, -1, -14 },
  { 1326, 10, 3, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC18PT7B_H_
