#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC22PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x30, 0x60, 0x01, 0x0F,
  0x1E, 0x3C, 0x00, 0x73, 0x67, 0xE7, 0xE7, 0xE6, 0xC6, 0xC4, 0x03, 0x38,
  0x39, 0x81, 0x8C, 0x0C, 0xC3, 0xFF, 0xBF, 0xFC, 0x73, 0x03, 0x18, 0x19,
  0x87, 0xFF, 0xBF, 0xF8, 0xE6, 0x06, 0x70, 0x33, 0x03, 0x38, 0x00, 0x00,
  0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0x1E, 0x71, 0xC0, 0x1C, 0x01, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0xE4, 0x0E, 0x7F, 0xCF, 0xF8, 0x1E,
  0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x1E, 0x1C, 0x6C, 0x30, 0xD8, 0xC3,
  0x33, 0x06, 0x6C, 0x07, 0xB0, 0x0E, 0xC0, 0x03, 0x80, 0x06, 0xE0, 0x1B,
  0x60, 0x64, 0xC1, 0x99, 0x86, 0x33, 0x1C, 0x6C, 0x70, 0x70, 0x01, 0x80,
  0x7C, 0x0E, 0xE1, 0xC6, 0x18, 0xE1, 0x8C, 0x1F, 0x80, 0xF0, 0x1E, 0x73,
  0x76, 0x63, 0x6E, 0x3C, 0xE1, 0xCE, 0x3C, 0x7F, 0xC7, 0xEE, 0x77, 0x76,
  0xEE, 0xC0, 0x01, 0x83, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x40, 0x00, 0x0E, 0x03, 0x06, 0xCF, 0xFF, 0x7F, 0xC7,
  0x83, 0xF1, 0xCE, 0x33, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF,
  0xFF, 0xBF, 0xF0, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x3B, 0xDE, 0x71,
  0xBB, 0x90, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xF8, 0x7F,
  0x9C, 0x73, 0x06, 0xE0, 0xD9, 0x1F, 0x77, 0xEE, 0xFC, 0x9F, 0x83, 0x70,
  0xEE, 0x19, 0xC7, 0x1F, 0xC3, 0xF0, 0x03, 0x83, 0xC7, 0xE7, 0xF3, 0x30,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC7, 0xFF, 0xFE, 0x01,
  0x80, 0xFE, 0x1F, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xFC, 0x03,
  0x81, 0xFE, 0x0F, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0xFC, 0x0F,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE4, 0x1C, 0xFF, 0xCF, 0xF0, 0x00,
  0x70, 0x0F, 0x01, 0xF0, 0x36, 0x06, 0x60, 0xCE, 0x18, 0xE3, 0x0C, 0x70,
  0xC7, 0xFF, 0xFF, 0xE0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x07, 0xF8,
  0x7F, 0x83, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x7E, 0x03, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC4, 0x1C, 0x7F, 0xC3, 0xFC, 0x00, 0x03,
  0xF0, 0xFE, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x20, 0x7F, 0x8F, 0xFC, 0xE0,
  0xCE, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x7F, 0xF7,
  0xFE, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xF8,
  0x7F, 0x9C, 0x33, 0x06, 0x71, 0xCE, 0x30, 0xFC, 0x3F, 0x0E, 0x73, 0x87,
  0x60, 0xEC, 0x1D, 0xC7, 0xBF, 0xE3, 0xF8, 0x03, 0x03, 0xF8, 0xFF, 0xB8,
  0x77, 0x06, 0xE0, 0xDC, 0x1B, 0x87, 0x7F, 0xE7, 0xFC, 0x07, 0x00, 0xE0,
  0x78, 0x3E, 0x3F, 0x07, 0x80, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x73,
  0xCF, 0x3C, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE1,
  0xC1, 0x8E, 0x38, 0x40, 0x00, 0x20, 0x1C, 0x0F, 0x8F, 0xC7, 0xE1, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x70, 0x02, 0x00, 0x3F, 0xF3, 0xFF, 0x40,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x10, 0x03, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x0E, 0x03, 0xE1, 0xF8, 0xFE, 0x07, 0x00, 0x40, 0x00,
  0x0C, 0x3F, 0x9F, 0xE8, 0x70, 0x38, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x1C,
  0x00, 0x06, 0x07, 0x83, 0xC1, 0xC0, 0x01, 0x80, 0xFE, 0x1E, 0xF3, 0x87,
  0x70, 0x36, 0x3F, 0x67, 0xFC, 0xE6, 0xCC, 0x6D, 0xCE, 0xDC, 0xED, 0xCC,
  0xDC, 0xCC, 0xFC, 0xC7, 0xCC, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x66, 0x0E, 0x60, 0xC7, 0x1C,
  0x71, 0xFF, 0x3F, 0xF3, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x70, 0x1F, 0xE1,
  0xFF, 0x1C, 0x71, 0x83, 0x18, 0x73, 0x8E, 0x3F, 0xC3, 0xFC, 0x30, 0xE7,
  0x06, 0x70, 0x67, 0x0E, 0x61, 0xEF, 0xFC, 0xFF, 0x00, 0x01, 0xC0, 0x7F,
  0x1F, 0xF1, 0xC2, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x08, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE,
  0x1C, 0xF1, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x0E,
  0x70, 0xE6, 0x1C, 0xE3, 0xCF, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0x87, 0xF8, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x02, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC7, 0xFC, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x7F, 0x1F,
  0xF3, 0xC2, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0xEE, 0x0C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCF, 0x18, 0x7F, 0x83, 0xF8, 0x1C, 0x18, 0xE1, 0xC7,
  0x0E, 0x30, 0x73, 0x83, 0x1C, 0x38, 0xFF, 0xC7, 0xFE, 0x70, 0x63, 0x87,
  0x1C, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x86, 0x38, 0x7F, 0xC1, 0xFC, 0x00, 0x1C,
  0x3C, 0x71, 0xC1, 0xCF, 0x06, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0xF0, 0x0F,
  0x80, 0x37, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0x70, 0x61, 0xC3, 0x87, 0x0E,
  0x0E, 0x00, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFC, 0x06, 0x1C, 0x38,
  0x70, 0xE3, 0xC3, 0xCB, 0x1B, 0x78, 0x6D, 0x61, 0xBD, 0x8E, 0xE6, 0x33,
  0xB8, 0xCC, 0xE3, 0x03, 0x1C, 0x0C, 0x60, 0x71, 0x81, 0xCE, 0x06, 0x00,
  0x1C, 0x18, 0xE0, 0xC7, 0x8E, 0x3C, 0x73, 0xE3, 0x1F, 0x98, 0xCD, 0xC6,
  0x6E, 0x73, 0x63, 0x9B, 0x18, 0x78, 0xC3, 0xCE, 0x1C, 0x70, 0xE3, 0x07,
  0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x06, 0xE0, 0xD8, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x1D, 0xC7, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE0, 0xFF, 0x87, 0x1E, 0x38, 0x71, 0x83, 0x9C, 0x18, 0xE1, 0xC7, 0xFC,
  0x3F, 0xC3, 0xF0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x06, 0xE0, 0xD8, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x1D, 0xC7, 0x1F, 0xC3, 0xF0, 0x18, 0x03,
  0x80, 0x7C, 0x03, 0x80, 0x1F, 0xE1, 0xFF, 0x1C, 0x71, 0x87, 0x38, 0x73,
  0x87, 0x38, 0xE3, 0xFE, 0x3F, 0x87, 0x38, 0x73, 0x87, 0x1C, 0x61, 0xCE,
  0x0C, 0xE0, 0xE0, 0x01, 0xC0, 0x7F, 0xC7, 0xFC, 0x38, 0x21, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x20, 0xE3, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x00, 0x38, 0x73, 0x87, 0x30, 0x77, 0x06, 0x70, 0xE7,
  0x0E, 0x60, 0xE6, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8F,
  0xF0, 0x7E, 0x00, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0x61, 0xC6, 0x1C,
  0x63, 0x86, 0x38, 0x67, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x00, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x8E, 0x06, 0x30, 0x38, 0xCC,
  0xC3, 0x73, 0x1D, 0xCC, 0x6D, 0x71, 0xB5, 0x87, 0x96, 0x1E, 0x78, 0x71,
  0xC3, 0xC7, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0xE0, 0x3B,
  0x80, 0x36, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x1D, 0x80,
  0x3B, 0x80, 0xE7, 0x03, 0x86, 0x0E, 0x0C, 0x3C, 0x1C, 0x00, 0xC0, 0xFC,
  0x3B, 0x87, 0x71, 0xC6, 0x70, 0xCE, 0x1F, 0x83, 0xE0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xE0, 0xFE, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0x8E, 0x73, 0x9C, 0xE7,
  0x38, 0xC6, 0x31, 0x8E, 0x73, 0x80, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x7E, 0x0F, 0xC0, 0x03,
  0x80, 0xF0, 0x3F, 0x0E, 0xE3, 0x9C, 0x71, 0xDC, 0x3F, 0x07, 0x7F, 0xFF,
  0xFE, 0x47, 0x1E, 0x30, 0x80, 0x07, 0xC3, 0xFC, 0xFF, 0xB8, 0x6E, 0x1D,
  0xC3, 0xB8, 0x76, 0x0C, 0xC3, 0x9C, 0x73, 0xFE, 0x3E, 0xE0, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3F, 0x07, 0xF9, 0xFF, 0x38, 0x67, 0x0C,
  0xC1, 0xB8, 0x37, 0x0E, 0xE1, 0xD8, 0xF7, 0xFC, 0xFF, 0x00, 0x07, 0xC3,
  0xFC, 0xFF, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x11,
  0xFE, 0x1F, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x7E,
  0x1F, 0xE3, 0xFE, 0x70, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x18,
  0xE3, 0x8F, 0xF8, 0x7D, 0xC0, 0x07, 0x83, 0xF8, 0xF7, 0xB8, 0x76, 0x0F,
  0xC7, 0xBF, 0xE7, 0xE0, 0xE0, 0x1C, 0x11, 0xFE, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0x90, 0x0E, 0x00, 0x38, 0x01, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x02, 0x70, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0xC3, 0xDE, 0x38, 0x71, 0x83, 0x1C, 0x38,
  0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x1C, 0x21,
  0xE3, 0xFE, 0x0F, 0xE0, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3F,
  0x07, 0xF9, 0xFF, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x98,
  0x73, 0x0E, 0xE1, 0x80, 0x0E, 0x0E, 0x0E, 0x04, 0x00, 0x7C, 0xFC, 0xFC,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x02, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x47, 0x0F, 0xF0, 0x7E, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x1C, 0x71, 0xC3, 0x1C, 0x19, 0xC1, 0xFC, 0x0F, 0x80, 0x7E,
  0x03, 0x70, 0x39, 0xC1, 0xC7, 0x0E, 0x38, 0xE0, 0xE0, 0xFD, 0xF8, 0x70,
  0xE1, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x1C, 0xBF, 0x7E,
  0x0E, 0x63, 0xFF, 0x33, 0x73, 0x33, 0x73, 0x76, 0x77, 0x66, 0x66, 0x66,
  0x60, 0x6E, 0x0E, 0xC0, 0xCC, 0x0C, 0x07, 0x83, 0xFC, 0x7F, 0x9C, 0x73,
  0x86, 0x71, 0xCC, 0x3B, 0x87, 0x70, 0xCE, 0x39, 0x87, 0x70, 0xE0, 0x0F,
  0x03, 0xF8, 0xFF, 0x38, 0x6E, 0x0F, 0xC1, 0xB8, 0x37, 0x0E, 0xE1, 0xDC,
  0x73, 0xFC, 0x3F, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xBC, 0x38, 0x61, 0xC3,
  0x8C, 0x18, 0xE0, 0xC7, 0x0E, 0x38, 0xF1, 0x8F, 0x0F, 0xF0, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xB8, 0x76,
  0x0D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0xFE, 0x3F, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xE7, 0xFC, 0xFF, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x07, 0xC1, 0xFC,
  0x7B, 0x8C, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xC8, 0x39, 0xFE,
  0x7F, 0x80, 0x0C, 0x07, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xF3, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x71, 0x1F, 0xC3, 0xF0, 0x30, 0xEE, 0x1D,
  0xC3, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0x73, 0xFE,
  0x3E, 0xE0, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xCE, 0x39, 0xC3,
  0x70, 0x6E, 0x0F, 0x81, 0xE0, 0x38, 0x00, 0x60, 0x36, 0x03, 0xE0, 0x7E,
  0x66, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xEC, 0xF7, 0x8F, 0x38, 0xE3, 0x8C,
  0x30, 0x1C, 0x1C, 0x70, 0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x73, 0x83, 0x8E, 0x3C, 0x3C, 0x0E, 0x0E,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xC0, 0xE3, 0x80, 0xC6, 0x01, 0x9C, 0x03,
  0xB0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x09, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xF0,
  0x3F, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x07,
  0xC0, 0x70, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x38, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x07, 0xC0, 0xF8, 0x00, 0x08,
  0x23, 0xE3, 0x7F, 0xEE, 0x3E, 0x21, 0x80,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 15, 12, 3, -15 },
  { 15, 8, 7, 12, 4, -17 },
  { 22, 13, 15, 12, 0, -15 },
  { 47, 12, 19, 12, 0, -17 },
  { 76, 15, 16, 12, -1, -16 },
  { 106, 12, 16, 12, 0, -16 },
  { 130, 4, 7, 12, 6, -17 },
  { 134, 9, 21, 12, 3, -17 },
  { 158, 10, 21, 12, 0, -17 },
  { 185, 10, 9, 12, 2, -15 },
  { 197, 11, 11, 12, 1, -12 },
  { 213, 5, 8, 12, 2, -4 },
  { 218, 7, 3, 12, 3, -8 },
  { 221, 4, 4, 12, 3, -4 },
  { 223, 14, 21, 12, -1, -17 },
  { 260, 11, 16, 12, 1, -16 },
  { 282, 9, 15, 12, 1, -15 },
  { 299, 12, 16, 12, 0, -16 },
  { 323, 12, 16, 12, 0, -16 },
  { 347, 12, 15, 12, 0, -15 },
  { 370, 13, 15, 12, 0, -15 },
  { 395, 12, 15, 12, 1, -15 },
  { 418, 12, 15, 12, 2, -15 },
  { 441, 11, 16, 12, 1, -16 },
  { 463, 11, 16, 12, 1, -16 },
  { 485, 6, 12, 12, 3, -12 },
  { 494, 7, 16, 12, 2, -12 },
  { 508, 11, 11, 12, 1, -12 },
  { 524, 12, 7, 12, 0, -10 },
  { 535, 12, 11, 12, 0, -12 },
  { 552, 9, 16, 12, 3, -16 },
  { 570, 12, 19, 12, 1, -16 },
  { 599, 12, 15, 12, -1, -15 },
  { 622, 12, 15, 12, 0, -15 },
  { 645, 12, 16, 12, 1, -16 },
  { 669, 12, 15, 12, 0, -15 },
  { 692, 13, 15, 12, 0, -15 },
  { 717, 12, 15, 12, 1, -15 },
  { 740, 12, 16, 12, 1, -16 },
  { 764, 13, 15, 12, 0, -15 },
  { 789, 13, 15, 12, 0, -15 },
  { 814, 13, 15, 12, 0, -15 },
  { 839, 14, 15, 12, 0, -15 },
  { 866, 10, 15, 12, 0, -15 },
  { 885, 14, 15, 12, -1, -15 },
  { 912, 13, 15, 12, 0, -15 },
  { 937, 11, 16, 12, 1, -16 },
  { 959, 13, 15, 12, 0, -15 },
  { 984, 11, 20, 12, 1, -16 },
  { 1012, 12, 15, 12, 0, -15 },
  { 1035, 13, 16, 12, 0, -16 },
  { 1061, 12, 15, 12, 2, -15 },
  { 1084, 12, 15, 12, 1, -15 },
  { 1107, 12, 15, 12, 2, -15 },
  { 1130, 14, 15, 12, 0, -15 },
  { 1157, 15, 15, 12, -1, -15 },
  { 1186, 11, 15, 12, 3, -15 },
  { 1207, 13, 15, 12, 0, -15 },
  { 1232, 12, 21, 12, 1, -17 },
  { 1264, 5, 21, 12, 4, -17 },
  { 1278, 11, 21, 12, 0, -17 },
  { 1307, 11, 8, 12, 1, -15 },
  { 1318, 12, 2, 12, -2, 2 },
  { 1321, 5, 5, 12, 5, -17 },
  { 1325, 11, 12, 12, 1, -12 },
  { 1342, 11, 17, 12, 0, -17 },
  { 1366, 11, 12, 12, 1, -12 },
  { 1383, 12, 17, 12, 1, -17 },
  { 1409, 11, 12, 12, 1, -12 },
  { 1426, 15, 21, 12, -1, -17 },
  { 1466, 13, 16, 12, -1, -12 },
  { 1492, 11, 17, 12, 0, -17 },
  { 1516, 8, 17, 12, 2, -17 },
  { 1533, 12, 21, 12, -1, -17 },
  { 1565, 13, 17, 12, 0, -17 },
  { 1593, 7, 17, 12, 3, -17 },
  { 1608, 12, 12, 12, 0, -12 },
  { 1626, 11, 12, 12, 0, -12 },
  { 1643, 11, 12, 12, 1, -12 },
  { 1660, 13, 16, 12, -1, -12 },
  { 1686, 11, 16, 12, 1, -12 },
  { 1708, 11, 12, 12, 1, -12 },
  { 1725, 11, 12, 12, 0, -12 },
  { 1742, 10, 15, 12, 2, -15 },
  { 1761, 11, 12, 12, 1, -12 },
  { 1778, 11, 12, 12, 2, -12 },
  { 1795, 12, 12, 12, 1, -12 },
  { 1813, 14, 12, 12, -1, -12 },
  { 1834, 15, 16, 12, -2, -12 },
  { 1864, 12, 12, 12, 0, -12 },
  { 1882, 12, 21, 12, 1, -17 },
  { 1914, 8, 21, 12, 2, -17 },
  { 1935, 12, 21, 12, -1, -17 },
  { 1967, 12, 5, 12, 0, -9 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC22PT7B_H_
