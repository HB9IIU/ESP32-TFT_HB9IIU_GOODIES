#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC30PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x3C, 0x3F, 0x1F, 0x07,
  0x80, 0x79, 0xFE, 0x3F, 0xC7, 0x79, 0xEE, 0x3D, 0xC7, 0x38, 0xE6, 0x1C,
  0xC3, 0x00, 0x00, 0xF1, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x1C, 0x01,
  0xC7, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x40, 0x78, 0xFB, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x70, 0xFC, 0x0E, 0x0E,
  0xE1, 0xC1, 0xCE, 0x18, 0x1C, 0xE3, 0x81, 0x8C, 0x70, 0x18, 0xCE, 0x01,
  0xDD, 0xC0, 0x1F, 0xB8, 0x00, 0xF3, 0x00, 0x00, 0x70, 0x00, 0x0E, 0xF0,
  0x01, 0xDF, 0x80, 0x3B, 0xF8, 0x07, 0x39, 0x80, 0x63, 0x18, 0x0E, 0x71,
  0x81, 0xC7, 0x38, 0x38, 0x73, 0x07, 0x03, 0xF0, 0xE0, 0x3E, 0x00, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x1C, 0x0E,
  0x1C, 0x0F, 0x38, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x87, 0x1F, 0xC7, 0x3D,
  0xEE, 0x78, 0xEE, 0x70, 0xFC, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xFC, 0x7F,
  0xFC, 0x7F, 0xDC, 0x3F, 0x9E, 0x3D, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0xE3,
  0x80, 0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x80, 0x07, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x19, 0xC6, 0x73, 0x7B, 0xFF, 0xEF, 0xFF, 0xC1,
  0xE0, 0x0F, 0xC0, 0x77, 0x87, 0xCF, 0x0E, 0x38, 0x08, 0x40, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x1E, 0x1F, 0x3F, 0x3F, 0x1F, 0x0E, 0x1E, 0xFC, 0xF8,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x1E, 0x1E, 0x0E, 0x3C, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x79, 0xCE, 0x7B, 0xCE, 0x73, 0xCE, 0x73, 0x9E, 0xF0, 0x1E,
  0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x70, 0xF0, 0x7F, 0xF0,
  0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x0F, 0xF1, 0xFF,
  0x0F, 0xF8, 0x73, 0xC2, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0xE1, 0xE0,
  0x40, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x06, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x40, 0x7C,
  0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x38, 0x0F, 0x3C, 0x07,
  0x1E, 0x07, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x87, 0x83, 0xC3, 0xFF, 0xF9,
  0xFF, 0xFD, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x20, 0x3E, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3B, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x78, 0x3C,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8,
  0x38, 0x78, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F,
  0x3C, 0x0E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xDE, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7C,
  0xFC, 0xFC, 0x78, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0x38, 0x1E,
  0x3F, 0x0F, 0x83, 0x80, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x30, 0x1F, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x10, 0x00, 0x78, 0x00, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1E, 0x01, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0xE3, 0xFF,
  0x3F, 0xF2, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x83, 0xF7, 0xC1,
  0xE0, 0xE1, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0xFC, 0xE1, 0xFE, 0x71, 0xFF,
  0x39, 0xE7, 0xB8, 0xE3, 0xDC, 0xF1, 0xCE, 0x70, 0xE7, 0x38, 0x73, 0x9C,
  0x79, 0xCE, 0x38, 0xE7, 0x9C, 0x73, 0xFE, 0x38, 0xFF, 0x1C, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x70,
  0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1,
  0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x1C,
  0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x78, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x78,
  0x1C, 0x3C, 0x1E, 0x1E, 0x7E, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xC3,
  0xC1, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x38, 0x1F,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0x06, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x10, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x1F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x7C, 0x70,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC1, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF0, 0x61, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x07,
  0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x78,
  0x38, 0x3C, 0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x01,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C,
  0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE1, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x38, 0x7C,
  0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0x83, 0xE0, 0xE0, 0xF8,
  0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1C, 0x78, 0x07, 0x9E, 0x00,
  0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xDE, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8, 0x03, 0xC1,
  0xE0, 0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x1D, 0x8F,
  0x83, 0xB3, 0xF0, 0x76, 0x6E, 0x0E, 0xDD, 0xC3, 0x9B, 0x70, 0x73, 0xCE,
  0x0E, 0x79, 0xC3, 0xCE, 0x38, 0x71, 0xCF, 0x0E, 0x01, 0xE1, 0xC0, 0x38,
  0x78, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x00, 0xE0,
  0x07, 0x01, 0xC3, 0xC0, 0x70, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0x87,
  0xF0, 0xE1, 0xFC, 0x38, 0x77, 0x1E, 0x1C, 0xC7, 0x07, 0x39, 0xC3, 0xCE,
  0x70, 0xE3, 0xBC, 0x38, 0x6E, 0x0E, 0x1B, 0x87, 0x87, 0xE1, 0xC1, 0xF8,
  0x70, 0x7C, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x07, 0x87, 0x3F, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x60, 0x07, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x70, 0x3C, 0x78, 0x1E,
  0x3C, 0x0E, 0x1E, 0x0F, 0x0E, 0x0F, 0x0F, 0xFF, 0x87, 0xFF, 0x03, 0xFE,
  0x01, 0xC7, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C,
  0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xC1, 0xE0, 0x60, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x30, 0x1E, 0x1F, 0xFE, 0x1F, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x7C, 0x1F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0x70, 0xF0, 0x71, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80,
  0x77, 0x80, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0xE3, 0x87, 0x3C, 0xF0,
  0xE7, 0x9C, 0x1D, 0xF3, 0x83, 0xB6, 0x70, 0xEE, 0xDC, 0x1D, 0x9B, 0x83,
  0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x78, 0x1C, 0x0F,
  0x03, 0x80, 0x07, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C,
  0x01, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xBC, 0x00, 0xF1, 0xC0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x3C,
  0x1E, 0x07, 0x80, 0xE0, 0xF8, 0x0F, 0x00, 0xE0, 0x1F, 0xE0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0x70, 0xE0, 0x71, 0xE0, 0x7B,
  0xC0, 0x7B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xE3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3, 0xCF, 0x3C, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xE0, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xEF, 0x07, 0x9E, 0x1E, 0x1E, 0x78, 0x3D,
  0xE0, 0x7B, 0xC0, 0x79, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0xE3, 0xE3, 0xE1, 0xE0, 0x80, 0x01, 0xFC, 0x0F, 0xFC,
  0x7F, 0xF9, 0xF8, 0xF3, 0xC1, 0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0,
  0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFE,
  0x1F, 0x9C, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E,
  0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFE, 0x0F, 0xFC, 0x7F, 0xF8, 0xF8, 0x23, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x0F, 0xC7, 0x87, 0x83, 0x87, 0x81, 0xC3, 0xC1, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFC, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF9, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xDC, 0x0F, 0xF9, 0xFE, 0xFF, 0xF9,
  0xFF, 0x83, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F,
  0xF8, 0x3F, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x70, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x7D, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x10, 0x1E, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F,
  0xFC, 0x3F, 0xFC, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8E,
  0x0F, 0x3C, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x20, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0x1F, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xFE, 0x3F, 0xC3, 0xF8,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x41, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x1F, 0x1E, 0x1E, 0x0F, 0x1E, 0x07,
  0x1E, 0x07, 0x9E, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x83,
  0xC3, 0xC1, 0xF0, 0x7F, 0xBF, 0xCF, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE1, 0x7F, 0xDF, 0xF3, 0xFC, 0x0F, 0x9E, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1C, 0xE7, 0x38, 0xE7, 0x38, 0xE7, 0x39, 0xC7, 0x39, 0xC7,
  0x71, 0xCE, 0x71, 0xCE, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC1, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xE0,
  0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x78, 0x3C, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x8F, 0x8F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1,
  0xE0, 0xF0, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F,
  0x07, 0x87, 0x03, 0xC7, 0x83, 0xC3, 0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x1E, 0x3C,
  0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0xF8, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x8C, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x7F,
  0xF0, 0xF0, 0x41, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC4, 0x07, 0x9F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x23, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x1C, 0x1E,
  0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x8F, 0x8F, 0xFF,
  0x1F, 0xFE, 0x1F, 0x9C, 0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xBC, 0x1E, 0xF0,
  0x73, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x07, 0x78, 0x1D,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xB8, 0x03,
  0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x1C, 0x73, 0x9E, 0x71, 0xCF, 0x39, 0xCF,
  0x9C, 0xE6, 0xDC, 0x77, 0x6E, 0x3B, 0x37, 0x1F, 0x9F, 0x0F, 0x8F, 0x87,
  0xC7, 0x83, 0xC3, 0xC1, 0xC1, 0xC0, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x78,
  0x70, 0x1E, 0x3C, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3C, 0xE0, 0x1E, 0x3C, 0x0F,
  0x8F, 0x03, 0xC1, 0xE3, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x78, 0x03, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0C, 0x04, 0x7E, 0x1D, 0xFF,
  0x7F, 0xFF, 0xEE, 0x1F, 0x88, 0x1E, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 21, 17, 4, -21 },
  { 25, 11, 9, 17, 6, -23 },
  { 38, 18, 21, 17, 0, -21 },
  { 86, 16, 26, 17, 1, -23 },
  { 138, 20, 21, 17, -1, -21 },
  { 191, 16, 21, 17, 0, -21 },
  { 233, 6, 10, 17, 8, -23 },
  { 241, 14, 30, 17, 3, -24 },
  { 294, 14, 30, 17, 0, -24 },
  { 347, 14, 13, 17, 3, -21 },
  { 370, 15, 15, 17, 1, -16 },
  { 399, 8, 10, 17, 2, -5 },
  { 409, 9, 3, 17, 4, -10 },
  { 413, 6, 5, 17, 4, -5 },
  { 417, 20, 29, 17, -2, -23 },
  { 490, 16, 21, 17, 1, -21 },
  { 532, 13, 21, 17, 1, -21 },
  { 567, 17, 21, 17, 0, -21 },
  { 612, 16, 21, 17, 0, -21 },
  { 654, 17, 21, 17, 0, -21 },
  { 699, 17, 21, 17, 0, -21 },
  { 744, 16, 21, 17, 1, -21 },
  { 786, 16, 21, 17, 3, -21 },
  { 828, 16, 21, 17, 1, -21 },
  { 870, 16, 21, 17, 1, -21 },
  { 912, 8, 15, 17, 4, -15 },
  { 927, 10, 20, 17, 2, -15 },
  { 952, 16, 14, 17, 1, -16 },
  { 980, 17, 10, 17, 0, -14 },
  { 1002, 15, 14, 17, 1, -16 },
  { 1029, 12, 21, 17, 4, -21 },
  { 1061, 17, 26, 17, 1, -21 },
  { 1117, 17, 21, 17, -2, -21 },
  { 1162, 17, 21, 17, 0, -21 },
  { 1207, 16, 21, 17, 2, -21 },
  { 1249, 16, 21, 17, 0, -21 },
  { 1291, 17, 21, 17, 1, -21 },
  { 1336, 17, 21, 17, 1, -21 },
  { 1381, 17, 21, 17, 1, -21 },
  { 1426, 18, 21, 17, 0, -21 },
  { 1474, 18, 21, 17, 0, -21 },
  { 1522, 17, 21, 17, 0, -21 },
  { 1567, 19, 21, 17, 0, -21 },
  { 1617, 14, 21, 17, 0, -21 },
  { 1654, 19, 21, 17, -1, -21 },
  { 1704, 18, 21, 17, 0, -21 },
  { 1752, 16, 21, 17, 1, -21 },
  { 1794, 17, 21, 17, 0, -21 },
  { 1839, 16, 27, 17, 1, -21 },
  { 1893, 17, 21, 17, 0, -21 },
  { 1938, 17, 21, 17, 0, -21 },
  { 1983, 16, 21, 17, 3, -21 },
  { 2025, 17, 21, 17, 1, -21 },
  { 2070, 16, 21, 17, 3, -21 },
  { 2112, 19, 21, 17, 0, -21 },
  { 2162, 20, 21, 17, -1, -21 },
  { 2215, 16, 21, 17, 4, -21 },
  { 2257, 18, 21, 17, 0, -21 },
  { 2305, 16, 29, 17, 2, -23 },
  { 2363, 6, 29, 17, 6, -23 },
  { 2385, 16, 29, 17, -1, -23 },
  { 2443, 15, 12, 17, 2, -21 },
  { 2466, 15, 4, 17, -2, 2 },
  { 2474, 7, 6, 17, 7, -23 },
  { 2480, 15, 16, 17, 1, -16 },
  { 2510, 16, 23, 17, 0, -23 },
  { 2556, 15, 16, 17, 1, -16 },
  { 2586, 17, 23, 17, 1, -23 },
  { 2635, 15, 16, 17, 1, -16 },
  { 2665, 21, 29, 17, -2, -23 },
  { 2742, 18, 22, 17, -1, -16 },
  { 2792, 15, 23, 17, 0, -23 },
  { 2836, 11, 23, 17, 3, -23 },
  { 2868, 17, 29, 17, -1, -23 },
  { 2930, 17, 23, 17, 1, -23 },
  { 2979, 10, 23, 17, 4, -23 },
  { 3008, 16, 16, 17, 0, -16 },
  { 3040, 15, 16, 17, 0, -16 },
  { 3070, 15, 16, 17, 1, -16 },
  { 3100, 17, 22, 17, -1, -16 },
  { 3147, 16, 22, 17, 1, -16 },
  { 3191, 16, 16, 17, 1, -16 },
  { 3223, 15, 16, 17, 1, -16 },
  { 3253, 13, 20, 17, 3, -20 },
  { 3286, 15, 16, 17, 1, -16 },
  { 3316, 14, 16, 17, 3, -16 },
  { 3344, 17, 16, 17, 1, -16 },
  { 3378, 18, 16, 17, -1, -16 },
  { 3414, 19, 22, 17, -2, -16 },
  { 3467, 16, 16, 17, 0, -16 },
  { 3499, 16, 29, 17, 2, -23 },
  { 3557, 11, 29, 17, 3, -23 },
  { 3597, 16, 29, 17, -1, -23 },
  { 3655, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC30PT7B_H_
