#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC28PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF8, 0xF0, 0x79, 0xEE, 0x39, 0xC7,
  0x39, 0xEF, 0x39, 0xC7, 0x38, 0xE6, 0x18, 0x00, 0xE7, 0x80, 0xE3, 0x80,
  0x73, 0x80, 0x71, 0xC3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x0E, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE0, 0xE3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x31, 0xC0, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF8, 0x03, 0xFF, 0x0F, 0xFE,
  0x0F, 0x06, 0x0E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x78, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x21, 0xF8, 0x18, 0x3F, 0x06, 0x0E, 0x61, 0x81,
  0x8C, 0x70, 0x31, 0x9C, 0x06, 0x77, 0x00, 0xDD, 0xC0, 0x1F, 0x30, 0x01,
  0xCC, 0x00, 0x03, 0x80, 0x00, 0xEF, 0x00, 0x3B, 0xF0, 0x0E, 0x66, 0x01,
  0x9C, 0xC0, 0x63, 0x18, 0x1C, 0x67, 0x07, 0x0C, 0xC1, 0xC1, 0xF8, 0x70,
  0x3E, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x78, 0xE0, 0xE1, 0xC1,
  0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x39, 0xFE,
  0x77, 0x9D, 0xCE, 0x3F, 0xBC, 0x3E, 0x78, 0x38, 0xF0, 0xF8, 0xF7, 0xF1,
  0xFF, 0xE1, 0xF9, 0xE0, 0x7B, 0xBD, 0xEF, 0x73, 0x98, 0xC0, 0x00, 0x30,
  0x03, 0x80, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0x80,
  0x18, 0x00, 0x0F, 0x00, 0x70, 0x47, 0x1F, 0x67, 0xFF, 0xFF, 0xFF, 0x0F,
  0x01, 0xF8, 0x3D, 0xC7, 0x9E, 0x38, 0xC1, 0x08, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x7C, 0xF9,
  0xF1, 0xE1, 0xC7, 0x7C, 0xF1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF9, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0xBC, 0x0E, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x77, 0x99, 0xEF, 0x03, 0xDC, 0x07, 0x38, 0x1E, 0x78,
  0x38, 0xF0, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x1F,
  0x07, 0xF1, 0xFE, 0x1E, 0xE1, 0xDE, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x78, 0xF0, 0x40, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xF1,
  0xFF, 0xE7, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x03, 0xF8, 0x07, 0xC0, 0x1F,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x40, 0x78,
  0xF7, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xDC, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x38,
  0x3C, 0x38, 0x38, 0x38, 0x70, 0x78, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x40, 0x78, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x06,
  0x00, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x7B, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0x81, 0xCF, 0x03, 0xDE, 0x07,
  0xBC, 0x0E, 0x78, 0x1C, 0x70, 0x78, 0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x0E,
  0x1E, 0x1F, 0x78, 0x1F, 0xE0, 0x7F, 0x81, 0xEF, 0x87, 0x87, 0x9E, 0x0F,
  0x38, 0x0E, 0x70, 0x3C, 0xF0, 0x79, 0xF3, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE1, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1C, 0x78, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0x23,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE1, 0xFF, 0x03, 0xFC, 0x07,
  0xC0, 0x00, 0x0E, 0x1E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0x81, 0xE0, 0xFC, 0x3E, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0,
  0x38, 0x1C, 0x3E, 0x0F, 0x02, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x07, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7C, 0x00, 0x70, 0x00, 0x40, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFC, 0x20, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0x80, 0x3E, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x0F, 0x8F, 0xF9, 0xFF, 0x90, 0xF0, 0x0E, 0x03, 0xC0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x01, 0x00,
  0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x3F, 0xF8,
  0xF0, 0x71, 0xC0, 0xE7, 0x01, 0xCE, 0x1F, 0xB8, 0xFF, 0x73, 0xFF, 0xCF,
  0x1F, 0x9C, 0x77, 0x38, 0xEE, 0x71, 0xDD, 0xC3, 0xB3, 0x8E, 0x63, 0x9C,
  0xE7, 0xF9, 0xC7, 0xF3, 0x87, 0x87, 0x00, 0x07, 0x00, 0x0F, 0xC8, 0x0F,
  0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D,
  0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xCE, 0x07, 0xBC, 0x0F, 0x70, 0x1F, 0xE0,
  0x3F, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1E, 0x0E,
  0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xF8, 0x38, 0x7C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70,
  0x7C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF8, 0x63, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x21, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0x80, 0x1F,
  0xF0, 0x3F, 0xF0, 0x73, 0xF0, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07,
  0x1C, 0x0E, 0x78, 0x1C, 0xF0, 0x39, 0xC0, 0xF3, 0x81, 0xEF, 0x07, 0x9E,
  0x0F, 0x38, 0x3C, 0x70, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x86, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x78,
  0x70, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x07, 0x87, 0x03, 0xC3,
  0x81, 0xC3, 0xC0, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x38, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x81, 0xC3, 0xC1,
  0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x38, 0x1E, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x20,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x07, 0xC3, 0xC3, 0xC0,
  0xE1, 0xE0, 0x38, 0xF0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xDF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xBC, 0x00, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x3C, 0x07, 0x0F, 0x01, 0xC1, 0xE0, 0x70, 0x78, 0x3C, 0x0E, 0x0F,
  0x03, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFC, 0x03, 0x83, 0xC1,
  0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xD9,
  0xB8, 0x77, 0xEE, 0x1D, 0xF7, 0x07, 0x3D, 0xC3, 0x8E, 0x70, 0xE3, 0x1C,
  0x38, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x8E, 0x01, 0xC0, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0xC1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xEC, 0x38, 0x76, 0x38, 0x3B, 0x9C, 0x39, 0xCE, 0x1C,
  0x67, 0x0E, 0x37, 0x87, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC1, 0xF0,
  0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF9, 0xE1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F,
  0x70, 0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x3F, 0x0E, 0x0F, 0x0E, 0x07, 0x1E,
  0x07, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xE0, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE1, 0xC1,
  0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x3B, 0xC0, 0x77,
  0x80, 0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xC0, 0x01, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x71, 0xF0, 0xE0, 0xE3,
  0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x1E, 0x78, 0xF8, 0xFF, 0xE1, 0xFF,
  0x83, 0xFE, 0x07, 0x1C, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xF3,
  0xC0, 0xE7, 0x81, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x06,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x40, 0x78, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C,
  0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x70, 0xF0, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0xF0, 0x1F,
  0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78,
  0x70, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0xC7, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xC3,
  0x80, 0x70, 0xE7, 0x1C, 0x39, 0xCE, 0x0E, 0xF3, 0x83, 0x3E, 0xE1, 0xDB,
  0xB8, 0x76, 0xFC, 0x1F, 0x1F, 0x06, 0xC7, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x1E,
  0x01, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80,
  0x1E, 0x70, 0x07, 0x8F, 0x00, 0xF0, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0x83,
  0xC0, 0x78, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0xC7, 0x8F,
  0x0F, 0x1C, 0x0E, 0x78, 0x1D, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x00, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xE1, 0xEF, 0x1E, 0x38, 0xE1, 0xEF, 0x0F,
  0xF0, 0x3F, 0x01, 0xC8, 0x08, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x20,
  0x63, 0xE3, 0xE1, 0xE0, 0x80, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x8F,
  0x78, 0x39, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xE0, 0x73, 0x81, 0xCE, 0x0F,
  0x3C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xF7, 0x00, 0x01, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x78, 0x1F,
  0xF8, 0x3F, 0xF8, 0x78, 0xF0, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07,
  0x1C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xC1, 0xE3, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0x82, 0x7C, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFC, 0x3E, 0x3C, 0x78, 0x38, 0x78, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0x70, 0xE0, 0x70, 0xF0, 0x70, 0xF0, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0x78, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x1D, 0xC0, 0xF7,
  0x07, 0xBF, 0xFC, 0xFF, 0xE3, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xF1,
  0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1E, 0x20, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x38,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0E, 0x0F, 0x07, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x40, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xE3, 0xC7,
  0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x39, 0xE0, 0xE7,
  0x87, 0x9C, 0x1E, 0x70, 0x73, 0xC3, 0xC0, 0x07, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x3F, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0x1F, 0xC7, 0xF0, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x41, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x1C, 0x3C, 0x38, 0xF0,
  0xF3, 0xC1, 0xEF, 0x03, 0xBC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x73,
  0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x87, 0x0E, 0x0F, 0x1C, 0x0F, 0x00, 0xFF,
  0x7F, 0xBF, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x0F, 0xF7, 0xF9, 0xFC,
  0x0F, 0x9C, 0x3F, 0xFC, 0x7F, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xB8, 0xC7, 0x73, 0x9C, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0xEE, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x00, 0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0xC7, 0x8F,
  0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x38, 0x3C, 0xE0, 0xE7, 0x83,
  0x9E, 0x1E, 0x70, 0x79, 0xC1, 0xCF, 0x07, 0x00, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x1E, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0xFC, 0x0E, 0xF0, 0x3B,
  0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x8F, 0x38, 0x3D,
  0xE0, 0xE7, 0x03, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x07, 0x3C, 0x3C,
  0x7F, 0xF1, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x82, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x02,
  0x3C, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x10, 0x3C, 0xFF, 0xE3, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x80, 0x7F, 0xC7, 0xFC, 0x3F,
  0xC0, 0x3C, 0x1C, 0xF0, 0xF3, 0x83, 0xCE, 0x0E, 0x78, 0x39, 0xE1, 0xE7,
  0x07, 0x9C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xFF, 0xF1,
  0xFF, 0xC3, 0xF7, 0x00, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x70,
  0x71, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x79, 0xC1, 0xEE, 0x07, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x0E, 0x71, 0x8E, 0x63, 0x8E, 0x63, 0x9C, 0xE7, 0x9C, 0xE7, 0x98, 0xEF,
  0xB8, 0xED, 0xB8, 0xFD, 0xB0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xE0,
  0xE0, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xC3, 0x80, 0xF3, 0xC0, 0x3B, 0xC0,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xDE,
  0x03, 0xCF, 0x03, 0xC3, 0x81, 0xC1, 0xE3, 0xE0, 0x70, 0x07, 0x03, 0xC1,
  0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x07, 0x07, 0x01, 0xE3, 0xC0, 0x78,
  0xE0, 0x1E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x0F, 0xE0, 0x1F,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x00,
  0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0x1E, 0x09, 0xFC, 0x77, 0xFF, 0xF9, 0xFE, 0xC1, 0xF0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 19, 16, 4, -19 },
  { 20, 11, 8, 16, 5, -21 },
  { 31, 17, 19, 16, 0, -19 },
  { 72, 16, 25, 16, 0, -22 },
  { 122, 19, 20, 16, -1, -20 },
  { 170, 15, 20, 16, 0, -20 },
  { 208, 5, 9, 16, 8, -21 },
  { 214, 13, 27, 16, 3, -22 },
  { 258, 13, 27, 16, 0, -22 },
  { 302, 12, 12, 16, 3, -19 },
  { 320, 14, 14, 16, 1, -15 },
  { 345, 7, 10, 16, 2, -5 },
  { 354, 8, 4, 16, 4, -10 },
  { 358, 5, 5, 16, 4, -5 },
  { 362, 19, 27, 16, -2, -22 },
  { 427, 15, 20, 16, 1, -20 },
  { 465, 12, 19, 16, 1, -19 },
  { 494, 15, 20, 16, 0, -20 },
  { 532, 15, 20, 16, 0, -20 },
  { 570, 16, 19, 16, 0, -19 },
  { 608, 16, 19, 16, 0, -19 },
  { 646, 15, 20, 16, 1, -20 },
  { 684, 14, 19, 16, 3, -19 },
  { 718, 15, 20, 16, 1, -20 },
  { 756, 15, 20, 16, 1, -20 },
  { 794, 8, 15, 16, 4, -15 },
  { 809, 10, 20, 16, 2, -15 },
  { 834, 14, 14, 16, 1, -15 },
  { 859, 16, 9, 16, 0, -13 },
  { 877, 14, 14, 16, 1, -15 },
  { 902, 11, 20, 16, 4, -20 },
  { 930, 15, 24, 16, 1, -20 },
  { 975, 15, 19, 16, -1, -19 },
  { 1011, 16, 20, 16, 0, -20 },
  { 1051, 15, 20, 16, 2, -20 },
  { 1089, 15, 20, 16, 0, -20 },
  { 1127, 16, 19, 16, 1, -19 },
  { 1165, 16, 19, 16, 1, -19 },
  { 1203, 16, 20, 16, 1, -20 },
  { 1243, 17, 19, 16, 0, -19 },
  { 1284, 17, 19, 16, 0, -19 },
  { 1325, 16, 19, 16, 0, -19 },
  { 1363, 18, 19, 16, 0, -19 },
  { 1406, 13, 19, 16, 0, -19 },
  { 1437, 18, 19, 16, -1, -19 },
  { 1480, 17, 19, 16, 0, -19 },
  { 1521, 15, 20, 16, 1, -20 },
  { 1559, 16, 20, 16, 0, -20 },
  { 1599, 15, 25, 16, 1, -20 },
  { 1646, 15, 20, 16, 0, -20 },
  { 1684, 16, 20, 16, 0, -20 },
  { 1724, 15, 19, 16, 3, -19 },
  { 1760, 16, 19, 16, 1, -19 },
  { 1798, 15, 19, 16, 3, -19 },
  { 1834, 18, 19, 16, 0, -19 },
  { 1877, 19, 19, 16, -1, -19 },
  { 1923, 15, 19, 16, 3, -19 },
  { 1959, 17, 19, 16, 0, -19 },
  { 2000, 15, 27, 16, 2, -22 },
  { 2051, 6, 27, 16, 5, -22 },
  { 2072, 15, 27, 16, -1, -22 },
  { 2123, 13, 11, 16, 2, -19 },
  { 2141, 15, 3, 16, -2, 2 },
  { 2147, 7, 6, 16, 6, -22 },
  { 2153, 14, 15, 16, 1, -15 },
  { 2180, 15, 22, 16, 0, -22 },
  { 2222, 14, 15, 16, 1, -15 },
  { 2249, 16, 22, 16, 1, -22 },
  { 2293, 14, 15, 16, 1, -15 },
  { 2320, 19, 27, 16, -2, -22 },
  { 2385, 17, 20, 16, -1, -15 },
  { 2428, 14, 22, 16, 0, -22 },
  { 2467, 10, 22, 16, 3, -22 },
  { 2495, 16, 27, 16, -1, -22 },
  { 2549, 15, 22, 16, 1, -22 },
  { 2591, 9, 22, 16, 4, -22 },
  { 2616, 15, 15, 16, 0, -15 },
  { 2645, 14, 15, 16, 0, -15 },
  { 2672, 14, 15, 16, 1, -15 },
  { 2699, 16, 20, 16, -1, -15 },
  { 2739, 14, 20, 16, 1, -15 },
  { 2774, 14, 15, 16, 1, -15 },
  { 2801, 14, 15, 16, 1, -15 },
  { 2828, 12, 19, 16, 3, -19 },
  { 2857, 14, 15, 16, 1, -15 },
  { 2884, 14, 15, 16, 2, -15 },
  { 2911, 16, 15, 16, 1, -15 },
  { 2941, 17, 15, 16, -1, -15 },
  { 2973, 18, 20, 16, -2, -15 },
  { 3018, 15, 15, 16, 0, -15 },
  { 3047, 15, 27, 16, 2, -22 },
  { 3098, 10, 27, 16, 3, -22 },
  { 3132, 15, 27, 16, -1, -22 },
  { 3183, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC28PT7B_H_
