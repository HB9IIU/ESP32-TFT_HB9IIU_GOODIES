#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC42PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x08, 0x00, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70,
  0xE0, 0x70, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07,
  0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x01,
  0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC4, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC0, 0x78, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xC0, 0xE0, 0x7C, 0x00, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x82, 0x00,
  0x3E, 0x1E, 0x03, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xC0, 0x7F, 0x80, 0x3C, 0x07, 0xFC, 0x03, 0xC0, 0x38,
  0xF0, 0x3C, 0x03, 0xC7, 0x83, 0xC0, 0x1E, 0x3C, 0x3C, 0x00, 0xE1, 0xC3,
  0xC0, 0x07, 0x0E, 0x1C, 0x00, 0x38, 0xF1, 0xE0, 0x01, 0xC7, 0x9E, 0x00,
  0x0F, 0x79, 0xE0, 0x00, 0x7F, 0x9E, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3,
  0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF3, 0xDF, 0x00, 0x0F, 0x1C, 0x78,
  0x00, 0x79, 0xE3, 0xC0, 0x07, 0x8F, 0x1E, 0x00, 0x78, 0x70, 0xE0, 0x07,
  0x83, 0x87, 0x00, 0x78, 0x1C, 0x78, 0x07, 0x80, 0xE3, 0x80, 0x3C, 0x07,
  0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF9, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC3, 0x01, 0xFE, 0x0F, 0x0F, 0xFC, 0x3C,
  0x7F, 0xF1, 0xF3, 0xE3, 0xE7, 0x8F, 0x07, 0xFE, 0x7C, 0x1F, 0xF1, 0xF0,
  0x3F, 0xC7, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE1, 0xF0, 0x7F,
  0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xF9, 0xF0, 0x7F, 0x83, 0xE0,
  0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBF, 0x7C, 0xF9, 0xE3, 0xC7, 0x8E, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x03, 0x0F, 0x0C,
  0xF9, 0xC7, 0x9F, 0xBB, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3F, 0x3E, 0x0F, 0xC7, 0xE0,
  0xF8, 0xF8, 0x0E, 0x0E, 0x00, 0x40, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x1E, 0x07,
  0xC1, 0xF3, 0xFC, 0x7F, 0x0F, 0xC1, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF0, 0xFC, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC7, 0x8F, 0xBE, 0x7C, 0x7D, 0xF3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF9, 0xF7, 0xC3, 0x8F, 0xBE, 0x00, 0x7D,
  0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0x7C, 0x0F, 0x1F, 0x03, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x03, 0xF0, 0x30, 0x07, 0xC0, 0x80, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x18, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x20, 0x03, 0xF0, 0x30, 0x0F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xBF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0x81, 0xF8, 0xFC, 0x03, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x40,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x1F, 0x00,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7E, 0x3F, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x1F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0xF8, 0x04, 0x00, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0x80, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3E, 0x07, 0xE0, 0x1E, 0x07, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x01, 0xDE, 0x3E, 0x0F,
  0xFE, 0x3C, 0x1F, 0xFE, 0x3C, 0x3F, 0xFE, 0x7C, 0x7F, 0x7E, 0x78, 0x7C,
  0x3C, 0x78, 0xF8, 0x7C, 0x78, 0xF0, 0x7C, 0xF8, 0xF0, 0x7C, 0xF1, 0xF0,
  0x78, 0xF1, 0xF0, 0x78, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0,
  0xF0, 0xF1, 0xF8, 0xF0, 0xF0, 0xFF, 0xF0, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F,
  0xE0, 0xF8, 0x3F, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDF,
  0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x03, 0xF0,
  0x7C, 0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x01,
  0xFC, 0x7C, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0x03, 0x83, 0xF8, 0x01,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x40, 0xFE, 0x03, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x1F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x3E,
  0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3,
  0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E,
  0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF0, 0x7C, 0x3F, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE,
  0x03, 0x03, 0xF0, 0x02, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E,
  0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x80,
  0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x10, 0x07, 0xC0, 0x3C, 0x1F, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x01,
  0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF1, 0xFE,
  0x03, 0xBC, 0x77, 0x81, 0xEF, 0x3D, 0xE0, 0x7B, 0xCE, 0xF0, 0x1E, 0x77,
  0xBC, 0x0F, 0x1D, 0xCF, 0x03, 0xC7, 0xE3, 0xC0, 0xF1, 0xF9, 0xF0, 0x7C,
  0x7C, 0x7C, 0x1F, 0x1F, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xE1, 0xE3, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0xFC, 0x01, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF8,
  0x0F, 0x81, 0xFE, 0x03, 0xC0, 0x7F, 0x81, 0xF0, 0x1E, 0xE0, 0x7C, 0x07,
  0xBC, 0x1F, 0x03, 0xEF, 0x07, 0x80, 0xFB, 0xC3, 0xE0, 0x3C, 0x78, 0xF8,
  0x0F, 0x1E, 0x3E, 0x07, 0xC7, 0x8F, 0x01, 0xF1, 0xE3, 0xC0, 0x7C, 0x39,
  0xF0, 0x1E, 0x0F, 0x7C, 0x0F, 0x83, 0xDE, 0x03, 0xE0, 0xF7, 0x80, 0xF8,
  0x3F, 0xE0, 0x3C, 0x07, 0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xC0, 0x7F, 0x01,
  0xF0, 0x1F, 0xC0, 0x78, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87,
  0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E,
  0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0,
  0x7F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x7E, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x3F,
  0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x0C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x20, 0x03,
  0xF0, 0x38, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF1,
  0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3F,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0xFC, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01,
  0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0,
  0x01, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x78, 0x7C,
  0x0F, 0x8F, 0x0F, 0x81, 0xE3, 0xF1, 0xE0, 0x3C, 0x7E, 0x3C, 0x07, 0x9F,
  0xCF, 0x81, 0xF3, 0xB9, 0xE0, 0x3C, 0xF7, 0x3C, 0x07, 0x9C, 0xE7, 0x80,
  0xF7, 0x9D, 0xF0, 0x1E, 0xE3, 0xBC, 0x03, 0xBC, 0x77, 0x80, 0xF7, 0x0E,
  0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x80,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x1E, 0x7C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x7E,
  0x1F, 0x87, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0x00, 0x7D,
  0xF0, 0x03, 0xE3, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x20, 0x18,
  0x1E, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x0F, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0x83, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x07,
  0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F,
  0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0x7E, 0x0F,
  0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xFC, 0x7E, 0x1F, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xF0, 0x10, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x60, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xF3, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0xBE, 0x03, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x60, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFC, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x21, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xF8, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x63, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x60, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F,
  0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0xFC, 0x07, 0xC0, 0x00,
  0x70, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x21, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x30, 0x3F,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x7F, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x3F, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC3, 0x3F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFF, 0x01, 0x80, 0x01, 0xFC, 0x7C, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x8F, 0x1F, 0x0F, 0x8F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x00,
  0x04, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xF8, 0x7F, 0x3F, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xFC, 0x3F, 0x8F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xFC, 0x1F, 0x87, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xE0,
  0xF8, 0xFE, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x3F,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x0E, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0x10, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC2, 0x00, 0x3E, 0x1C, 0x03, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x06, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0x7C, 0x1F, 0xF3, 0xE0, 0x08, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x3E,
  0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7D, 0xF8, 0x07, 0xDF,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x7C, 0x7C, 0x78, 0xFC, 0x78, 0x78, 0xFC,
  0x78, 0x79, 0xFC, 0xF0, 0x79, 0xDC, 0xF0, 0x7B, 0xDE, 0xF0, 0x7F, 0x9F,
  0xE0, 0x77, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F,
  0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF, 0x80,
  0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x38, 0x7F, 0xC1, 0xF3, 0xFF, 0xCF, 0x9F, 0xFF, 0xFE, 0x7D, 0xFF, 0xF3,
  0xE1, 0xFF, 0x8F, 0x01, 0xFC, 0x04, 0x01, 0x80,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 13, 30, 24, 6, -29 },
  { 50, 16, 13, 24, 8, -32 },
  { 76, 25, 29, 24, 0, -29 },
  { 167, 22, 38, 24, 1, -33 },
  { 272, 29, 31, 24, -2, -30 },
  { 385, 22, 30, 24, 0, -30 },
  { 468, 7, 14, 24, 12, -32 },
  { 481, 18, 41, 24, 5, -33 },
  { 574, 19, 41, 24, 0, -33 },
  { 672, 19, 18, 24, 4, -29 },
  { 715, 20, 21, 24, 2, -23 },
  { 768, 11, 14, 24, 3, -7 },
  { 788, 14, 6, 24, 5, -15 },
  { 799, 8, 8, 24, 6, -7 },
  { 807, 27, 41, 24, -2, -33 },
  { 946, 21, 31, 24, 2, -30 },
  { 1028, 18, 29, 24, 2, -29 },
  { 1094, 22, 30, 24, 1, -30 },
  { 1177, 23, 31, 24, 0, -30 },
  { 1267, 23, 29, 24, 0, -29 },
  { 1351, 24, 30, 24, 0, -29 },
  { 1441, 22, 30, 24, 2, -29 },
  { 1524, 22, 29, 24, 4, -29 },
  { 1604, 23, 31, 24, 1, -30 },
  { 1694, 22, 30, 24, 1, -30 },
  { 1777, 11, 23, 24, 6, -22 },
  { 1809, 14, 29, 24, 3, -22 },
  { 1860, 21, 20, 24, 2, -22 },
  { 1913, 22, 13, 24, 1, -19 },
  { 1949, 21, 20, 24, 1, -22 },
  { 2002, 17, 31, 24, 6, -30 },
  { 2068, 24, 36, 24, 1, -30 },
  { 2176, 23, 29, 24, -2, -29 },
  { 2260, 23, 29, 24, 0, -29 },
  { 2344, 23, 31, 24, 2, -30 },
  { 2434, 23, 29, 24, 0, -29 },
  { 2518, 24, 29, 24, 1, -29 },
  { 2605, 25, 29, 24, 1, -29 },
  { 2696, 23, 31, 24, 2, -30 },
  { 2786, 26, 29, 24, 0, -29 },
  { 2881, 25, 29, 24, 0, -29 },
  { 2972, 24, 30, 24, 0, -29 },
  { 3062, 26, 29, 24, 0, -29 },
  { 3157, 19, 29, 24, 0, -29 },
  { 3226, 26, 29, 24, -1, -29 },
  { 3321, 26, 29, 24, 0, -29 },
  { 3416, 22, 31, 24, 2, -30 },
  { 3502, 24, 29, 24, 0, -29 },
  { 3589, 22, 38, 24, 2, -30 },
  { 3694, 23, 29, 24, 0, -29 },
  { 3778, 24, 31, 24, 0, -30 },
  { 3871, 21, 29, 24, 5, -29 },
  { 3948, 23, 30, 24, 2, -29 },
  { 4035, 22, 29, 24, 5, -29 },
  { 4115, 27, 29, 24, 0, -29 },
  { 4213, 29, 29, 24, -2, -29 },
  { 4319, 22, 29, 24, 5, -29 },
  { 4399, 25, 29, 24, 0, -29 },
  { 4490, 22, 41, 24, 3, -33 },
  { 4603, 9, 41, 24, 8, -33 },
  { 4650, 22, 41, 24, -1, -33 },
  { 4763, 21, 17, 24, 2, -29 },
  { 4808, 22, 5, 24, -3, 3 },
  { 4822, 9, 9, 24, 10, -33 },
  { 4833, 22, 24, 24, 1, -23 },
  { 4899, 22, 34, 24, 0, -33 },
  { 4993, 21, 24, 24, 2, -23 },
  { 5056, 25, 34, 24, 1, -33 },
  { 5163, 21, 24, 24, 2, -23 },
  { 5226, 29, 41, 24, -3, -33 },
  { 5375, 24, 31, 24, -1, -23 },
  { 5468, 21, 33, 24, 0, -33 },
  { 5555, 15, 33, 24, 4, -33 },
  { 5617, 24, 41, 24, -2, -33 },
  { 5740, 24, 33, 24, 1, -33 },
  { 5839, 14, 33, 24, 5, -32 },
  { 5897, 24, 22, 24, -1, -22 },
  { 5963, 21, 23, 24, 1, -23 },
  { 6024, 20, 24, 24, 2, -23 },
  { 6084, 24, 31, 24, -2, -23 },
  { 6177, 21, 31, 24, 2, -23 },
  { 6259, 21, 22, 24, 2, -22 },
  { 6317, 21, 24, 24, 1, -23 },
  { 6380, 19, 30, 24, 4, -29 },
  { 6452, 21, 23, 24, 2, -22 },
  { 6513, 20, 22, 24, 4, -22 },
  { 6568, 24, 22, 24, 1, -22 },
  { 6634, 25, 22, 24, -1, -22 },
  { 6703, 27, 30, 24, -3, -22 },
  { 6805, 22, 22, 24, 1, -22 },
  { 6866, 22, 41, 24, 3, -33 },
  { 6979, 15, 41, 24, 4, -33 },
  { 7056, 23, 41, 24, -2, -33 },
  { 7174, 22, 8, 24, 1, -16 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC42PT7B_H_
