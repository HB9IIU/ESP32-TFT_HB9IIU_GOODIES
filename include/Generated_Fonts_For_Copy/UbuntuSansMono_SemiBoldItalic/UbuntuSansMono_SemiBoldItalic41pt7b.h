#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC41PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x7C, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x7C, 0x3E, 0xF8,
  0xFD, 0xF1, 0xFF, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1E, 0x78, 0x7C,
  0xF0, 0xF9, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x03, 0xE1, 0xE0, 0x03,
  0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x07, 0x87, 0x80, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3E,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x40,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE1, 0x00, 0x1F, 0x87, 0x00, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x3D, 0xE0,
  0x3C, 0x03, 0x8E, 0x07, 0x80, 0x78, 0xE0, 0xF0, 0x07, 0x0E, 0x1E, 0x00,
  0x70, 0xE1, 0xC0, 0x07, 0x1E, 0x3C, 0x00, 0x71, 0xC7, 0x80, 0x07, 0x3C,
  0xF0, 0x00, 0x7F, 0x9E, 0x00, 0x07, 0xFB, 0xC0, 0x00, 0x3E, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1E, 0x7E, 0x00, 0x03,
  0xCF, 0xF0, 0x00, 0x79, 0xFF, 0x00, 0x0F, 0x1C, 0x70, 0x00, 0xF3, 0xC7,
  0x00, 0x1E, 0x38, 0x70, 0x03, 0xC3, 0x87, 0x00, 0x78, 0x38, 0xF0, 0x0F,
  0x07, 0x8E, 0x01, 0xE0, 0x79, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0xC0, 0x3F,
  0xC0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0xF0, 0x0F, 0x83,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80,
  0x3C, 0x7C, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x83, 0xC3, 0xFE, 0x1F, 0x1F, 0xFC, 0x78, 0xF8, 0xF9, 0xE3, 0xC3, 0xEF,
  0x1F, 0x07, 0xFC, 0x78, 0x1F, 0xE1, 0xE0, 0x3F, 0x8F, 0x80, 0x7C, 0x3E,
  0x03, 0xF0, 0x7C, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xDE, 0x0F, 0xFE,
  0x7C, 0x1F, 0xE1, 0xF0, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x20, 0xF0, 0x27, 0x0E, 0x18, 0xF9, 0xCF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0xFB, 0xE0,
  0x3E, 0x7E, 0x0F, 0xC7, 0xE0, 0x70, 0xF0, 0x06, 0x0C, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC1, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0x1E, 0x07,
  0x81, 0xF3, 0xFC, 0x7F, 0x0F, 0x81, 0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C,
  0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x03, 0xE3, 0xE0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x61, 0xF7,
  0xCF, 0x8F, 0x3C, 0x7C, 0xFB, 0xE3, 0xE7, 0xDF, 0x1F, 0x3E, 0xF8, 0xF1,
  0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3E, 0x7C, 0x0E, 0x3E, 0x02, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xF3, 0xF8, 0x1E, 0x03, 0xF0, 0x20, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xE1, 0xFC,
  0x04, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x70, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xEF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x30, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x7D, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xC3, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xF0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xFE, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7E, 0x03, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFE, 0x1F, 0x83, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x07,
  0xC0, 0x20, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0xFF, 0x03, 0xF8,
  0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x1F, 0x84, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x03, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x0F, 0xFC,
  0xF0, 0x7F, 0xF9, 0xE1, 0xFF, 0xE7, 0xC7, 0xFF, 0xCF, 0x0F, 0x8F, 0x9E,
  0x3E, 0x1F, 0x3C, 0x78, 0x3C, 0xF1, 0xF0, 0x79, 0xE3, 0xE1, 0xF3, 0xC7,
  0x83, 0xE7, 0x8F, 0x07, 0x8F, 0x1E, 0x0F, 0x1E, 0x3C, 0x3E, 0x3C, 0x7C,
  0x7C, 0x78, 0xFF, 0xF0, 0xF0, 0xFF, 0xE1, 0xE0, 0xFF, 0xC3, 0xE0, 0xFF,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x3C,
  0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x3F, 0x01,
  0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x07, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E,
  0x01, 0xF8, 0x7C, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFE, 0xF8, 0x1F, 0x80, 0x20, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x01, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x07, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0x7C, 0x3F,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x78, 0x3F,
  0x80, 0x60, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x10, 0x0F, 0xC0, 0x38, 0x1F, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE1, 0xDE, 0x07, 0x70, 0xEE, 0x07, 0xB8, 0xEF, 0x03, 0xDC, 0x77,
  0x81, 0xEE, 0x73, 0xC1, 0xE7, 0xF9, 0xE0, 0xF3, 0xF9, 0xE0, 0x79, 0xFC,
  0xF0, 0x7C, 0x7C, 0x78, 0x3C, 0x3E, 0x3C, 0x1E, 0x1E, 0x3E, 0x0F, 0x0F,
  0x1F, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x7E, 0x01, 0xE0, 0x7F, 0x01,
  0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x0F, 0xBC,
  0x3E, 0x07, 0xDE, 0x1F, 0x03, 0xCF, 0x0F, 0x01, 0xE7, 0x87, 0x81, 0xF1,
  0xE7, 0xC0, 0xF8, 0xF3, 0xE0, 0x78, 0x79, 0xE0, 0x3C, 0x3C, 0xF0, 0x3E,
  0x0E, 0x78, 0x1F, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xFE, 0x07,
  0xC0, 0x7F, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0xF0, 0x0F, 0xC0,
  0x78, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0xFC, 0x0F, 0x8F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F,
  0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F,
  0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0x87, 0xC0, 0x7C, 0x01, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x10, 0x01, 0xF0, 0x38, 0x07,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81,
  0xF1, 0xE1, 0xE0, 0x78, 0xF8, 0x78, 0x1E, 0x3E, 0x3E, 0x07, 0x9F, 0x8F,
  0x03, 0xE7, 0xE3, 0xC0, 0xF3, 0xF8, 0xF0, 0x3C, 0xEF, 0x78, 0x0F, 0x7B,
  0xDE, 0x03, 0xDC, 0xF7, 0x80, 0xEF, 0x1D, 0xC0, 0x7B, 0x87, 0xF0, 0x1F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0xE0, 0x07, 0xC0,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0x7C,
  0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x3C, 0x1F,
  0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00,
  0xFC, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xFC, 0x7C, 0x03,
  0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFC, 0xE0, 0x03, 0x82, 0x00, 0x10, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x20, 0x38, 0x1E, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x0E, 0x02, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x03, 0xF3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xBC, 0x0F, 0xF1, 0xF0, 0x00, 0x18,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF3, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xCF, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0,
  0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xF1, 0xE3, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x18, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xF1, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xC3, 0xF3, 0xF0, 0x1F, 0x3E,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFE, 0xFB, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x10, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x3E, 0x07, 0xF0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x63, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x60, 0x1F, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x81,
  0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x8F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x10, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0xC0, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x08, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7E,
  0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x00,
  0x7D, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xBF, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0xF9, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0xFF,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x83, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE,
  0x00, 0xF8, 0x78, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x78, 0xF1, 0xE1, 0xF1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x8F, 0x8F, 0x0F,
  0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0xC7, 0x8F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0xF8, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0xFC, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE7, 0xF1,
  0xF8, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xEF, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0xFE,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFE, 0x3F, 0x1F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C,
  0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xE0, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xEF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xE0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC7, 0x00, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x18,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x7E, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xC7, 0xC0, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xDF,
  0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x3C, 0x3C, 0x7C, 0x3C,
  0x3C, 0x78, 0x7C, 0x78, 0x78, 0x7C, 0x78, 0x78, 0xFC, 0x78, 0x78, 0xFC,
  0xF0, 0x79, 0xFC, 0xF0, 0x79, 0xDC, 0xF0, 0x7B, 0xDD, 0xE0, 0x77, 0x9D,
  0xE0, 0x77, 0x1D, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xE0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF1,
  0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x83, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x43, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE1, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x30, 0xFF, 0x03, 0xCF, 0xFE, 0x3E, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7C, 0x3F, 0xF3, 0xC0, 0xFF, 0x02, 0x01, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 12, 29, 23, 6, -28 },
  { 45, 15, 12, 23, 8, -31 },
  { 68, 24, 28, 23, 0, -28 },
  { 152, 22, 36, 23, 1, -32 },
  { 251, 28, 30, 23, -2, -29 },
  { 356, 22, 29, 23, 0, -29 },
  { 436, 8, 13, 23, 11, -31 },
  { 449, 18, 40, 23, 5, -32 },
  { 539, 18, 40, 23, 0, -32 },
  { 629, 19, 17, 23, 4, -28 },
  { 670, 20, 20, 23, 2, -22 },
  { 720, 11, 14, 23, 3, -7 },
  { 740, 13, 5, 23, 5, -14 },
  { 749, 8, 8, 23, 6, -7 },
  { 757, 27, 40, 23, -2, -32 },
  { 892, 21, 30, 23, 2, -29 },
  { 971, 18, 28, 23, 2, -28 },
  { 1034, 22, 29, 23, 1, -29 },
  { 1114, 22, 30, 23, 0, -29 },
  { 1197, 23, 28, 23, 0, -28 },
  { 1278, 24, 29, 23, 0, -28 },
  { 1365, 22, 30, 23, 2, -29 },
  { 1448, 22, 28, 23, 4, -28 },
  { 1525, 22, 30, 23, 1, -29 },
  { 1608, 22, 29, 23, 1, -29 },
  { 1688, 11, 22, 23, 6, -21 },
  { 1719, 14, 28, 23, 3, -21 },
  { 1768, 21, 19, 23, 2, -21 },
  { 1818, 22, 14, 23, 1, -19 },
  { 1857, 21, 19, 23, 1, -21 },
  { 1907, 18, 30, 23, 5, -29 },
  { 1975, 23, 35, 23, 1, -29 },
  { 2076, 22, 28, 23, -2, -28 },
  { 2153, 23, 29, 23, 0, -29 },
  { 2237, 22, 30, 23, 2, -29 },
  { 2320, 22, 29, 23, 0, -29 },
  { 2400, 23, 28, 23, 1, -28 },
  { 2481, 24, 28, 23, 1, -28 },
  { 2565, 22, 30, 23, 2, -29 },
  { 2648, 25, 28, 23, 0, -28 },
  { 2736, 24, 28, 23, 0, -28 },
  { 2820, 24, 29, 23, 0, -28 },
  { 2907, 26, 28, 23, 0, -28 },
  { 2998, 19, 28, 23, 0, -28 },
  { 3065, 25, 28, 23, -1, -28 },
  { 3153, 25, 28, 23, 0, -28 },
  { 3241, 21, 30, 23, 2, -29 },
  { 3320, 24, 29, 23, 0, -29 },
  { 3407, 21, 37, 23, 2, -29 },
  { 3505, 23, 29, 23, 0, -29 },
  { 3589, 23, 30, 23, 0, -29 },
  { 3676, 21, 28, 23, 5, -28 },
  { 3750, 23, 29, 23, 2, -28 },
  { 3834, 23, 28, 23, 4, -28 },
  { 3915, 26, 28, 23, 0, -28 },
  { 4006, 28, 28, 23, -2, -28 },
  { 4104, 22, 28, 23, 5, -28 },
  { 4181, 25, 28, 23, 0, -28 },
  { 4269, 22, 40, 23, 2, -32 },
  { 4379, 8, 40, 23, 8, -32 },
  { 4419, 22, 40, 23, -1, -32 },
  { 4529, 21, 16, 23, 2, -28 },
  { 4571, 21, 5, 23, -3, 3 },
  { 4585, 9, 9, 23, 10, -32 },
  { 4596, 21, 22, 23, 1, -22 },
  { 4654, 21, 33, 23, 0, -32 },
  { 4741, 20, 22, 23, 2, -22 },
  { 4796, 24, 32, 23, 1, -32 },
  { 4892, 20, 23, 23, 2, -22 },
  { 4950, 29, 40, 23, -3, -32 },
  { 5095, 24, 30, 23, -1, -22 },
  { 5185, 21, 32, 23, 0, -32 },
  { 5269, 15, 32, 23, 4, -32 },
  { 5329, 23, 40, 23, -2, -32 },
  { 5444, 23, 32, 23, 1, -32 },
  { 5536, 14, 32, 23, 5, -32 },
  { 5592, 23, 22, 23, -1, -22 },
  { 5656, 20, 22, 23, 1, -22 },
  { 5711, 20, 23, 23, 1, -22 },
  { 5769, 24, 30, 23, -2, -22 },
  { 5859, 21, 30, 23, 2, -22 },
  { 5938, 21, 22, 23, 2, -22 },
  { 5996, 20, 23, 23, 1, -22 },
  { 6054, 18, 28, 23, 4, -28 },
  { 6117, 20, 21, 23, 2, -21 },
  { 6170, 20, 21, 23, 4, -21 },
  { 6223, 24, 21, 23, 1, -21 },
  { 6286, 24, 21, 23, -1, -21 },
  { 6349, 26, 29, 23, -3, -21 },
  { 6444, 21, 21, 23, 1, -21 },
  { 6500, 22, 40, 23, 3, -32 },
  { 6610, 15, 40, 23, 4, -32 },
  { 6685, 22, 40, 23, -2, -32 },
  { 6795, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC41PT7B_H_
