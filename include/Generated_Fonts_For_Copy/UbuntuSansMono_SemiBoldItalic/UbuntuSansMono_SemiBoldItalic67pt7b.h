#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC67PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFE,
  0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x10,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xC0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0x00,
  0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE3, 0xF0,
  0x00, 0x00, 0xFE, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF3, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xF1, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xC7, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xE3,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF0,
  0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xC0,
  0x00, 0x7F, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x00, 0x3F,
  0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFE,
  0x01, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF,
  0x3F, 0xC1, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0xCF, 0xE1,
  0xFC, 0x07, 0xFB, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF,
  0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xFE, 0x0F, 0xE0, 0x01,
  0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0x80, 0xFC, 0x03, 0x0F, 0x83, 0xF0, 0x3C, 0x7F, 0x0F,
  0xC3, 0xF1, 0xFF, 0x3E, 0x3F, 0xE7, 0xFE, 0x7B, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x03, 0xC0,
  0xFF, 0x3F, 0xC1, 0xF8, 0x3F, 0xCF, 0xF0, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F,
  0xC3, 0xF9, 0xFE, 0x1F, 0xE1, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x9F, 0xE1,
  0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x07, 0xFB, 0xFC, 0x1F, 0xC1, 0xFC, 0xFF,
  0x01, 0xC0, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F,
  0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFC, 0x3F, 0xE0, 0x07, 0x81, 0xFE, 0x00,
  0x30, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x03, 0xE0, 0x03,
  0xFF, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0x00, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x07, 0xFE, 0x03, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF7, 0xF8, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xFE, 0x0F,
  0x00, 0x3F, 0xF0, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFF, 0xC7, 0xF0,
  0x1F, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xFF,
  0x1F, 0xC1, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF,
  0x01, 0xFC, 0x7F, 0x07, 0xF0, 0x0F, 0xE3, 0xF0, 0x7F, 0x80, 0xFF, 0x1F,
  0x83, 0xF8, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0xFE, 0x01,
  0xFC, 0x7F, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x83,
  0xF8, 0x07, 0xF0, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC1, 0xFE,
  0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x3F, 0xF3, 0xF8, 0x1F,
  0x81, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x18, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x02,
  0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x7F,
  0xE0, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x03, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xBF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x01, 0xFF, 0xE0,
  0x03, 0xF7, 0xC0, 0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x3F, 0xFC, 0x00, 0x7F,
  0x7C, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xC3,
  0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0xF9, 0xFC, 0x00, 0xFE, 0x7C, 0x7E, 0x7E,
  0x00, 0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xCF, 0xC7, 0xE0, 0x07,
  0xF1, 0xFB, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xFF, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0x87,
  0xF0, 0x03, 0xF8, 0x3F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x7F, 0x80, 0x0F,
  0xE7, 0xE0, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0xFF, 0x00, 0x1F, 0xC3, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x00,
  0xFF, 0x07, 0xE1, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x0F, 0xE0,
  0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x03, 0xF3,
  0xFC, 0x00, 0x7F, 0x80, 0xFC, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x3F, 0x80,
  0x07, 0xF0, 0x0F, 0xCF, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x06, 0x00,
  0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xA0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFF, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xFF, 0x0F, 0xE0,
  0x07, 0xE1, 0xF7, 0xC3, 0xF0, 0x01, 0xF8, 0xFD, 0xF1, 0xFC, 0x00, 0xFE,
  0x3E, 0x7C, 0x7F, 0x00, 0x3F, 0x9F, 0x9F, 0x1F, 0xC0, 0x0F, 0xCF, 0xC7,
  0xE7, 0xE0, 0x03, 0xF3, 0xE1, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x7E, 0xFE,
  0x00, 0x3F, 0x7C, 0x1F, 0xBF, 0x00, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0x07,
  0xEF, 0x80, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xF0,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x0F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x7E, 0x00,
  0x00, 0xFE, 0x0E, 0x00, 0x00, 0x78, 0x02, 0x00, 0x00, 0x30, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x38, 0x00, 0xF8, 0x01,
  0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x02, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x83,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x3F, 0xC0, 0x0F, 0xFF, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00,
  0x3F, 0xDF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0x80, 0x02, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x60,
  0x1F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x17, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x02, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x38, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0x00, 0x00, 0x0F,
  0xC3, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE7, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x08, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFE,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF7,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x0C, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x0F,
  0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xCF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x00, 0x78, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x04, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x04, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x01, 0xFF, 0x01, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x60, 0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xE1, 0xFC, 0x00, 0x1F, 0x80,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0x07, 0xF0, 0x3F,
  0x87, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0xF8, 0xFC, 0x03, 0xF1, 0xFB, 0xF3, 0xF8, 0x07,
  0xE3, 0xF7, 0xE7, 0xE0, 0x0F, 0xCF, 0xCF, 0xCF, 0xC0, 0x1F, 0x9F, 0x0F,
  0xBF, 0x80, 0x3F, 0x7E, 0x1F, 0x7E, 0x00, 0x7E, 0xF8, 0x3E, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x08,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x07, 0xE0,
  0x7F, 0xFF, 0x80, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xF8, 0x7F, 0x81,
  0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 20, 47, 38, 10, -46 },
  { 119, 26, 20, 38, 12, -51 },
  { 184, 40, 46, 38, 0, -46 },
  { 414, 36, 59, 38, 1, -52 },
  { 680, 45, 49, 38, -2, -48 },
  { 956, 35, 49, 38, 1, -48 },
  { 1171, 12, 22, 38, 19, -51 },
  { 1204, 29, 66, 38, 8, -53 },
  { 1444, 29, 66, 38, 1, -53 },
  { 1684, 30, 28, 38, 7, -46 },
  { 1789, 32, 33, 38, 3, -36 },
  { 1921, 17, 23, 38, 5, -12 },
  { 1970, 22, 8, 38, 8, -23 },
  { 1992, 12, 13, 38, 10, -12 },
  { 2012, 44, 64, 38, -4, -52 },
  { 2364, 34, 49, 38, 3, -48 },
  { 2573, 29, 46, 38, 3, -46 },
  { 2740, 36, 48, 38, 1, -48 },
  { 2956, 36, 49, 38, 0, -48 },
  { 3177, 37, 46, 38, 0, -46 },
  { 3390, 39, 47, 38, 0, -46 },
  { 3620, 36, 48, 38, 3, -47 },
  { 3836, 36, 46, 38, 6, -46 },
  { 4043, 36, 49, 38, 2, -48 },
  { 4264, 35, 48, 38, 2, -48 },
  { 4474, 18, 36, 38, 10, -35 },
  { 4555, 23, 46, 38, 5, -35 },
  { 4688, 34, 31, 38, 3, -35 },
  { 4820, 36, 21, 38, 1, -30 },
  { 4915, 34, 31, 38, 1, -35 },
  { 5047, 28, 49, 38, 9, -48 },
  { 5219, 37, 58, 38, 2, -48 },
  { 5488, 36, 46, 38, -3, -46 },
  { 5695, 37, 48, 38, 0, -47 },
  { 5917, 36, 49, 38, 4, -48 },
  { 6138, 37, 48, 38, 0, -47 },
  { 6360, 38, 46, 38, 2, -46 },
  { 6579, 39, 46, 38, 2, -46 },
  { 6804, 37, 49, 38, 3, -48 },
  { 7031, 42, 46, 38, -1, -46 },
  { 7273, 39, 46, 38, 1, -46 },
  { 7498, 38, 47, 38, 1, -46 },
  { 7722, 42, 46, 38, 0, -46 },
  { 7964, 29, 46, 38, 1, -46 },
  { 8131, 42, 46, 38, -2, -46 },
  { 8373, 42, 46, 38, -1, -46 },
  { 8615, 35, 49, 38, 3, -48 },
  { 8830, 39, 47, 38, 0, -47 },
  { 9060, 35, 61, 38, 3, -48 },
  { 9327, 37, 47, 38, 0, -47 },
  { 9545, 38, 49, 38, 0, -48 },
  { 9778, 35, 46, 38, 7, -46 },
  { 9980, 37, 47, 38, 3, -46 },
  { 10198, 36, 46, 38, 7, -46 },
  { 10405, 42, 46, 38, 1, -46 },
  { 10647, 46, 46, 38, -3, -46 },
  { 10912, 36, 46, 38, 8, -46 },
  { 11119, 41, 46, 38, -1, -46 },
  { 11355, 36, 64, 38, 4, -52 },
  { 11643, 14, 64, 38, 13, -52 },
  { 11755, 35, 64, 38, -1, -52 },
  { 12035, 33, 26, 38, 4, -46 },
  { 12143, 35, 7, 38, -5, 5 },
  { 12174, 15, 14, 38, 16, -52 },
  { 12201, 34, 37, 38, 2, -36 },
  { 12359, 34, 53, 38, 1, -52 },
  { 12585, 34, 37, 38, 3, -36 },
  { 12743, 39, 53, 38, 2, -52 },
  { 13002, 33, 37, 38, 3, -36 },
  { 13155, 46, 65, 38, -4, -52 },
  { 13529, 39, 49, 38, -2, -36 },
  { 13768, 34, 52, 38, 0, -52 },
  { 13989, 25, 53, 38, 6, -52 },
  { 14155, 38, 65, 38, -3, -52 },
  { 14464, 38, 52, 38, 1, -52 },
  { 14711, 22, 53, 38, 9, -52 },
  { 14857, 38, 36, 38, -1, -36 },
  { 15028, 33, 36, 38, 1, -36 },
  { 15177, 33, 37, 38, 2, -36 },
  { 15330, 37, 48, 38, -2, -36 },
  { 15552, 34, 48, 38, 3, -36 },
  { 15756, 34, 36, 38, 3, -36 },
  { 15909, 33, 37, 38, 2, -36 },
  { 16062, 31, 47, 38, 6, -46 },
  { 16245, 33, 36, 38, 3, -35 },
  { 16394, 32, 35, 38, 6, -35 },
  { 16534, 39, 35, 38, 2, -35 },
  { 16705, 40, 35, 38, -2, -35 },
  { 16880, 44, 48, 38, -6, -35 },
  { 17144, 36, 35, 38, 1, -35 },
  { 17302, 36, 64, 38, 4, -52 },
  { 17590, 24, 64, 38, 7, -52 },
  { 17782, 36, 64, 38, -3, -52 },
  { 18070, 36, 13, 38, 1, -26 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC67PT7B_H_
