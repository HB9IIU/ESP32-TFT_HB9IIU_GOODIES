#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC12PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x36, 0x5E, 0xA5, 0x20, 0x1A, 0x29, 0xF9, 0x66, 0x9F,
  0x94, 0x58, 0x0C, 0x7C, 0x8B, 0x03, 0x83, 0x83, 0x26, 0xF8, 0x40, 0x21,
  0x52, 0x54, 0x78, 0x70, 0x1C, 0x2C, 0x54, 0x9C, 0x08, 0xF2, 0x4A, 0x31,
  0x5D, 0xF2, 0x7C, 0x6B, 0x40, 0x04, 0x31, 0x08, 0x61, 0x04, 0x30, 0xC1,
  0x06, 0x08, 0x10, 0x86, 0x10, 0x84, 0x23, 0x11, 0x99, 0x80, 0x33, 0xA3,
  0x5E, 0x50, 0x18, 0x61, 0x1F, 0x90, 0xC0, 0x6D, 0xE0, 0xE0, 0xF0, 0x03,
  0x02, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x08, 0x78,
  0x9B, 0x35, 0x6A, 0xB3, 0x24, 0x78, 0x1C, 0xE4, 0x86, 0x18, 0x41, 0x3F,
  0x08, 0x78, 0x98, 0x20, 0xC7, 0x18, 0x20, 0xFC, 0x08, 0xF0, 0x41, 0x38,
  0x30, 0xE3, 0xF8, 0x0E, 0x38, 0xD3, 0x64, 0xDF, 0x82, 0x0C, 0x3E, 0x40,
  0x83, 0xC0, 0xC1, 0xA3, 0x7C, 0x3D, 0x8C, 0x3E, 0x8A, 0x29, 0xBC, 0x7C,
  0x21, 0x8C, 0x21, 0x84, 0x30, 0x08, 0x7C, 0x99, 0x23, 0x8D, 0xB1, 0x66,
  0x78, 0x08, 0x79, 0x9A, 0x36, 0x67, 0x83, 0x0C, 0xE0, 0x6C, 0x0D, 0x80,
  0x33, 0x00, 0x66, 0x6C, 0x1D, 0xCC, 0x38, 0x38, 0x7E, 0x03, 0xF0, 0x60,
  0xE0, 0x4E, 0xE0, 0x27, 0x86, 0x66, 0x60, 0x18, 0xC0, 0x08, 0x7D, 0x8A,
  0x75, 0x7E, 0xAD, 0x6E, 0xC8, 0xC0, 0xE0, 0x0C, 0x1C, 0x58, 0xB2, 0x67,
  0xD9, 0xE3, 0x3C, 0x4D, 0x93, 0xC4, 0xC8, 0xB3, 0x7C, 0x08, 0xF4, 0x30,
  0x82, 0x08, 0x32, 0xF8, 0x3C, 0xC9, 0x9A, 0x34, 0x49, 0xB6, 0x78, 0x3E,
  0x40, 0x83, 0xE6, 0x08, 0x10, 0x7E, 0x3E, 0x40, 0x83, 0xE6, 0x08, 0x10,
  0x60, 0x09, 0xF4, 0x30, 0x82, 0x29, 0xA6, 0xF0, 0x22, 0xCD, 0x9B, 0xE4,
  0x59, 0xB3, 0x44, 0x3E, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x7C, 0x3E, 0x0C,
  0x10, 0x20, 0xC1, 0xA2, 0x7C, 0x27, 0x2C, 0x78, 0x70, 0x50, 0x58, 0xC8,
  0xCC, 0x31, 0x18, 0xC4, 0x23, 0x1F, 0x26, 0xED, 0x6A, 0xF5, 0x58, 0xA1,
  0x46, 0x22, 0xE5, 0xDA, 0xA5, 0x49, 0xB3, 0x44, 0x08, 0x79, 0x9B, 0x34,
  0x68, 0xB1, 0x26, 0x78, 0x3E, 0x4D, 0x9B, 0x27, 0x88, 0x30, 0x60, 0x08,
  0x79, 0x9B, 0x34, 0x68, 0xB1, 0x26, 0x78, 0x40, 0xE0, 0x3C, 0x4D, 0x9B,
  0x67, 0x89, 0x32, 0x66, 0x08, 0x7C, 0x83, 0x03, 0x81, 0x83, 0x46, 0xF8,
  0xFE, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x22, 0xCD, 0x9A, 0x24, 0x59,
  0xB3, 0x3C, 0xC7, 0x9B, 0x26, 0xCD, 0x0A, 0x18, 0x30, 0x63, 0x62, 0x42,
  0x56, 0x6C, 0xEC, 0xCC, 0xC8, 0x23, 0x34, 0x1C, 0x18, 0x38, 0x28, 0x4C,
  0xCC, 0xC6, 0x99, 0x63, 0x82, 0x0C, 0x18, 0x30, 0x3E, 0x08, 0x20, 0xC3,
  0x0C, 0x10, 0x7E, 0x3C, 0x82, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x0F, 0x00,
  0xD9, 0x24, 0x92, 0x6D, 0x80, 0x3C, 0x30, 0x82, 0x08, 0x61, 0x04, 0x10,
  0xCF, 0x00, 0x39, 0xE4, 0xB3, 0xFC, 0xCC, 0x3E, 0xC9, 0x36, 0x6C, 0xCF,
  0x80, 0x30, 0x82, 0x1F, 0x65, 0x14, 0xF3, 0xF8, 0x3E, 0xC1, 0x06, 0x04,
  0x0F, 0x80, 0x02, 0x0C, 0x19, 0xE6, 0x49, 0xB3, 0x66, 0x7C, 0x3D, 0x94,
  0xFC, 0x41, 0xF0, 0x07, 0x0C, 0x08, 0x3F, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x30, 0xE0, 0x3E, 0xC9, 0x12, 0x67, 0xC5, 0x06, 0x78, 0x30, 0x82, 0x1F,
  0x65, 0x34, 0xF2, 0xC8, 0x31, 0x05, 0xC2, 0x31, 0x8C, 0x78, 0x0C, 0x10,
  0x0F, 0x08, 0x21, 0x86, 0x12, 0x4F, 0x00, 0x30, 0x60, 0x81, 0x37, 0x8E,
  0x16, 0x24, 0xCC, 0xE6, 0x44, 0x4C, 0xCC, 0xF0, 0x7E, 0xAD, 0x56, 0xA8,
  0x51, 0x80, 0x7D, 0x96, 0x53, 0x4F, 0x20, 0x3D, 0x94, 0x71, 0xCD, 0xE0,
  0x7D, 0x94, 0x53, 0xCF, 0xE8, 0x20, 0x3E, 0xC9, 0x16, 0x64, 0xCF, 0x02,
  0x0C, 0x3E, 0x41, 0x83, 0x04, 0x18, 0x00, 0x3D, 0x83, 0x06, 0x8F, 0xE0,
  0x30, 0x9F, 0x98, 0x41, 0x04, 0x1E, 0xCF, 0x29, 0xA6, 0x93, 0xE0, 0xCF,
  0x2D, 0xB4, 0x61, 0x80, 0x42, 0xAD, 0x53, 0xAE, 0xD9, 0x00, 0x66, 0x50,
  0xE1, 0xC6, 0x99, 0x80, 0x33, 0x32, 0x36, 0x14, 0x1C, 0x18, 0x10, 0xE0,
  0x3E, 0x10, 0x41, 0x06, 0x1F, 0x00, 0x1C, 0xC3, 0x08, 0x63, 0x04, 0x10,
  0x41, 0x07, 0x00, 0x18, 0x8C, 0x62, 0x11, 0x8C, 0x42, 0x30, 0x38, 0x20,
  0x86, 0x18, 0x31, 0x0C, 0x30, 0x8E, 0x00, 0x26, 0xFB, 0x20,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 5, 4, 7, 2, -9 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 7, 10, 7, 0, -9 },
  { 23, 8, 9, 7, 0, -9 },
  { 32, 6, 9, 7, 0, -9 },
  { 39, 3, 4, 7, 3, -9 },
  { 41, 6, 12, 7, 1, -10 },
  { 50, 5, 12, 7, 0, -10 },
  { 58, 6, 5, 7, 1, -8 },
  { 62, 6, 6, 7, 0, -7 },
  { 67, 3, 4, 7, 1, -2 },
  { 69, 3, 1, 7, 2, -4 },
  { 70, 2, 2, 7, 2, -2 },
  { 71, 8, 11, 7, -1, -9 },
  { 82, 7, 9, 7, 0, -9 },
  { 90, 6, 8, 7, 0, -8 },
  { 96, 7, 9, 7, 0, -9 },
  { 104, 6, 9, 7, 0, -9 },
  { 111, 7, 8, 7, 0, -8 },
  { 118, 7, 8, 7, 0, -8 },
  { 125, 6, 8, 7, 1, -8 },
  { 131, 6, 8, 7, 1, -8 },
  { 137, 7, 9, 7, 0, -9 },
  { 145, 7, 9, 7, 0, -9 },
  { 153, 3, 6, 7, 2, -6 },
  { 156, 4, 8, 7, 1, -6 },
  { 160, 6, 5, 7, 1, -6 },
  { 164, 7, 3, 7, 0, -5 },
  { 167, 6, 5, 7, 0, -6 },
  { 171, 5, 9, 7, 2, -9 },
  { 177, 7, 11, 7, 0, -9 },
  { 187, 7, 8, 7, -1, -8 },
  { 194, 7, 8, 7, 0, -8 },
  { 201, 6, 9, 7, 1, -9 },
  { 208, 7, 8, 7, 0, -8 },
  { 215, 7, 8, 7, 0, -8 },
  { 222, 7, 8, 7, 0, -8 },
  { 229, 6, 9, 7, 1, -9 },
  { 236, 7, 8, 7, 0, -8 },
  { 243, 7, 8, 7, 0, -8 },
  { 250, 7, 8, 7, 0, -8 },
  { 257, 8, 8, 7, 0, -8 },
  { 265, 5, 8, 7, 0, -8 },
  { 270, 7, 8, 7, 0, -8 },
  { 277, 7, 8, 7, 0, -8 },
  { 284, 7, 9, 7, 0, -9 },
  { 292, 7, 8, 7, 0, -8 },
  { 299, 7, 11, 7, 0, -9 },
  { 309, 7, 8, 7, 0, -8 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 7, 8, 7, 1, -8 },
  { 331, 7, 8, 7, 0, -8 },
  { 338, 7, 8, 7, 1, -8 },
  { 345, 8, 8, 7, 0, -8 },
  { 353, 8, 8, 7, 0, -8 },
  { 361, 7, 8, 7, 1, -8 },
  { 368, 7, 8, 7, 0, -8 },
  { 375, 6, 11, 7, 1, -9 },
  { 384, 3, 11, 7, 2, -9 },
  { 389, 6, 11, 7, 0, -9 },
  { 398, 6, 4, 7, 1, -8 },
  { 401, 6, 1, 7, -1, 1 },
  { 402, 3, 2, 7, 3, -9 },
  { 403, 7, 6, 7, 0, -6 },
  { 409, 6, 9, 7, 0, -9 },
  { 416, 7, 6, 7, 0, -6 },
  { 422, 7, 9, 7, 0, -9 },
  { 430, 6, 6, 7, 0, -6 },
  { 435, 8, 11, 7, -1, -9 },
  { 446, 7, 8, 7, 0, -6 },
  { 453, 6, 9, 7, 0, -9 },
  { 460, 5, 9, 7, 1, -9 },
  { 466, 6, 11, 7, 0, -9 },
  { 475, 7, 9, 7, 0, -9 },
  { 483, 4, 9, 7, 2, -9 },
  { 488, 7, 6, 7, 0, -6 },
  { 494, 6, 6, 7, 0, -6 },
  { 499, 6, 6, 7, 0, -6 },
  { 504, 6, 8, 7, 0, -6 },
  { 510, 7, 8, 7, 0, -6 },
  { 517, 7, 6, 7, 0, -6 },
  { 523, 6, 6, 7, 0, -6 },
  { 528, 6, 8, 7, 1, -8 },
  { 534, 6, 6, 7, 1, -6 },
  { 539, 6, 6, 7, 1, -6 },
  { 544, 7, 6, 7, 0, -6 },
  { 550, 7, 6, 7, 0, -6 },
  { 556, 8, 8, 7, -1, -6 },
  { 564, 7, 6, 7, 0, -6 },
  { 570, 6, 11, 7, 1, -9 },
  { 579, 5, 11, 7, 1, -9 },
  { 586, 6, 11, 7, 0, -9 },
  { 595, 7, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC12PT7B_H_
