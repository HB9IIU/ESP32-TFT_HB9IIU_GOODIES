#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC60PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x10, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x3C, 0x01, 0xFE, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x10, 0x00,
  0x0F, 0xF0, 0x18, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x01, 0xF0,
  0x78, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x7E, 0x00, 0x03,
  0xE0, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF1,
  0xF8, 0x00, 0x03, 0xF7, 0xE3, 0xF0, 0x00, 0x03, 0xFF, 0xE7, 0xE0, 0x00,
  0x01, 0xFF, 0xCF, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0xFE,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00,
  0x03, 0xF1, 0xFF, 0x80, 0x00, 0x03, 0xE3, 0xFF, 0xC0, 0x00, 0x07, 0xC7,
  0xFF, 0xC0, 0x00, 0x0F, 0xC7, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x87, 0xC0,
  0x00, 0x3F, 0x0F, 0x83, 0xC0, 0x00, 0x7E, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0xFC, 0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xC0,
  0x7F, 0xF0, 0x1F, 0x83, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F,
  0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0xE7, 0xE1, 0xF8, 0x1F, 0xCF, 0xC7, 0xF0,
  0x3F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFE, 0x3F, 0x80, 0x3F, 0xF8, 0x7F, 0x00,
  0x7F, 0xF0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xE7,
  0xF0, 0x3F, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0, 0x06, 0x00, 0x00,
  0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F,
  0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x07,
  0xE0, 0x21, 0xE0, 0xF8, 0x3C, 0x7F, 0x1F, 0x0F, 0xCF, 0xFB, 0xE7, 0xF9,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x03, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0x10, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xC8, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x0E, 0x07,
  0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF1,
  0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0,
  0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x0F, 0x07, 0xF7, 0xF0, 0x7E, 0x1F, 0xDF, 0xC3, 0xF8,
  0x7F, 0x7F, 0x1F, 0xE1, 0xFD, 0xFC, 0x7F, 0x8F, 0xEF, 0xE1, 0xFE, 0x3F,
  0xBF, 0x87, 0xF0, 0xFE, 0xFE, 0x0F, 0x83, 0xFB, 0xF8, 0x1C, 0x1F, 0xEF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0x8F, 0xF0, 0x03, 0xC1, 0xFC, 0x00, 0x60, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x40, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x20, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0x3F,
  0xF0, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0x1F, 0xF8,
  0x03, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x9F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0xC0, 0x0F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xF0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1E,
  0x01, 0xFF, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x23, 0xF0, 0xFE, 0x01, 0xFF, 0xFC, 0x3F,
  0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0x87, 0xE0, 0x7F, 0xFF, 0xE1,
  0xF8, 0x3F, 0xFF, 0xF8, 0xFC, 0x1F, 0xF9, 0xFE, 0x3F, 0x07, 0xF8, 0x3F,
  0x0F, 0xC3, 0xFC, 0x0F, 0xC3, 0xE0, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x01,
  0xFC, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x87, 0xF0, 0x1F, 0x87, 0xE1, 0xF8,
  0x0F, 0xE1, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x07,
  0xE0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0xC1, 0xF0, 0x7E, 0x07, 0xF0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xC1, 0xFF, 0x3F, 0x81,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xFC,
  0x07, 0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x7F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0xFE,
  0x07, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x20, 0x03, 0xFF,
  0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x7F,
  0xF8, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0x00, 0x0C, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xC0,
  0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x1F,
  0xF0, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x7C,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x79, 0xF0, 0x03, 0xF7, 0xC3, 0xEF, 0xC0,
  0x0F, 0xDF, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x7C, 0xFC, 0x01, 0xF8, 0xF3,
  0xE3, 0xE0, 0x07, 0xE3, 0xCF, 0x9F, 0x80, 0x1F, 0x8F, 0x7C, 0x7E, 0x00,
  0xFC, 0x3D, 0xF1, 0xF8, 0x03, 0xF0, 0xFF, 0x87, 0xE0, 0x0F, 0xC3, 0xFE,
  0x3F, 0x00, 0x3F, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0xC3, 0xF0, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xF7, 0xC0, 0x3F, 0x80, 0x1F, 0xBF, 0x01,
  0xFC, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x0F, 0xEF, 0xC0, 0x7E, 0x00, 0x7F,
  0x3E, 0x07, 0xF0, 0x03, 0xF1, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xC1, 0xFC,
  0x01, 0xFC, 0x3E, 0x0F, 0xC0, 0x0F, 0xE1, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC7, 0xF0, 0x07, 0xF0, 0x7E, 0x3F, 0x80, 0x3F, 0x83, 0xF1, 0xF8, 0x01,
  0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0xC0, 0x7C, 0xFE, 0x00, 0xFE, 0x03, 0xF7,
  0xF0, 0x07, 0xF0, 0x1F, 0xBF, 0x00, 0x3F, 0x80, 0x7D, 0xF8, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x02,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x60, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x1F, 0xF0, 0x0F,
  0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x7E, 0x1F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xF0, 0x7E, 0x01,
  0xF8, 0x7F, 0x87, 0xF0, 0x0F, 0xC7, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0xE1,
  0xF8, 0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0x3F, 0x1F, 0x7C, 0x7C, 0x01, 0xF9,
  0xF3, 0xE7, 0xE0, 0x0F, 0xCF, 0x9F, 0x3F, 0x00, 0x7C, 0xF8, 0xF9, 0xF8,
  0x03, 0xE7, 0xC7, 0xCF, 0x80, 0x3F, 0x7C, 0x3E, 0xFC, 0x01, 0xFB, 0xC1,
  0xF7, 0xE0, 0x0F, 0xBE, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x3D, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x1E, 0x01, 0x00,
  0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x18, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xC0, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF7, 0xF8, 0x03,
  0xFF, 0x87, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF8, 0x7F, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0xC3, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x0F,
  0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xE7, 0xF0, 0x0F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x06, 0x03, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x06, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0xFF,
  0x80, 0x07, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE1, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xEF, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x06, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x7F, 0x03,
  0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x83, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xC3, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xC1, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x10, 0x00, 0x1F, 0xC0,
  0x70, 0x01, 0xFF, 0x03, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x0E, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0xFE, 0x00, 0xFF, 0xE1, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0x1F, 0x87, 0xE0, 0xFF, 0x07,
  0xE1, 0xF8, 0x3F, 0xC3, 0xF0, 0x7E, 0x1F, 0xF0, 0xFC, 0x1F, 0x87, 0xFC,
  0x3F, 0x07, 0xE3, 0xFF, 0x1F, 0x81, 0xF8, 0xFF, 0xC7, 0xE0, 0x7C, 0x7F,
  0xF1, 0xF0, 0x1F, 0x1F, 0x7C, 0xFC, 0x07, 0xCF, 0x9F, 0x3F, 0x01, 0xF3,
  0xE7, 0xCF, 0x80, 0xFD, 0xF0, 0xF7, 0xE0, 0x3F, 0x7C, 0x3D, 0xF8, 0x0F,
  0xFE, 0x0F, 0x7C, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0x81, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x07,
  0xFF, 0x80, 0x3F, 0x0F, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF, 0xF8, 0x7E,
  0x07, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xC0, 0x0C,
  0x00, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 18, 43, 34, 9, -42 },
  { 98, 23, 19, 34, 11, -46 },
  { 153, 36, 42, 34, 0, -42 },
  { 342, 32, 54, 34, 1, -47 },
  { 558, 40, 44, 34, -2, -43 },
  { 778, 31, 44, 34, 1, -43 },
  { 949, 10, 20, 34, 17, -46 },
  { 974, 26, 59, 34, 7, -48 },
  { 1166, 26, 59, 34, 1, -48 },
  { 1358, 27, 26, 34, 6, -42 },
  { 1446, 30, 30, 34, 2, -33 },
  { 1559, 16, 21, 34, 4, -11 },
  { 1601, 19, 7, 34, 8, -21 },
  { 1618, 11, 12, 34, 9, -11 },
  { 1635, 39, 58, 34, -3, -47 },
  { 1918, 30, 44, 34, 3, -43 },
  { 2083, 27, 42, 34, 2, -42 },
  { 2225, 32, 43, 34, 1, -43 },
  { 2397, 32, 44, 34, 0, -43 },
  { 2573, 33, 42, 34, 0, -42 },
  { 2747, 35, 43, 34, 0, -42 },
  { 2936, 32, 43, 34, 3, -42 },
  { 3108, 31, 42, 34, 6, -42 },
  { 3271, 32, 44, 34, 2, -43 },
  { 3447, 31, 43, 34, 2, -43 },
  { 3614, 16, 33, 34, 9, -32 },
  { 3680, 21, 42, 34, 4, -32 },
  { 3791, 30, 28, 34, 3, -31 },
  { 3896, 32, 19, 34, 1, -27 },
  { 3972, 31, 28, 34, 1, -31 },
  { 4081, 25, 44, 34, 8, -43 },
  { 4219, 34, 52, 34, 1, -43 },
  { 4440, 32, 42, 34, -3, -42 },
  { 4608, 33, 42, 34, 0, -42 },
  { 4782, 33, 44, 34, 3, -43 },
  { 4964, 33, 42, 34, 0, -42 },
  { 5138, 35, 42, 34, 1, -42 },
  { 5322, 35, 42, 34, 2, -42 },
  { 5506, 32, 44, 34, 3, -43 },
  { 5682, 38, 42, 34, -1, -42 },
  { 5882, 34, 42, 34, 1, -42 },
  { 6061, 34, 43, 34, 1, -42 },
  { 6244, 38, 42, 34, 0, -42 },
  { 6444, 26, 42, 34, 1, -42 },
  { 6581, 38, 42, 34, -2, -42 },
  { 6781, 37, 42, 34, 0, -42 },
  { 6976, 32, 44, 34, 2, -43 },
  { 7152, 35, 42, 34, 0, -42 },
  { 7336, 32, 54, 34, 2, -43 },
  { 7552, 33, 42, 34, 0, -42 },
  { 7726, 34, 44, 34, 0, -43 },
  { 7913, 31, 42, 34, 7, -42 },
  { 8076, 34, 43, 34, 2, -42 },
  { 8259, 32, 42, 34, 7, -42 },
  { 8427, 37, 42, 34, 1, -42 },
  { 8622, 40, 42, 34, -2, -42 },
  { 8832, 32, 42, 34, 7, -42 },
  { 9000, 36, 42, 34, 0, -42 },
  { 9189, 32, 58, 34, 4, -47 },
  { 9421, 12, 58, 34, 12, -47 },
  { 9508, 32, 58, 34, -1, -47 },
  { 9740, 30, 24, 34, 3, -42 },
  { 9830, 32, 6, 34, -5, 5 },
  { 9854, 14, 12, 34, 14, -46 },
  { 9875, 31, 33, 34, 2, -32 },
  { 10003, 30, 48, 34, 1, -47 },
  { 10183, 30, 33, 34, 3, -32 },
  { 10307, 35, 48, 34, 2, -47 },
  { 10517, 30, 33, 34, 2, -32 },
  { 10641, 41, 58, 34, -4, -47 },
  { 10939, 35, 43, 34, -2, -32 },
  { 11128, 30, 47, 34, 0, -47 },
  { 11305, 23, 48, 34, 5, -47 },
  { 11443, 33, 58, 34, -2, -47 },
  { 11683, 34, 47, 34, 1, -47 },
  { 11883, 20, 47, 34, 8, -46 },
  { 12001, 34, 32, 34, -1, -32 },
  { 12137, 30, 32, 34, 1, -32 },
  { 12257, 29, 33, 34, 2, -32 },
  { 12377, 34, 43, 34, -2, -32 },
  { 12560, 30, 43, 34, 3, -32 },
  { 12722, 30, 32, 34, 3, -32 },
  { 12842, 30, 33, 34, 1, -32 },
  { 12966, 28, 42, 34, 5, -41 },
  { 13113, 30, 32, 34, 3, -31 },
  { 13233, 29, 31, 34, 5, -31 },
  { 13346, 34, 31, 34, 2, -31 },
  { 13478, 36, 31, 34, -2, -31 },
  { 13618, 39, 42, 34, -5, -31 },
  { 13823, 32, 31, 34, 1, -31 },
  { 13947, 32, 58, 34, 4, -47 },
  { 14179, 22, 58, 34, 6, -47 },
  { 14339, 32, 58, 34, -2, -47 },
  { 14571, 32, 12, 34, 1, -24 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic60pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC60PT7B_H_
