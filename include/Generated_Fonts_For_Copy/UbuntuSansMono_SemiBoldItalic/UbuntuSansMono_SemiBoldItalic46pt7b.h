#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC46PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xE1,
  0xE0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x07,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFC, 0x03, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x81, 0x80, 0x1F, 0xC1, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3C,
  0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xC0, 0x3E, 0x78, 0x0F, 0x80,
  0x78, 0xF0, 0x3E, 0x00, 0xE1, 0xE0, 0x78, 0x03, 0xC3, 0xC1, 0xE0, 0x07,
  0x87, 0x87, 0x80, 0x0F, 0x0E, 0x1E, 0x00, 0x1E, 0x3C, 0x7C, 0x00, 0x3C,
  0x79, 0xF0, 0x00, 0x79, 0xE3, 0xC0, 0x00, 0xFF, 0xCF, 0x00, 0x00, 0xFF,
  0x3C, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x79, 0xFE, 0x00, 0x01, 0xE7,
  0xFC, 0x00, 0x07, 0x8F, 0x7C, 0x00, 0x1E, 0x3C, 0x78, 0x00, 0x7C, 0x70,
  0xF0, 0x01, 0xF1, 0xE1, 0xE0, 0x03, 0xC3, 0xC3, 0xC0, 0x0F, 0x07, 0x87,
  0x00, 0x3C, 0x0F, 0x1E, 0x00, 0xF0, 0x1E, 0x3C, 0x03, 0xE0, 0x3C, 0xF0,
  0x0F, 0x80, 0x7F, 0xE0, 0x1E, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC1,
  0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0x07, 0xFC, 0x1E, 0x1F, 0xFC,
  0x3E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3F, 0x7C, 0x7C, 0x1F, 0x7C, 0xF8, 0x1F,
  0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0xF0, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE,
  0xF8, 0x7F, 0xF8, 0xF8, 0x1F, 0xE0, 0xFC, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x40, 0xF0, 0x27, 0x0F, 0x0E, 0x7C, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x0E,
  0x07, 0x00, 0x20, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xE0, 0x3E, 0x07,
  0xC3, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x04, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC3, 0x87, 0xDF, 0x8F, 0x8F, 0xBE, 0x3F, 0x1F, 0x7C, 0x7E, 0x7E,
  0xF8, 0xFC, 0xFF, 0xF1, 0xF1, 0xF7, 0xE1, 0xC3, 0xEF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x07, 0xE1, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0,
  0x78, 0xFC, 0x06, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xC0, 0x3F, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0x83, 0xFC, 0x03, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x04, 0x00, 0x3F, 0x87, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x05, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x80,
  0x0F, 0xE0, 0x1E, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF1, 0xF8, 0x01, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xEF, 0xF8, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7C, 0x07, 0xE1, 0xFC, 0x07, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x3F, 0x0F, 0xF0, 0x7E,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x87, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07,
  0xE0, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3C, 0x1F, 0xC4, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x07, 0x7C, 0x7C, 0x0F, 0xFF,
  0x3E, 0x0F, 0xFF, 0x8F, 0x87, 0xFF, 0xE3, 0xC3, 0xFF, 0xF9, 0xF0, 0xFC,
  0x3E, 0x7C, 0x7E, 0x1F, 0x1E, 0x1F, 0x07, 0xC7, 0x87, 0xC1, 0xF1, 0xE3,
  0xE0, 0x7C, 0xF8, 0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xE3,
  0xE3, 0xE0, 0xF8, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0xE7,
  0xC3, 0xE1, 0xFF, 0xF0, 0xF8, 0x7F, 0xFC, 0x3E, 0x0F, 0xFE, 0x07, 0x80,
  0xFF, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x83, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x9E, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x7C, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x07, 0xF0, 0x06,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x40, 0x7F, 0xC3, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7C, 0x01, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x83, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xE0, 0x08, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xFC, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x02, 0x00, 0x7E, 0x00, 0xE0, 0x1F, 0xC0, 0x1F, 0x8F, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x7D, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3D, 0xE3, 0xDE, 0x03,
  0xDE, 0x39, 0xE0, 0x7D, 0xE7, 0xBE, 0x07, 0xDE, 0x73, 0xE0, 0x79, 0xEF,
  0x3C, 0x0F, 0x8E, 0xE3, 0xC0, 0xF8, 0xFE, 0x7C, 0x0F, 0x8F, 0xC7, 0xC0,
  0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0x81, 0xF0, 0xF8, 0xF8, 0x1F, 0x0F,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0,
  0x3E, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0xC0,
  0x7D, 0xE0, 0x7C, 0x07, 0xDE, 0x07, 0xC0, 0x7D, 0xF0, 0xF8, 0x0F, 0x9F,
  0x0F, 0x80, 0xF8, 0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x80, 0xF8, 0xF9, 0xF0,
  0x1F, 0x0F, 0x9F, 0x01, 0xF0, 0x79, 0xF0, 0x1F, 0x07, 0x9F, 0x01, 0xF0,
  0x7B, 0xE0, 0x3E, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x03, 0xFE,
  0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x7C,
  0x01, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFD, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0,
  0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFD, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x3F, 0x03, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0x83, 0xE0, 0x3F, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0xC0, 0x07, 0xF0, 0x7E, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xBC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC3, 0xE0, 0x7C, 0x7E, 0x1E, 0x03, 0xE3, 0xF1,
  0xF0, 0x1F, 0x3F, 0x8F, 0x80, 0xF1, 0xDC, 0x78, 0x0F, 0x9E, 0xE3, 0xC0,
  0x7D, 0xE7, 0x3E, 0x03, 0xEF, 0x39, 0xF0, 0x1E, 0xF1, 0xEF, 0x00, 0xF7,
  0x8F, 0x78, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xBE, 0x00, 0xFE, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0x78, 0x00, 0x7C, 0x40, 0x01, 0x80, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE0, 0x20, 0x0C, 0x07, 0x83, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0x03, 0x80, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x7E, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x3E, 0x03, 0xF8, 0x7E, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xBF, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0x03, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0x07, 0xFE, 0x7E,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x04, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFC, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC7, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xF7,
  0xE0, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x01, 0x07, 0xF8, 0x1E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0x60, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xDF,
  0x00, 0x00, 0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x10, 0x01, 0xFC, 0x03, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x9C,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xF1, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x01, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x02, 0x00, 0xFC, 0x00, 0xF0, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x0F,
  0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x5F,
  0xF7, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x04, 0x00, 0x01,
  0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xC7, 0xC7, 0xC1, 0xE1, 0xF1, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xE0, 0xF0, 0xF8, 0xF8, 0x7C,
  0x3C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC7, 0xC3, 0xC1, 0xE1, 0xF1, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF0,
  0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E,
  0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF3, 0xF8, 0x1F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0x7E, 0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8,
  0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x0F,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0xDF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xC8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE,
  0x0F, 0xC7, 0xF0, 0x1F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x02, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFE, 0x03, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0x00, 0x1F, 0x87, 0xC0, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x02, 0x0F, 0xFB, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07,
  0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC,
  0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87,
  0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xFB, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFC, 0x0F, 0xF8, 0xF8, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x01, 0xF8, 0x7C,
  0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F,
  0x0F, 0x07, 0xC7, 0x83, 0xE1, 0xF1, 0xE1, 0xF8, 0x78, 0xF8, 0x7E, 0x3E,
  0x3E, 0x3F, 0x8F, 0x8F, 0x8F, 0xE3, 0xC3, 0xE7, 0xF9, 0xF0, 0xF9, 0xFE,
  0x7C, 0x3C, 0xF7, 0x9E, 0x0F, 0x3D, 0xEF, 0x83, 0xDE, 0x7B, 0xC0, 0xF7,
  0x8E, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x3E,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x08, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x04, 0x3F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x0C, 0x0F, 0xF8, 0x0F, 0x1F, 0xFC, 0x1F, 0x3F,
  0xFF, 0x7E, 0x7F, 0xFF, 0xFE, 0x7E, 0x7F, 0xFC, 0xF8, 0x3F, 0xF8, 0xF8,
  0x0F, 0xF0, 0x10, 0x03, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 14, 33, 26, 7, -32 },
  { 59, 18, 14, 26, 8, -35 },
  { 91, 27, 32, 26, 0, -32 },
  { 199, 25, 41, 26, 1, -36 },
  { 328, 31, 34, 26, -2, -33 },
  { 460, 24, 33, 26, 1, -33 },
  { 559, 8, 15, 26, 13, -35 },
  { 574, 20, 45, 26, 5, -36 },
  { 687, 21, 45, 26, 0, -36 },
  { 806, 20, 20, 26, 5, -32 },
  { 856, 22, 23, 26, 2, -25 },
  { 920, 12, 16, 26, 3, -8 },
  { 944, 14, 6, 26, 6, -16 },
  { 955, 8, 9, 26, 7, -8 },
  { 964, 31, 45, 26, -3, -36 },
  { 1139, 23, 34, 26, 2, -33 },
  { 1237, 20, 32, 26, 2, -32 },
  { 1317, 24, 33, 26, 1, -33 },
  { 1416, 25, 34, 26, 0, -33 },
  { 1523, 26, 32, 26, 0, -32 },
  { 1627, 27, 33, 26, 0, -32 },
  { 1739, 25, 33, 26, 2, -32 },
  { 1843, 25, 32, 26, 4, -32 },
  { 1943, 24, 34, 26, 2, -33 },
  { 2045, 25, 33, 26, 1, -33 },
  { 2149, 12, 25, 26, 7, -24 },
  { 2187, 16, 32, 26, 3, -24 },
  { 2251, 23, 22, 26, 2, -24 },
  { 2315, 24, 15, 26, 1, -21 },
  { 2360, 23, 22, 26, 1, -24 },
  { 2424, 19, 34, 26, 6, -33 },
  { 2505, 26, 40, 26, 1, -33 },
  { 2635, 25, 32, 26, -2, -32 },
  { 2735, 25, 32, 26, 0, -32 },
  { 2835, 24, 34, 26, 3, -33 },
  { 2937, 25, 32, 26, 0, -32 },
  { 3037, 26, 32, 26, 1, -32 },
  { 3141, 27, 32, 26, 1, -32 },
  { 3249, 25, 34, 26, 2, -33 },
  { 3356, 28, 32, 26, 0, -32 },
  { 3468, 27, 32, 26, 0, -32 },
  { 3576, 27, 33, 26, 0, -32 },
  { 3688, 29, 32, 26, 0, -32 },
  { 3804, 21, 32, 26, 0, -32 },
  { 3888, 28, 32, 26, -1, -32 },
  { 4000, 28, 32, 26, 0, -32 },
  { 4112, 24, 34, 26, 2, -33 },
  { 4214, 26, 32, 26, 0, -32 },
  { 4318, 24, 42, 26, 2, -33 },
  { 4444, 25, 32, 26, 0, -32 },
  { 4544, 26, 34, 26, 0, -33 },
  { 4655, 24, 32, 26, 5, -32 },
  { 4751, 26, 33, 26, 2, -32 },
  { 4859, 25, 32, 26, 5, -32 },
  { 4959, 29, 32, 26, 0, -32 },
  { 5075, 31, 32, 26, -2, -32 },
  { 5199, 25, 32, 26, 5, -32 },
  { 5299, 28, 32, 26, 0, -32 },
  { 5411, 24, 45, 26, 3, -36 },
  { 5546, 9, 45, 26, 9, -36 },
  { 5597, 24, 45, 26, -1, -36 },
  { 5732, 22, 18, 26, 3, -32 },
  { 5782, 25, 5, 26, -4, 4 },
  { 5798, 10, 10, 26, 11, -36 },
  { 5811, 24, 26, 26, 1, -25 },
  { 5889, 24, 37, 26, 0, -36 },
  { 6000, 23, 26, 26, 2, -25 },
  { 6075, 26, 37, 26, 2, -36 },
  { 6196, 23, 26, 26, 2, -25 },
  { 6271, 32, 45, 26, -3, -36 },
  { 6451, 27, 34, 26, -2, -25 },
  { 6566, 23, 36, 26, 0, -36 },
  { 6670, 17, 36, 26, 4, -36 },
  { 6747, 26, 45, 26, -2, -36 },
  { 6894, 26, 36, 26, 1, -36 },
  { 7011, 15, 36, 26, 6, -35 },
  { 7079, 26, 24, 26, -1, -24 },
  { 7157, 23, 25, 26, 1, -25 },
  { 7229, 22, 26, 26, 2, -25 },
  { 7301, 26, 34, 26, -2, -25 },
  { 7412, 23, 34, 26, 2, -25 },
  { 7510, 23, 25, 26, 2, -25 },
  { 7582, 23, 26, 26, 1, -25 },
  { 7657, 21, 32, 26, 4, -31 },
  { 7741, 23, 25, 26, 2, -24 },
  { 7813, 22, 24, 26, 4, -24 },
  { 7879, 26, 24, 26, 2, -24 },
  { 7957, 27, 24, 26, -1, -24 },
  { 8038, 30, 33, 26, -4, -24 },
  { 8162, 24, 24, 26, 1, -24 },
  { 8234, 25, 45, 26, 3, -36 },
  { 8375, 16, 45, 26, 5, -36 },
  { 8465, 25, 45, 26, -2, -36 },
  { 8606, 24, 9, 26, 1, -18 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC46PT7B_H_
