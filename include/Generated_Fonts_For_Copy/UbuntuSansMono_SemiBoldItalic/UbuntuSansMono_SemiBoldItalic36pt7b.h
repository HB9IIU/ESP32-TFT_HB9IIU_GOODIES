#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC36PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00,
  0x7C, 0xFB, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9C,
  0x3C, 0xE1, 0xE7, 0x0E, 0x30, 0x70, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0,
  0x1E, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x38, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78, 0x70, 0x03, 0x87,
  0x80, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xBE, 0x0F, 0x80, 0x41, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1E, 0x10, 0x07, 0xC3, 0x81, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x0F, 0x07, 0xF0,
  0x1E, 0x07, 0x78, 0x1C, 0x0E, 0x38, 0x38, 0x0E, 0x38, 0x70, 0x0C, 0x30,
  0xE0, 0x1C, 0x71, 0xE0, 0x1C, 0x73, 0xC0, 0x1C, 0xF3, 0x80, 0x1F, 0xE7,
  0x00, 0x0F, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0xF7, 0xF0, 0x00, 0xE7, 0xF0, 0x01, 0xCE, 0x70, 0x03, 0x8E,
  0x30, 0x07, 0x9C, 0x70, 0x0F, 0x1C, 0x70, 0x1E, 0x1C, 0x70, 0x1C, 0x1C,
  0x70, 0x38, 0x1E, 0xE0, 0x70, 0x1F, 0xE0, 0xE0, 0x0F, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3C,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1,
  0xE0, 0x1E, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC3, 0xC3, 0xFC,
  0x78, 0xF7, 0xCF, 0x3C, 0x7B, 0xCF, 0x0F, 0xF9, 0xE0, 0xFE, 0x3C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x1F, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xF7,
  0x83, 0xF8, 0xF8, 0x3D, 0xF7, 0xDF, 0x79, 0xEF, 0xBC, 0xF3, 0x8E, 0x00,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x20, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0xC2, 0x73, 0x8E, 0xFB, 0xBE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0xF8,
  0x7E, 0x7C, 0x3C, 0x78, 0x1C, 0x30, 0x08, 0x20, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFA, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x0F, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x38, 0x1E, 0x1F,
  0x3F, 0x87, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x7C, 0xFF,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xCF,
  0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7,
  0x84, 0x3D, 0xE7, 0x9F, 0xF9, 0xE7, 0xFC, 0xF9, 0xEF, 0x1E, 0x7B, 0xC6,
  0x1E, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3C, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x3C, 0x0C, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xE7, 0xF0, 0x30, 0x1F, 0x02, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3C, 0x7E, 0x04, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x80,
  0x1F, 0x1E, 0x1F, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x3C, 0x07, 0x87, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x04, 0x00, 0xF8,
  0x3C, 0x3F, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x8E, 0x01, 0xEF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x3E, 0x3C,
  0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x81, 0xF0, 0xF8, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7C, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x78, 0x3E, 0x1F, 0x03, 0xEF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0x81, 0xF1, 0xF8, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0,
  0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3F, 0x0F, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0xFC, 0x3E, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9F,
  0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x7F, 0x01, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE2,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0x87, 0xE4, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC1,
  0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x0F, 0xF3, 0xC3,
  0xFF, 0x78, 0x7F, 0xF7, 0x8F, 0xFE, 0x71, 0xF1, 0xE7, 0x1E, 0x1E, 0xF1,
  0xC1, 0xEF, 0x3C, 0x3C, 0xF3, 0xC3, 0xCF, 0x3C, 0x3C, 0xE3, 0xC3, 0xCE,
  0x3C, 0x78, 0xE3, 0xE7, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x0F, 0xF0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0,
  0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x81, 0xF0, 0x78, 0x0F,
  0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x7E, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1E, 0x07, 0xC3, 0xE0,
  0x3C, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x78,
  0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x3C,
  0x1F, 0x00, 0x87, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x04, 0x1F, 0xCF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x07, 0xC3,
  0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x78, 0x3F, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0x3C, 0x1F, 0x00, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x1F, 0x8F, 0x83,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0x03, 0xF0, 0x3E, 0x7F, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x07, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x3E,
  0x00, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x00,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78,
  0x7C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x03,
  0xF0, 0xFC, 0x1F, 0xC7, 0x70, 0x77, 0x1F, 0xC1, 0xDC, 0xEE, 0x07, 0x73,
  0xB8, 0x3D, 0xDC, 0xE0, 0xF7, 0x77, 0x83, 0x9F, 0x9E, 0x1E, 0x7E, 0x78,
  0x79, 0xF1, 0xC1, 0xE7, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x1F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x3F,
  0x81, 0xE0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0x70, 0xF0, 0x79, 0xC3,
  0xC1, 0xE7, 0x8F, 0x07, 0x9E, 0x78, 0x1E, 0x39, 0xE0, 0xF0, 0xE7, 0x83,
  0xC3, 0x9E, 0x0F, 0x0F, 0xF0, 0x3C, 0x1F, 0xC0, 0xE0, 0x7F, 0x07, 0x81,
  0xFC, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x3E, 0x0F, 0x00, 0xF8,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x7E, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF8,
  0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0,
  0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x9F,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x1F,
  0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78,
  0x07, 0x83, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x03, 0xFF, 0xE0, 0x7E, 0x7E, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x0F,
  0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x3E,
  0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x9F, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x81,
  0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x8F, 0x80, 0x78,
  0xF8, 0x07, 0x80, 0x00, 0x06, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xE1, 0xE0, 0x7C, 0x02, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x82, 0x00, 0xF8, 0x7C, 0x7F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0,
  0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x70,
  0xE0, 0x71, 0xE3, 0xC1, 0xE3, 0xC7, 0x83, 0xCF, 0x8E, 0x07, 0x9F, 0x9C,
  0x0E, 0x77, 0x78, 0x1D, 0xCE, 0xF0, 0x3B, 0x9D, 0xC0, 0xFE, 0x3B, 0x81,
  0xDC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x00,
  0xF1, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07,
  0xCF, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x3E, 0x1F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xFB,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF1, 0xE3, 0xE7, 0xCF,
  0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x3E, 0x7C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0xF9, 0xF3, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x8F,
  0x83, 0xE7, 0xC0, 0x7B, 0xF0, 0x1F, 0x78, 0x07, 0xCC, 0x00, 0xC0, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x18, 0x1F,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1C, 0x04, 0x00, 0xFF, 0xA0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x1F, 0x01, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x03, 0xE3, 0xE0,
  0xFC, 0x7C, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x20,
  0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xFE,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1E,
  0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7E,
  0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0x9E, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x1F, 0x1F, 0x03, 0xCF, 0x80, 0xF3,
  0xC0, 0x3D, 0xF0, 0x1F, 0x78, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0x80, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x38, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x82, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x47,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF3,
  0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x30, 0x3F, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F,
  0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x03,
  0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF3,
  0xE0, 0x78, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x04, 0x07, 0xC0, 0x60, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x03, 0xE0, 0xF0,
  0x7C, 0x1F, 0x0F, 0x81, 0xF3, 0xF0, 0x1F, 0x7E, 0x01, 0xEF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xDF, 0x00, 0x3C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0x7C, 0x07, 0x83, 0xC0, 0x78, 0x3E, 0x0F, 0x81, 0xE0,
  0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0x7F, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x7E, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x03,
  0xF3, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1E, 0x7D, 0xF0, 0xF3, 0xC7,
  0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x1E, 0x1E, 0x38, 0xF0, 0xE3,
  0xC7, 0x8F, 0x1E, 0x38, 0x78, 0xF3, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0,
  0x7C, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xC0,
  0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x03,
  0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x81,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7B,
  0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xF1, 0xFB, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1,
  0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07, 0xCF,
  0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x83, 0xE3, 0xF3,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0x3E, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC4, 0x01, 0xE1, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F,
  0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xFD, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x3E, 0x07,
  0xCF, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0xF8, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xF7, 0xF0, 0xFF, 0xFE,
  0x1F, 0xF7, 0x83, 0xF9, 0xE0, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78,
  0x7C, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x79, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x87,
  0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x3E, 0x38, 0x71, 0xF3, 0xC3,
  0x9F, 0x9E, 0x1C, 0xFC, 0xE0, 0xEE, 0xEF, 0x0F, 0x73, 0x70, 0x7F, 0x1B,
  0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3C,
  0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xE0, 0x3E, 0x07,
  0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F,
  0x00, 0x78, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x08, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x81, 0x87,
  0xF8, 0x3D, 0xFF, 0xCF, 0x3F, 0xFF, 0xCF, 0x1F, 0xF9, 0xE0, 0xFE, 0x08,
  0x07, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 25, 20, 5, -25 },
  { 36, 13, 11, 20, 7, -27 },
  { 54, 21, 25, 20, 0, -25 },
  { 120, 19, 32, 20, 1, -28 },
  { 196, 24, 27, 20, -1, -26 },
  { 277, 19, 26, 20, 0, -26 },
  { 339, 6, 11, 20, 10, -27 },
  { 348, 16, 36, 20, 4, -29 },
  { 420, 16, 36, 20, 0, -29 },
  { 492, 16, 16, 20, 4, -25 },
  { 524, 18, 18, 20, 1, -20 },
  { 565, 10, 12, 20, 2, -6 },
  { 580, 11, 4, 20, 5, -12 },
  { 586, 7, 6, 20, 5, -6 },
  { 592, 24, 35, 20, -2, -28 },
  { 697, 18, 27, 20, 2, -26 },
  { 758, 16, 25, 20, 1, -25 },
  { 808, 20, 26, 20, 0, -26 },
  { 873, 19, 27, 20, 0, -26 },
  { 938, 20, 25, 20, 0, -25 },
  { 1001, 21, 26, 20, 0, -25 },
  { 1070, 19, 26, 20, 2, -25 },
  { 1132, 19, 25, 20, 3, -25 },
  { 1192, 19, 27, 20, 1, -26 },
  { 1257, 19, 26, 20, 1, -26 },
  { 1319, 10, 18, 20, 5, -18 },
  { 1342, 13, 24, 20, 2, -18 },
  { 1381, 18, 17, 20, 2, -19 },
  { 1420, 20, 11, 20, 0, -16 },
  { 1448, 18, 17, 20, 1, -19 },
  { 1487, 15, 26, 20, 5, -26 },
  { 1536, 20, 31, 20, 1, -26 },
  { 1614, 20, 25, 20, -2, -25 },
  { 1677, 20, 25, 20, 0, -25 },
  { 1740, 19, 27, 20, 2, -26 },
  { 1805, 20, 25, 20, 0, -25 },
  { 1868, 20, 25, 20, 1, -25 },
  { 1931, 21, 25, 20, 1, -25 },
  { 1997, 19, 27, 20, 2, -26 },
  { 2062, 22, 25, 20, 0, -25 },
  { 2131, 21, 25, 20, 0, -25 },
  { 2197, 21, 26, 20, 0, -25 },
  { 2266, 23, 25, 20, 0, -25 },
  { 2338, 16, 25, 20, 0, -25 },
  { 2388, 22, 25, 20, -1, -25 },
  { 2457, 22, 25, 20, 0, -25 },
  { 2526, 19, 27, 20, 1, -26 },
  { 2591, 21, 25, 20, 0, -25 },
  { 2657, 19, 33, 20, 1, -26 },
  { 2736, 20, 25, 20, 0, -25 },
  { 2799, 20, 27, 20, 0, -26 },
  { 2867, 19, 25, 20, 4, -25 },
  { 2927, 21, 26, 20, 1, -25 },
  { 2996, 19, 25, 20, 4, -25 },
  { 3056, 23, 25, 20, 0, -25 },
  { 3128, 24, 25, 20, -1, -25 },
  { 3203, 19, 25, 20, 4, -25 },
  { 3263, 22, 25, 20, 0, -25 },
  { 3332, 19, 35, 20, 2, -28 },
  { 3416, 7, 35, 20, 7, -28 },
  { 3447, 19, 35, 20, -1, -28 },
  { 3531, 18, 14, 20, 2, -25 },
  { 3563, 19, 4, 20, -3, 3 },
  { 3573, 9, 8, 20, 8, -28 },
  { 3582, 19, 19, 20, 1, -19 },
  { 3628, 19, 29, 20, 0, -28 },
  { 3697, 18, 19, 20, 2, -19 },
  { 3740, 21, 28, 20, 1, -28 },
  { 3814, 18, 19, 20, 1, -19 },
  { 3857, 24, 35, 20, -2, -28 },
  { 3962, 21, 26, 20, -1, -19 },
  { 4031, 18, 28, 20, 0, -28 },
  { 4094, 14, 28, 20, 3, -28 },
  { 4143, 20, 35, 20, -1, -28 },
  { 4231, 20, 28, 20, 1, -28 },
  { 4301, 12, 28, 20, 5, -28 },
  { 4343, 21, 19, 20, -1, -19 },
  { 4393, 19, 19, 20, 0, -19 },
  { 4439, 18, 20, 20, 1, -19 },
  { 4484, 20, 26, 20, -1, -19 },
  { 4549, 18, 26, 20, 2, -19 },
  { 4608, 18, 19, 20, 2, -19 },
  { 4651, 18, 20, 20, 1, -19 },
  { 4696, 17, 25, 20, 3, -25 },
  { 4750, 18, 19, 20, 2, -19 },
  { 4793, 18, 19, 20, 3, -19 },
  { 4836, 21, 19, 20, 1, -19 },
  { 4886, 22, 19, 20, -1, -19 },
  { 4939, 23, 26, 20, -3, -19 },
  { 5014, 19, 19, 20, 1, -19 },
  { 5060, 20, 35, 20, 2, -28 },
  { 5148, 13, 35, 20, 4, -28 },
  { 5205, 19, 35, 20, -1, -28 },
  { 5289, 19, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC36PT7B_H_
