#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC44PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x3F, 0x1F, 0xBF, 0x0F,
  0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x80,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78,
  0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xE0, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x81,
  0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x1C, 0x07, 0xE0, 0x04, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x20,
  0x03, 0xF0, 0x7C, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x04, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0xFB,
  0xC0, 0x3C, 0x03, 0xC7, 0x01, 0xE0, 0x0E, 0x1C, 0x0F, 0x00, 0x78, 0x70,
  0x78, 0x01, 0xE3, 0xC3, 0xC0, 0x07, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0xF8,
  0x00, 0x71, 0xE3, 0xC0, 0x01, 0xEF, 0x9E, 0x00, 0x07, 0xFC, 0xF0, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x86, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x0F,
  0x3F, 0xF0, 0x00, 0x78, 0xF3, 0xC0, 0x03, 0xE7, 0x8F, 0x00, 0x0F, 0x1C,
  0x3C, 0x00, 0x78, 0x70, 0xF0, 0x03, 0xC3, 0xC3, 0x80, 0x1E, 0x0F, 0x0E,
  0x00, 0xF0, 0x3C, 0x78, 0x07, 0x80, 0xF1, 0xC0, 0x3E, 0x03, 0xFF, 0x00,
  0xF0, 0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0x0F, 0xF8, 0x3C,
  0x3F, 0xF8, 0xF8, 0xF9, 0xF9, 0xE3, 0xE1, 0xF7, 0xCF, 0x83, 0xFF, 0x9F,
  0x03, 0xFE, 0x3E, 0x03, 0xF8, 0x7C, 0x07, 0xF0, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0xC3, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0x0F, 0xFF,
  0x3E, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x38, 0xF0, 0xE7, 0xC7, 0x1E, 0x7F, 0x77, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xDF, 0x00, 0xFD,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0x07, 0x80, 0x30, 0x60, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7E,
  0x0F, 0xE0, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x3C,
  0x0F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF0, 0x1E, 0x1F, 0x9F, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x38, 0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xC7,
  0xDF, 0x3F, 0x1F, 0xFC, 0xFC, 0xFF, 0xE1, 0xE3, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00,
  0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0x7C, 0x0F, 0x9F, 0x80, 0xC3, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x78, 0x0F, 0xC0, 0xC0, 0x1F, 0x81, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xF9, 0xFE, 0x00, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x20, 0x03, 0xF8, 0x78,
  0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x20, 0x03, 0xF8, 0x1C, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE7,
  0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x07,
  0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF0,
  0xF8, 0x07, 0xE1, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x7C, 0x03,
  0xF1, 0xFC, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xCF, 0xE0, 0x1F, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFB, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x8F, 0xF8, 0xFF, 0x07, 0xF0, 0x7E, 0x00, 0x80, 0x00, 0x38, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x81, 0xFE, 0x07, 0xF8,
  0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0x3F, 0xC4, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80,
  0x77, 0xC7, 0x81, 0xFF, 0xC7, 0xC1, 0xFF, 0xE3, 0xC1, 0xFF, 0xF1, 0xE1,
  0xFF, 0xF9, 0xF1, 0xF8, 0x7C, 0xF0, 0xF8, 0x7C, 0x78, 0xF8, 0x3E, 0x3C,
  0x7C, 0x1F, 0x3E, 0x3E, 0x0F, 0x9F, 0x1E, 0x0F, 0x8F, 0x8F, 0x07, 0xC7,
  0x87, 0x83, 0xE3, 0xC3, 0xC1, 0xF1, 0xE1, 0xF0, 0xF0, 0xF0, 0xFC, 0xF8,
  0x7C, 0x7F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x07, 0xFE, 0x07, 0x81, 0xFE,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF1, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xBC, 0x00,
  0x0F, 0xBC, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7C, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE,
  0x01, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0x01, 0xFE,
  0x0E, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0xFE, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x01, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F,
  0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x40, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x0F, 0x07, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xF7,
  0x07, 0xF0, 0x1E, 0xE1, 0xFE, 0x03, 0xDC, 0x7B, 0xC0, 0xFB, 0x8F, 0x78,
  0x1E, 0x73, 0xDF, 0x03, 0xCE, 0x73, 0xC0, 0x79, 0xDE, 0x78, 0x1F, 0x3F,
  0x8F, 0x03, 0xC7, 0xF3, 0xE0, 0x78, 0xFC, 0x7C, 0x1F, 0x1F, 0x8F, 0x83,
  0xE3, 0xE1, 0xE0, 0x78, 0x7C, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x78, 0x0F, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80,
  0x7C, 0x07, 0xF8, 0x0F, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07,
  0xFC, 0x0F, 0x80, 0xF3, 0xC1, 0xF0, 0x3E, 0x78, 0x7C, 0x07, 0xCF, 0x0F,
  0x80, 0xF9, 0xE1, 0xF0, 0x1E, 0x1E, 0x3E, 0x07, 0xC3, 0xCF, 0x80, 0xF8,
  0x79, 0xF0, 0x1F, 0x0F, 0x3E, 0x03, 0xE1, 0xF7, 0xC0, 0xF8, 0x1E, 0xF0,
  0x1F, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x1F, 0x00,
  0xFE, 0x03, 0xE0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0x03,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0,
  0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC,
  0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0xFD,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F,
  0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8,
  0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x81,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0x80, 0x30, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x18, 0x00, 0xFC, 0x1F, 0x01,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F,
  0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F,
  0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x81, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x01, 0xF3, 0xF0,
  0xF0, 0x1E, 0x3F, 0x1F, 0x01, 0xE7, 0xF1, 0xF0, 0x3E, 0x7F, 0x9E, 0x03,
  0xEF, 0x79, 0xE0, 0x3C, 0xF7, 0xBE, 0x03, 0xDE, 0x7B, 0xC0, 0x3D, 0xC7,
  0xBC, 0x03, 0xFC, 0x7B, 0xC0, 0x7B, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBF,
  0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x3E, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xCF, 0x00,
  0x1E, 0x08, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x10, 0x0E, 0x07, 0xC3, 0xF8,
  0x7F, 0x87, 0xF0, 0xFC, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F,
  0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0x83, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0x7C, 0x07, 0xF8, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x84, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xC3, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xC0, 0xC1, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC1, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFB, 0xE0, 0x0F, 0xF1, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xF9,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBE, 0x3F, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x70, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00,
  0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x02, 0x00,
  0x7F, 0x00, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x30,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xF8, 0x7F, 0x07, 0xC0, 0xFC, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE3, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0x01, 0xF8, 0x01, 0xF7, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xEF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0x7F,
  0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x37, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0x30,
  0x00, 0x01, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x78, 0xF8, 0xF8, 0x3C, 0x3C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F,
  0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x87, 0xC7, 0xC7, 0xC3,
  0xE3, 0xE3, 0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3F, 0x03, 0xF1, 0xFC, 0x7F, 0x8F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x81, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x7F,
  0x03, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x83, 0xE1, 0xF8, 0x0F,
  0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01,
  0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x87, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x00,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0xC0, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x82, 0x00, 0x7E, 0x1E, 0x03, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x70, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x60, 0x00, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xE3, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFE, 0x3E, 0x00, 0x40, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x83,
  0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3F,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC1, 0xE1, 0xF1, 0xE1, 0xF0, 0xF1, 0xF0,
  0xF8, 0x78, 0xF8, 0xFC, 0x7C, 0x7C, 0x7E, 0x3C, 0x3C, 0x7F, 0x1E, 0x1E,
  0x3F, 0x9F, 0x0F, 0x3D, 0xCF, 0x07, 0x9E, 0xE7, 0x83, 0xDE, 0x77, 0xC1,
  0xEE, 0x3B, 0xC0, 0xFF, 0x1D, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0C, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x18, 0x3F, 0xE0, 0x7C, 0xFF, 0xF0, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x8F, 0x0F, 0xFF, 0x3E, 0x07, 0xFC, 0x18, 0x07, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 14, 31, 25, 6, -30 },
  { 56, 17, 13, 25, 8, -33 },
  { 84, 26, 30, 25, 0, -30 },
  { 182, 24, 39, 25, 1, -34 },
  { 299, 30, 32, 25, -2, -31 },
  { 419, 23, 31, 25, 1, -31 },
  { 509, 8, 14, 25, 12, -33 },
  { 523, 19, 43, 25, 5, -35 },
  { 626, 20, 43, 25, 0, -35 },
  { 734, 20, 18, 25, 4, -30 },
  { 779, 21, 22, 25, 2, -24 },
  { 837, 12, 15, 25, 3, -8 },
  { 860, 14, 5, 25, 6, -15 },
  { 869, 9, 9, 25, 6, -8 },
  { 880, 28, 42, 25, -2, -34 },
  { 1027, 22, 32, 25, 2, -31 },
  { 1115, 19, 30, 25, 2, -30 },
  { 1187, 23, 31, 25, 1, -31 },
  { 1277, 24, 32, 25, 0, -31 },
  { 1373, 24, 30, 25, 0, -30 },
  { 1463, 25, 31, 25, 0, -30 },
  { 1560, 23, 32, 25, 2, -31 },
  { 1652, 23, 30, 25, 4, -30 },
  { 1739, 24, 32, 25, 1, -31 },
  { 1835, 24, 31, 25, 1, -31 },
  { 1928, 12, 24, 25, 6, -23 },
  { 1964, 15, 30, 25, 3, -23 },
  { 2021, 22, 21, 25, 2, -23 },
  { 2079, 23, 14, 25, 1, -20 },
  { 2120, 22, 21, 25, 1, -23 },
  { 2178, 18, 32, 25, 6, -31 },
  { 2250, 25, 38, 25, 1, -31 },
  { 2369, 24, 30, 25, -2, -30 },
  { 2459, 24, 31, 25, 0, -31 },
  { 2552, 23, 32, 25, 3, -31 },
  { 2644, 24, 31, 25, 0, -31 },
  { 2737, 25, 30, 25, 1, -30 },
  { 2831, 26, 30, 25, 1, -30 },
  { 2929, 24, 32, 25, 2, -31 },
  { 3025, 27, 30, 25, 0, -30 },
  { 3127, 26, 30, 25, 0, -30 },
  { 3225, 26, 31, 25, 0, -30 },
  { 3326, 28, 30, 25, 0, -30 },
  { 3431, 20, 30, 25, 0, -30 },
  { 3506, 27, 30, 25, -1, -30 },
  { 3608, 27, 30, 25, 0, -30 },
  { 3710, 23, 32, 25, 2, -31 },
  { 3802, 25, 31, 25, 0, -31 },
  { 3899, 23, 39, 25, 2, -31 },
  { 4012, 24, 31, 25, 0, -31 },
  { 4105, 25, 32, 25, 0, -31 },
  { 4205, 23, 30, 25, 5, -30 },
  { 4292, 25, 31, 25, 2, -30 },
  { 4389, 23, 30, 25, 5, -30 },
  { 4476, 28, 30, 25, 0, -30 },
  { 4581, 30, 30, 25, -2, -30 },
  { 4694, 24, 30, 25, 5, -30 },
  { 4784, 26, 30, 25, 0, -30 },
  { 4882, 23, 42, 25, 3, -34 },
  { 5003, 10, 42, 25, 8, -34 },
  { 5056, 23, 42, 25, -1, -34 },
  { 5177, 22, 17, 25, 2, -30 },
  { 5224, 23, 5, 25, -3, 3 },
  { 5239, 10, 9, 25, 10, -34 },
  { 5251, 23, 25, 25, 1, -24 },
  { 5323, 23, 35, 25, 0, -34 },
  { 5424, 22, 25, 25, 2, -24 },
  { 5493, 25, 35, 25, 2, -34 },
  { 5603, 22, 25, 25, 2, -24 },
  { 5672, 30, 42, 25, -3, -34 },
  { 5830, 26, 32, 25, -2, -24 },
  { 5934, 22, 34, 25, 0, -34 },
  { 6028, 16, 34, 25, 4, -34 },
  { 6096, 25, 42, 25, -2, -34 },
  { 6228, 25, 34, 25, 1, -34 },
  { 6335, 14, 35, 25, 6, -34 },
  { 6397, 25, 23, 25, -1, -23 },
  { 6469, 22, 24, 25, 1, -24 },
  { 6535, 21, 25, 25, 2, -24 },
  { 6601, 25, 32, 25, -2, -24 },
  { 6701, 22, 32, 25, 2, -24 },
  { 6789, 22, 24, 25, 2, -24 },
  { 6855, 22, 25, 25, 1, -24 },
  { 6924, 20, 31, 25, 4, -30 },
  { 7002, 22, 24, 25, 2, -23 },
  { 7068, 21, 23, 25, 4, -23 },
  { 7129, 25, 23, 25, 2, -23 },
  { 7201, 26, 23, 25, -1, -23 },
  { 7276, 29, 31, 25, -4, -23 },
  { 7389, 23, 23, 25, 1, -23 },
  { 7456, 24, 42, 25, 3, -34 },
  { 7582, 15, 42, 25, 5, -34 },
  { 7661, 24, 42, 25, -2, -34 },
  { 7787, 23, 8, 25, 1, -17 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC44PT7B_H_
