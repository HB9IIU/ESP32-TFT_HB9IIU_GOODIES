#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC35PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x3C, 0x7C,
  0xF1, 0xE7, 0xC7, 0x9F, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C,
  0x70, 0xE1, 0xC3, 0x8E, 0x0C, 0x00, 0x00, 0x38, 0x78, 0x03, 0xC7, 0x80,
  0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xE0, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1E, 0x3C, 0x01, 0xE1, 0xC0, 0x0F,
  0x1E, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7C, 0x0C, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x80,
  0x3E, 0x1C, 0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xE0, 0x3C, 0x1F, 0xC0, 0x70, 0x73, 0x81, 0xC0, 0xE3,
  0x07, 0x01, 0x8E, 0x1C, 0x07, 0x1C, 0x78, 0x0E, 0x39, 0xE0, 0x1C, 0x73,
  0x80, 0x3D, 0xCE, 0x00, 0x3F, 0x38, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x10, 0x00, 0x1D, 0xF8, 0x00, 0x77, 0xF8, 0x01, 0xCE, 0x70,
  0x07, 0x38, 0xE0, 0x1C, 0x71, 0xC0, 0x78, 0xE3, 0x81, 0xE1, 0xC6, 0x03,
  0x83, 0x9C, 0x0E, 0x07, 0x78, 0x38, 0x0F, 0xE0, 0xE0, 0x0F, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3C, 0x78, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00,
  0xF3, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x1E, 0x1F, 0xC3, 0x87,
  0xBC, 0xF1, 0xE7, 0xDE, 0x78, 0x7B, 0x8F, 0x07, 0xF1, 0xC0, 0xFC, 0x78,
  0x0F, 0x0F, 0x83, 0xF0, 0xF0, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x3C, 0x1F,
  0xC7, 0x80, 0x7D, 0xF7, 0xDE, 0xFB, 0xEF, 0x3C, 0xF3, 0x8E, 0x30, 0x00,
  0x04, 0x00, 0x18, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x60, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x02, 0x1C, 0x2F, 0x39,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0xC1,
  0xF7, 0xC7, 0xC7, 0xC3, 0x8E, 0x02, 0x08, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x83, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x78, 0x1C, 0x1F, 0x3F, 0x87, 0x81, 0x80,
  0x7F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x7C, 0xFB, 0xFF, 0xFF, 0xCF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xC7, 0xC3, 0xC0,
  0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xCE, 0x3D,
  0xE3, 0xCF, 0x79, 0xF3, 0xDE, 0x78, 0xF7, 0x8E, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0xBE, 0x03, 0xCF, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0x1F,
  0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0x3C,
  0x0C, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x04, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC4, 0x00, 0xF8,
  0xE0, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xCB,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x84, 0x01, 0xF0, 0x70,
  0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x07, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFC, 0x3F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x78, 0xFC, 0x7E, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3F, 0x3E, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0x8F, 0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01,
  0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x81, 0xF1, 0xF8, 0x7E, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1F, 0x01,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1E, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x87, 0xE1, 0xFC,
  0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x0F, 0xE3, 0xF8, 0xFC, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7C,
  0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x7F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFE,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x18, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0xFF, 0xC1, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xE0, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFF, 0x30, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF,
  0x03, 0xF1, 0xF0, 0xF8, 0x1E, 0x1E, 0x01, 0xC7, 0x80, 0x39, 0xE0, 0x07,
  0x3C, 0x1F, 0xE7, 0x0F, 0xFD, 0xE3, 0xFF, 0xB8, 0xF8, 0xF7, 0x1E, 0x1D,
  0xE7, 0x87, 0xBC, 0xF0, 0xF7, 0x9E, 0x1E, 0xE3, 0xC3, 0x9C, 0x78, 0xF3,
  0x8F, 0x1E, 0x71, 0xE3, 0xCE, 0x3F, 0xF1, 0xE3, 0xFE, 0x3C, 0x3F, 0xC7,
  0x80, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0x70, 0x07, 0x8E,
  0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F,
  0xC0, 0x0F, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x78, 0x3E, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x78, 0x7C, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0x83, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E,
  0x03, 0xE7, 0x80, 0xF8, 0xF8, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFC, 0x1C, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x40, 0xFE, 0x78, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x78, 0xFC, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x0F,
  0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C,
  0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0,
  0x3E, 0x3C, 0x0F, 0x87, 0x83, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFC, 0x18, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x09, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xFC, 0x78, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1,
  0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8,
  0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x80,
  0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x02,
  0x03, 0xE0, 0x7C, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x01,
  0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF,
  0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x1F, 0x00, 0x3C,
  0x3C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x1F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x1D,
  0x87, 0xE0, 0x76, 0x3B, 0x81, 0xDC, 0xFE, 0x0F, 0x77, 0x78, 0x39, 0xDD,
  0xC0, 0xE7, 0xE7, 0x07, 0x9F, 0xBC, 0x1E, 0x7C, 0xF0, 0x71, 0xE3, 0xC1,
  0xC7, 0x8E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F,
  0xC0, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xFE, 0x1E,
  0x1E, 0x71, 0xE0, 0xF3, 0x8F, 0x07, 0x9C, 0x78, 0x3C, 0xF3, 0xC3, 0xC3,
  0xBC, 0x1E, 0x1D, 0xE0, 0xF0, 0xEF, 0x07, 0x87, 0x78, 0x38, 0x3F, 0x83,
  0xC0, 0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x07, 0x01, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x01,
  0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x87, 0x83, 0xE0, 0xF8, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x87, 0xF0, 0x78, 0x1F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1,
  0xF0, 0x3E, 0x1F, 0x1F, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1E,
  0x07, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x87, 0x83,
  0xE0, 0xF8, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x78, 0x7E, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78,
  0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xC0, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x20, 0x0F, 0x87, 0x83, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1E,
  0x1F, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x3E, 0x03,
  0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1E, 0x0F, 0x83, 0xE0, 0x7C, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1E,
  0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0,
  0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x81,
  0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C,
  0x1E, 0x38, 0xF0, 0x71, 0xE3, 0xC3, 0xC7, 0x8E, 0x0F, 0x3E, 0x78, 0x3D,
  0xF9, 0xE0, 0xE7, 0xE7, 0x03, 0xB9, 0x9C, 0x0E, 0xE6, 0xF0, 0x7F, 0x1B,
  0xC1, 0xDC, 0x6E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x01,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9F, 0x00,
  0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x1F,
  0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3E,
  0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x01, 0xE3, 0xE0,
  0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0x7C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xE7, 0xCF, 0x8F, 0x1E, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3E,
  0xF0, 0x3E, 0x7C, 0x3E, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0xDF, 0x03, 0xFF,
  0x00, 0xF3, 0x00, 0x70, 0x80, 0x20, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x00, 0x20, 0x70, 0xFC, 0x7E, 0x3F, 0x0F, 0x06, 0x00, 0x7E, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x87, 0x8F, 0x81, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x9C,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF1,
  0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE7, 0xC1, 0xF1, 0xE1, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xC0, 0x8F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x78, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87, 0x83, 0xE0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x07, 0xC7, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x7D,
  0xE0, 0x1E, 0x78, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x38, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x4F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xE1, 0xF0, 0xF8, 0x1E,
  0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3E, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x07, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x60, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xBC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07,
  0x8F, 0x81, 0xE0, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFE, 0x1F, 0xF1, 0xFF, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF3, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x40, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x04, 0x07, 0x80, 0xE3, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x10, 0xF0, 0x3E, 0x0F, 0x07, 0xC1,
  0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3D, 0xF0, 0x03, 0xDF, 0x00, 0x7C, 0xF8,
  0x07, 0x87, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xC0, 0xF8, 0x3E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1F, 0x00, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE7, 0x7F, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0xC0, 0x80, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x3C, 0xF0, 0xE3, 0xCF, 0x1E, 0x38, 0xF1,
  0xE3, 0x8F, 0x1E, 0x78, 0xE1, 0xC7, 0x8E, 0x3C, 0x79, 0xE3, 0xC7, 0x1E,
  0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x00, 0x38, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F,
  0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x0F, 0x8F,
  0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x81,
  0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0xF9,
  0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0xF8, 0xFC, 0xFC, 0x7F,
  0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0,
  0x7C, 0x3C, 0x0F, 0x8F, 0x87, 0xE1, 0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xCF, 0xC1, 0xE3, 0xE0, 0x79, 0xF0, 0x3E,
  0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E,
  0x07, 0x87, 0x81, 0xE1, 0xF9, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xC1, 0x83, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0, 0x10, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0xF1, 0x00, 0x78, 0xE0, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x38, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xCF, 0x81, 0xE7,
  0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xF7, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0xCF, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07,
  0xDF, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78,
  0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1C,
  0x71, 0xF3, 0xC7, 0x1F, 0x3C, 0x73, 0xF3, 0x87, 0x3F, 0x78, 0x77, 0x77,
  0x0F, 0x77, 0x70, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x83,
  0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x80,
  0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x3C, 0x07, 0xC1, 0xF0,
  0x7C, 0x07, 0x87, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x04, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x40, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x06,
  0x01, 0x07, 0xE0, 0x73, 0xFE, 0x3D, 0xFF, 0xFE, 0xFB, 0xFF, 0x3C, 0x3F,
  0xC6, 0x03, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 24, 20, 5, -24 },
  { 34, 14, 11, 20, 6, -27 },
  { 54, 21, 24, 20, 0, -24 },
  { 117, 19, 31, 20, 1, -27 },
  { 191, 23, 26, 20, -1, -25 },
  { 266, 19, 25, 20, 0, -25 },
  { 326, 6, 12, 20, 10, -27 },
  { 335, 15, 35, 20, 4, -28 },
  { 401, 16, 35, 20, 0, -28 },
  { 471, 15, 15, 20, 4, -24 },
  { 500, 17, 17, 20, 1, -19 },
  { 537, 10, 12, 20, 2, -6 },
  { 552, 12, 4, 20, 4, -12 },
  { 558, 7, 6, 20, 5, -6 },
  { 564, 23, 33, 20, -2, -27 },
  { 659, 18, 26, 20, 1, -25 },
  { 718, 16, 24, 20, 1, -24 },
  { 766, 19, 25, 20, 0, -25 },
  { 826, 19, 26, 20, 0, -25 },
  { 888, 19, 24, 20, 0, -24 },
  { 945, 20, 25, 20, 0, -24 },
  { 1008, 18, 25, 20, 2, -24 },
  { 1065, 19, 24, 20, 3, -24 },
  { 1122, 19, 26, 20, 1, -25 },
  { 1184, 19, 25, 20, 1, -25 },
  { 1244, 10, 18, 20, 5, -18 },
  { 1267, 13, 24, 20, 2, -18 },
  { 1306, 17, 16, 20, 2, -18 },
  { 1340, 19, 11, 20, 0, -16 },
  { 1367, 17, 16, 20, 1, -18 },
  { 1401, 14, 25, 20, 5, -25 },
  { 1445, 19, 30, 20, 1, -25 },
  { 1517, 19, 24, 20, -2, -24 },
  { 1574, 19, 25, 20, 0, -25 },
  { 1634, 19, 26, 20, 2, -25 },
  { 1696, 19, 25, 20, 0, -25 },
  { 1756, 20, 24, 20, 1, -24 },
  { 1816, 20, 24, 20, 1, -24 },
  { 1876, 19, 26, 20, 2, -25 },
  { 1938, 21, 24, 20, 0, -24 },
  { 2001, 21, 24, 20, 0, -24 },
  { 2064, 20, 25, 20, 0, -24 },
  { 2127, 22, 24, 20, 0, -24 },
  { 2193, 16, 24, 20, 0, -24 },
  { 2241, 22, 24, 20, -1, -24 },
  { 2307, 21, 24, 20, 0, -24 },
  { 2370, 19, 26, 20, 1, -25 },
  { 2432, 20, 25, 20, 0, -25 },
  { 2495, 19, 32, 20, 1, -25 },
  { 2571, 19, 25, 20, 0, -25 },
  { 2631, 20, 26, 20, 0, -25 },
  { 2696, 18, 24, 20, 4, -24 },
  { 2750, 20, 25, 20, 1, -24 },
  { 2813, 19, 24, 20, 4, -24 },
  { 2870, 22, 24, 20, 0, -24 },
  { 2936, 23, 24, 20, -1, -24 },
  { 3005, 19, 24, 20, 4, -24 },
  { 3062, 21, 24, 20, 0, -24 },
  { 3125, 19, 33, 20, 2, -27 },
  { 3204, 7, 33, 20, 7, -27 },
  { 3233, 19, 33, 20, -1, -27 },
  { 3312, 17, 14, 20, 2, -24 },
  { 3342, 19, 3, 20, -3, 3 },
  { 3350, 8, 7, 20, 8, -27 },
  { 3357, 18, 19, 20, 1, -19 },
  { 3400, 18, 27, 20, 0, -27 },
  { 3461, 18, 19, 20, 1, -19 },
  { 3504, 20, 27, 20, 1, -27 },
  { 3572, 18, 19, 20, 1, -19 },
  { 3615, 24, 34, 20, -2, -27 },
  { 3717, 20, 26, 20, -1, -19 },
  { 3782, 18, 27, 20, 0, -27 },
  { 3843, 13, 27, 20, 3, -27 },
  { 3887, 19, 34, 20, -1, -27 },
  { 3968, 20, 27, 20, 1, -27 },
  { 4036, 11, 27, 20, 5, -27 },
  { 4074, 20, 19, 20, -1, -19 },
  { 4122, 18, 19, 20, 0, -19 },
  { 4165, 17, 19, 20, 1, -19 },
  { 4206, 19, 25, 20, -1, -19 },
  { 4266, 18, 25, 20, 1, -19 },
  { 4323, 18, 19, 20, 1, -19 },
  { 4366, 17, 19, 20, 1, -19 },
  { 4407, 16, 24, 20, 3, -24 },
  { 4455, 17, 18, 20, 2, -18 },
  { 4494, 17, 18, 20, 3, -18 },
  { 4533, 20, 18, 20, 1, -18 },
  { 4578, 21, 18, 20, -1, -18 },
  { 4626, 23, 25, 20, -3, -18 },
  { 4698, 18, 18, 20, 1, -18 },
  { 4739, 19, 33, 20, 2, -27 },
  { 4818, 12, 33, 20, 4, -27 },
  { 4868, 18, 33, 20, -1, -27 },
  { 4943, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC35PT7B_H_
