#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x80, 0x01, 0x18, 0x4A,
  0x52, 0x99, 0x48, 0x06, 0x40, 0x88, 0x12, 0x04, 0x43, 0xFE, 0x12, 0x02,
  0x40, 0x88, 0x11, 0x02, 0x43, 0xFE, 0x11, 0x02, 0x40, 0x88, 0x11, 0x02,
  0x40, 0x02, 0x01, 0xC1, 0xAC, 0x48, 0x24, 0x09, 0x02, 0x40, 0x50, 0x08,
  0x01, 0x80, 0xA0, 0x24, 0x09, 0x02, 0x41, 0x23, 0xF0, 0x10, 0x04, 0x00,
  0x18, 0x02, 0x42, 0x44, 0x44, 0x44, 0x44, 0x88, 0x48, 0x89, 0x08, 0xA6,
  0x8A, 0x99, 0x51, 0x65, 0x10, 0x91, 0x09, 0x11, 0x22, 0x22, 0x22, 0x22,
  0x41, 0xC0, 0x06, 0x02, 0x40, 0x88, 0x44, 0x11, 0x04, 0x41, 0x20, 0x30,
  0x18, 0x09, 0x04, 0x45, 0x12, 0x82, 0xA0, 0xC8, 0x32, 0x14, 0x79, 0x80,
  0x55, 0xA0, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x04, 0x00, 0x11,
  0x21, 0x49, 0xE7, 0x11, 0x02, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x25, 0x28, 0xF8, 0x70, 0x00, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x06, 0x19, 0x21, 0x21, 0x41, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x1B,
  0xA4, 0x21, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x03, 0x03, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x00, 0x06, 0x0C, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x06, 0x1C, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0xFC, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x50, 0x48, 0x28, 0x24, 0x22,
  0x11, 0x11, 0x10, 0x90, 0x4F, 0xF8, 0x10, 0x10, 0x08, 0x04, 0x00, 0x1F,
  0xC4, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xC0, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x63, 0xE0, 0x03, 0x86, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x00, 0xF8, 0xC2, 0x41, 0x20, 0x50, 0x48, 0x24, 0x12, 0x09,
  0x08, 0x78, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x80, 0x07, 0x02, 0x21,
  0x08, 0x41, 0x20, 0x84, 0x21, 0x10, 0x28, 0x0C, 0x0C, 0x84, 0x11, 0x04,
  0x81, 0x20, 0x48, 0x11, 0x08, 0x7C, 0x00, 0x06, 0x04, 0x84, 0x24, 0x12,
  0x09, 0x04, 0x82, 0x81, 0x21, 0x91, 0x47, 0x40, 0x20, 0x10, 0x10, 0x10,
  0x08, 0xF8, 0x00, 0x31, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x08, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x84, 0x22, 0x00, 0x01, 0x83, 0x06, 0x04, 0x0C,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x30, 0x60, 0x40,
  0x40, 0x00, 0x38, 0x88, 0x08, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x02,
  0x04, 0x00, 0x00, 0x40, 0x80, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x14,
  0x3C, 0xA2, 0x45, 0x22, 0x31, 0x11, 0x90, 0x94, 0x88, 0xA4, 0x45, 0x22,
  0x49, 0xB6, 0x42, 0x42, 0x00, 0x10, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x01,
  0x01, 0x80, 0xC0, 0xA0, 0x50, 0x44, 0x22, 0x21, 0x10, 0x8F, 0xC8, 0x24,
  0x14, 0x0A, 0x06, 0x03, 0x01, 0x0F, 0x84, 0x11, 0x04, 0x41, 0x10, 0x44,
  0x12, 0x18, 0xF8, 0x21, 0x08, 0x24, 0x09, 0x02, 0x40, 0x90, 0x44, 0x33,
  0xF0, 0x03, 0x83, 0x11, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x3E, 0x00, 0x0F,
  0x82, 0x08, 0x40, 0x88, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x44,
  0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x87, 0xE0, 0x0F, 0xC4, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0xFC, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0xF8, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x3F, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x03, 0xC1, 0x84, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x7A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x10, 0x22, 0x04, 0x3F,
  0x00, 0x08, 0x11, 0x01, 0x10, 0x11, 0x02, 0x10, 0x21, 0x02, 0x20, 0x23,
  0xFC, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x40, 0x88,
  0x08, 0x1E, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x78, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08,
  0x62, 0x08, 0x42, 0x08, 0x81, 0x20, 0x28, 0x0B, 0x01, 0x40, 0x34, 0x04,
  0x81, 0x10, 0x21, 0x04, 0x20, 0x84, 0x10, 0x44, 0x08, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x7F, 0x08,
  0x02, 0x30, 0x0C, 0x60, 0x18, 0xA0, 0x51, 0x40, 0xA2, 0x82, 0x89, 0x05,
  0x12, 0x12, 0x24, 0x24, 0x48, 0x91, 0x11, 0x22, 0x24, 0x44, 0x50, 0x88,
  0xA1, 0x11, 0x84, 0x41, 0x08, 0x08, 0x18, 0xC0, 0x85, 0x04, 0x28, 0x21,
  0x41, 0x0A, 0x10, 0x88, 0x84, 0x44, 0x22, 0x21, 0x12, 0x10, 0x50, 0x82,
  0x84, 0x14, 0x20, 0xA1, 0x02, 0x10, 0x10, 0x07, 0x01, 0x18, 0x41, 0x10,
  0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x20, 0x42, 0x18, 0x3C, 0x00, 0x0F, 0x84, 0x11, 0x04, 0x41,
  0x10, 0x44, 0x12, 0x08, 0x84, 0x3E, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x07, 0x01, 0x18, 0x41, 0x10, 0x12, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x42,
  0x18, 0x3C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0F, 0x84, 0x11, 0x04,
  0x41, 0x10, 0x44, 0x12, 0x08, 0x84, 0x3E, 0x09, 0x04, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x12, 0x04, 0x07, 0x06, 0x31, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x20, 0x08,
  0xFC, 0x00, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x30, 0x24, 0x04, 0x80, 0x90, 0x22,
  0x04, 0x80, 0x90, 0x12, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x11,
  0x02, 0x30, 0x83, 0xE0, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x12, 0x11,
  0x08, 0x88, 0x44, 0x24, 0x12, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x81, 0x03,
  0x02, 0x0A, 0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44,
  0x88, 0x91, 0x11, 0x22, 0x42, 0x44, 0x85, 0x0A, 0x0A, 0x14, 0x18, 0x30,
  0x30, 0x60, 0x40, 0xC0, 0x08, 0x21, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0A,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x84, 0x10,
  0x44, 0x08, 0x81, 0x82, 0x82, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0F, 0xE0, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x07, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0,
  0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x07, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x0C, 0x06, 0x04, 0x84, 0x42,
  0x22, 0x09, 0x05, 0x01, 0xFE, 0x89, 0x10, 0x1E, 0x90, 0x90, 0x48, 0x28,
  0x14, 0x0A, 0x09, 0x04, 0x82, 0x43, 0x22, 0x8E, 0x80, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFC, 0xC2, 0x61, 0x20, 0x90, 0x48, 0x28, 0x14, 0x0A,
  0x09, 0x05, 0x44, 0xBC, 0x00, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x03, 0xC0, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x87, 0xA2,
  0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x88, 0x62, 0x28,
  0x74, 0x00, 0x1E, 0x45, 0x0A, 0x18, 0x5F, 0x20, 0x40, 0x81, 0x02, 0x03,
  0xE0, 0x00, 0x60, 0x30, 0x04, 0x01, 0x00, 0x20, 0x04, 0x03, 0xE0, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x06, 0x00, 0x0F, 0x44,
  0x22, 0x08, 0x82, 0x40, 0x90, 0x24, 0x11, 0x04, 0x41, 0x10, 0xC4, 0x50,
  0xE8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x88, 0x1C, 0x00, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFC, 0xC2, 0x61, 0x20, 0x90, 0x48, 0x48, 0x24, 0x12,
  0x09, 0x04, 0x84, 0x82, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x84, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x80, 0x01, 0x03, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0xC0, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x8C, 0x84, 0x44,
  0x24, 0x14, 0x0E, 0x0D, 0x04, 0x42, 0x21, 0x10, 0x88, 0x82, 0x00, 0x08,
  0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x1F, 0x7C,
  0x42, 0x13, 0x08, 0x48, 0x41, 0x21, 0x04, 0x84, 0x24, 0x10, 0x90, 0x42,
  0x42, 0x09, 0x08, 0x24, 0x21, 0x20, 0x84, 0x1F, 0x88, 0x4C, 0x24, 0x12,
  0x09, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x90, 0x40, 0x1E, 0x21, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x0F, 0xC5, 0x11,
  0x84, 0x41, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x11, 0x78,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x90, 0x90, 0x48, 0x28,
  0x14, 0x0A, 0x09, 0x04, 0x82, 0x43, 0x22, 0x8E, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x00, 0x1E, 0x60, 0xC1, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x00, 0x3E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x17,
  0xC0, 0x21, 0x09, 0xF4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x43, 0x80, 0x21,
  0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x84, 0x8C, 0xF4, 0x83,
  0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x50, 0x50, 0x60, 0x60, 0x40, 0x82,
  0x18, 0x61, 0x86, 0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0x4A, 0x28, 0xA2,
  0x8A, 0x30, 0xC3, 0x04, 0x20, 0x10, 0xC4, 0x40, 0x90, 0x28, 0x0C, 0x03,
  0x00, 0xC0, 0x50, 0x24, 0x08, 0x84, 0x22, 0x08, 0x04, 0x10, 0x42, 0x04,
  0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x0E, 0x00, 0x1F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x07,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x40, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x0C, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x60, 0x80, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 7, 2, -16 },
  { 15, 11, 16, 10, 0, -16 },
  { 37, 10, 18, 9, 0, -17 },
  { 60, 12, 17, 14, 1, -17 },
  { 86, 10, 17, 10, 0, -17 },
  { 108, 2, 6, 4, 2, -16 },
  { 110, 6, 20, 6, 1, -16 },
  { 125, 7, 20, 6, -2, -16 },
  { 143, 7, 7, 9, 3, -17 },
  { 150, 9, 10, 10, 1, -13 },
  { 162, 3, 5, 4, -1, -2 },
  { 164, 5, 1, 6, 1, -7 },
  { 165, 2, 2, 4, 0, -2 },
  { 166, 10, 16, 7, -1, -16 },
  { 186, 8, 17, 9, 1, -17 },
  { 203, 5, 16, 9, 3, -16 },
  { 213, 10, 17, 9, -1, -17 },
  { 235, 9, 17, 9, 0, -17 },
  { 255, 9, 17, 9, 0, -17 },
  { 275, 10, 16, 9, 0, -16 },
  { 295, 9, 17, 9, 1, -17 },
  { 315, 9, 16, 9, 1, -16 },
  { 333, 10, 17, 9, 0, -17 },
  { 355, 9, 17, 9, 0, -17 },
  { 375, 4, 12, 4, 0, -12 },
  { 381, 5, 15, 4, -1, -12 },
  { 391, 9, 10, 10, 1, -13 },
  { 403, 9, 6, 10, 1, -11 },
  { 410, 9, 10, 10, 1, -13 },
  { 422, 7, 17, 7, 1, -17 },
  { 437, 13, 18, 14, 1, -16 },
  { 467, 9, 16, 9, -1, -16 },
  { 485, 10, 16, 10, 0, -16 },
  { 505, 10, 17, 10, 1, -17 },
  { 527, 11, 16, 11, 0, -16 },
  { 549, 10, 16, 9, 0, -16 },
  { 569, 10, 16, 8, 0, -16 },
  { 589, 11, 17, 12, 1, -17 },
  { 613, 12, 16, 12, 0, -16 },
  { 637, 7, 16, 5, -1, -16 },
  { 651, 8, 20, 4, -3, -16 },
  { 671, 11, 16, 10, 0, -16 },
  { 693, 7, 16, 8, 0, -16 },
  { 707, 15, 16, 15, 0, -16 },
  { 737, 13, 16, 12, 0, -16 },
  { 763, 11, 17, 12, 1, -17 },
  { 787, 10, 16, 10, 0, -16 },
  { 807, 11, 21, 12, 1, -17 },
  { 836, 10, 16, 10, 0, -16 },
  { 856, 10, 17, 9, 0, -17 },
  { 878, 8, 16, 8, 2, -16 },
  { 894, 11, 16, 12, 1, -16 },
  { 916, 9, 16, 9, 2, -16 },
  { 934, 15, 16, 16, 2, -16 },
  { 964, 11, 16, 9, -1, -16 },
  { 986, 8, 16, 8, 2, -16 },
  { 1002, 11, 16, 9, -1, -16 },
  { 1024, 8, 20, 7, 0, -16 },
  { 1044, 4, 16, 7, 2, -16 },
  { 1052, 9, 20, 7, -2, -16 },
  { 1075, 9, 8, 10, 1, -16 },
  { 1084, 7, 1, 7, -2, 2 },
  { 1085, 3, 4, 5, 3, -18 },
  { 1087, 9, 12, 10, 1, -12 },
  { 1101, 9, 17, 10, 0, -17 },
  { 1121, 7, 12, 8, 1, -12 },
  { 1132, 10, 17, 10, 1, -17 },
  { 1154, 7, 12, 9, 1, -12 },
  { 1165, 11, 24, 5, -3, -18 },
  { 1198, 10, 18, 10, 0, -12 },
  { 1221, 9, 17, 10, 0, -17 },
  { 1241, 5, 17, 4, 0, -17 },
  { 1252, 8, 23, 4, -3, -17 },
  { 1275, 9, 17, 8, 0, -17 },
  { 1295, 5, 17, 4, 0, -17 },
  { 1306, 14, 12, 15, 0, -12 },
  { 1327, 9, 12, 10, 0, -12 },
  { 1341, 8, 12, 10, 1, -12 },
  { 1353, 10, 17, 10, -1, -12 },
  { 1375, 9, 17, 10, 1, -12 },
  { 1395, 7, 12, 6, 0, -12 },
  { 1406, 7, 12, 7, 0, -12 },
  { 1417, 5, 15, 5, 1, -15 },
  { 1427, 8, 12, 10, 1, -12 },
  { 1439, 8, 12, 7, 1, -12 },
  { 1451, 12, 12, 12, 1, -12 },
  { 1469, 10, 12, 8, -1, -12 },
  { 1484, 12, 18, 8, -3, -12 },
  { 1511, 8, 12, 7, -1, -12 },
  { 1523, 8, 20, 7, 1, -16 },
  { 1543, 1, 24, 9, 4, -18 },
  { 1546, 8, 20, 7, -1, -16 },
  { 1566, 9, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC23PT7B_H_
