#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x18, 0xC0, 0xC6, 0x0E,
  0x70, 0x73, 0x83, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xC6, 0x06, 0x20, 0x63, 0x03, 0x18, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xF1, 0x87, 0x01, 0xC1, 0x01, 0x03, 0x81, 0x00, 0x03, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x11, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x70, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00,
  0x60, 0x70, 0x00, 0x60, 0x60, 0x00, 0x40, 0xE0, 0x00, 0xC0, 0xC0, 0x80,
  0xC1, 0xC0, 0xC0, 0xC7, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x38,
  0x1F, 0xE0, 0x00, 0xC0, 0x61, 0xC0, 0x06, 0x03, 0x03, 0x00, 0x18, 0x1C,
  0x0C, 0x00, 0xC0, 0x60, 0x30, 0x07, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x03,
  0x00, 0xE0, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x06, 0x00, 0xC0,
  0x60, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x0C, 0x1C, 0x03, 0x00, 0x70, 0x60,
  0x0C, 0x01, 0x83, 0x80, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x18, 0x60, 0x03,
  0x00, 0xE1, 0x81, 0x0C, 0x03, 0x0C, 0x3F, 0xB0, 0x0C, 0x71, 0xEF, 0xC0,
  0x61, 0x8E, 0x0F, 0x01, 0x8E, 0x30, 0x3C, 0x0C, 0x31, 0x80, 0xF0, 0x71,
  0x86, 0x03, 0xE1, 0x86, 0x30, 0x0D, 0xFC, 0x30, 0xC0, 0x33, 0xE1, 0xC3,
  0x00, 0xC0, 0x06, 0x18, 0x03, 0x00, 0x38, 0x60, 0x0C, 0x00, 0xC1, 0x80,
  0x30, 0x06, 0x0E, 0x00, 0xC0, 0x18, 0x30, 0x07, 0x00, 0xC0, 0xC0, 0x18,
  0x07, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xE0, 0x30, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x60, 0x03, 0x87, 0x03, 0x80, 0x07,
  0x38, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0x81, 0x80, 0x70, 0xC0, 0x70,
  0x18, 0x70, 0x0C, 0x0E, 0x38, 0x03, 0x83, 0x0C, 0x00, 0xE0, 0xC7, 0x00,
  0x18, 0x61, 0x80, 0x07, 0x18, 0x60, 0x00, 0xCC, 0x18, 0x00, 0x33, 0x0E,
  0x00, 0x0F, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x06, 0x00, 0x0F, 0x81, 0x80, 0x07, 0x60, 0x70, 0x03, 0x98, 0x0E, 0x03,
  0x87, 0x03, 0xF7, 0xC0, 0xC0, 0x3F, 0xE0, 0x38, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x06, 0x01, 0xC0, 0xC0,
  0x1E, 0x18, 0x00, 0xE2, 0x00, 0x07, 0x47, 0xE0, 0x3F, 0xFC, 0x03, 0x00,
  0x01, 0xF0, 0x00, 0x72, 0x00, 0x1C, 0x60, 0x07, 0x0C, 0x01, 0xC0, 0xC0,
  0x70, 0x18, 0x04, 0x01, 0x80, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x27, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xC0, 0x0E, 0x01, 0xC0,
  0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0E, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x9C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71,
  0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x78, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x07, 0x01, 0xF0,
  0x3F, 0x07, 0x61, 0xE6, 0x38, 0x67, 0x0E, 0xE0, 0xE4, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x03, 0xC0, 0x0E,
  0x00, 0xE0, 0x04, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xC0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x40, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x80, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x0F,
  0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x70, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x80, 0x03, 0x80, 0x60, 0x07, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x1E, 0x00,
  0x38, 0xFF, 0x80, 0x31, 0xE7, 0xC0, 0x37, 0x00, 0xE0, 0x36, 0x00, 0x70,
  0x7C, 0x00, 0x70, 0x78, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x60, 0x01, 0x80, 0x70, 0x03, 0x80, 0x30, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x70, 0x18,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x38, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC7, 0x80,
  0x03, 0x81, 0xC0, 0x07, 0x80, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x06,
  0x03, 0x80, 0x03, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xE0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0xC0,
  0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC7, 0x00,
  0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x83, 0x00, 0x1B,
  0x07, 0x00, 0x76, 0x07, 0x03, 0xDC, 0x07, 0xFE, 0x30, 0x07, 0xF8, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x78, 0x20, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x7F, 0x81, 0x83, 0x00, 0x3F, 0xF0, 0x38,
  0x60, 0x0E, 0x0E, 0x07, 0x1C, 0x03, 0x01, 0x80, 0xE3, 0x00, 0xE0, 0x30,
  0x18, 0x60, 0x38, 0x06, 0x03, 0x18, 0x06, 0x01, 0xC0, 0x63, 0x01, 0xC0,
  0x30, 0x0C, 0x60, 0x30, 0x06, 0x01, 0x9C, 0x06, 0x00, 0xC0, 0x33, 0x01,
  0x80, 0x30, 0x0E, 0x60, 0x30, 0x06, 0x01, 0x8C, 0x06, 0x00, 0xC0, 0x31,
  0x81, 0x80, 0x38, 0x06, 0x70, 0x30, 0x06, 0x01, 0x8C, 0x06, 0x00, 0xC0,
  0x31, 0x80, 0xC0, 0x38, 0x0E, 0x30, 0x18, 0x07, 0x01, 0x86, 0x03, 0x01,
  0xE0, 0x70, 0xC0, 0x60, 0x3C, 0x0C, 0x18, 0x0C, 0x0D, 0x83, 0x03, 0x00,
  0xC3, 0x30, 0xE0, 0x60, 0x1F, 0xE3, 0xF8, 0x0C, 0x01, 0xF0, 0x3C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01,
  0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0x80, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x18,
  0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x01,
  0xE0, 0x18, 0x01, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x60,
  0x1F, 0x00, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x03, 0xC0, 0x60, 0x01, 0xE0,
  0x18, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00, 0x20,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0x60, 0x00, 0xF0, 0x06, 0x00,
  0x1E, 0x00, 0x60, 0x07, 0x80, 0x0E, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xF8,
  0x0F, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFC, 0x38, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x67, 0x80, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x1B, 0x70, 0x00, 0x01, 0xF1,
  0x80, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0xD8, 0x00, 0x00, 0x6E, 0x01,
  0xD8, 0x00, 0x00, 0xEC, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x01, 0x98, 0x00,
  0x01, 0xCC, 0x01, 0x98, 0x00, 0x01, 0x9C, 0x01, 0x9C, 0x00, 0x03, 0x9C,
  0x03, 0x9C, 0x00, 0x03, 0x18, 0x03, 0x0C, 0x00, 0x07, 0x18, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x0E, 0x38, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x06,
  0x0C, 0x00, 0x38, 0x30, 0x06, 0x0C, 0x00, 0x30, 0x70, 0x06, 0x0C, 0x00,
  0x70, 0x60, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x0E, 0x00, 0xE0, 0x60,
  0x0C, 0x0E, 0x00, 0xC0, 0xE0, 0x0C, 0x06, 0x01, 0xC0, 0xE0, 0x1C, 0x06,
  0x01, 0x80, 0xC0, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x07, 0x01, 0xC0, 0x18, 0x06, 0x06, 0x01, 0x80, 0x38,
  0x06, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x18, 0x03, 0x80, 0x30, 0x07, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x30, 0x03, 0x00, 0x60, 0x03, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x60, 0x07, 0x00, 0x60, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x06,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x06, 0x00, 0xD8, 0x00, 0x06, 0x00,
  0xD8, 0x00, 0x06, 0x00, 0xDC, 0x00, 0x0E, 0x01, 0xCC, 0x00, 0x0C, 0x01,
  0xCC, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x0C, 0x01, 0x8E, 0x00, 0x0C, 0x01,
  0x86, 0x00, 0x1C, 0x03, 0x86, 0x00, 0x18, 0x03, 0x06, 0x00, 0x18, 0x03,
  0x07, 0x00, 0x18, 0x03, 0x03, 0x00, 0x18, 0x03, 0x03, 0x00, 0x38, 0x07,
  0x03, 0x00, 0x30, 0x06, 0x03, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x60, 0x0C,
  0x00, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0xE0, 0x1C,
  0x00, 0xE0, 0xC0, 0x1C, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x60, 0xC0, 0x18,
  0x00, 0x60, 0xC0, 0x18, 0x00, 0x71, 0xC0, 0x38, 0x00, 0x31, 0x80, 0x30,
  0x00, 0x31, 0x80, 0x30, 0x00, 0x31, 0x80, 0x30, 0x00, 0x3B, 0x80, 0x30,
  0x00, 0x1B, 0x80, 0x70, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x60,
  0x00, 0x1F, 0x00, 0x60, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0xC0, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03,
  0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x01, 0xC0,
  0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x1C, 0x3F, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x0F, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0xC0,
  0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0E,
  0x00, 0x30, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x80, 0x01, 0xC0, 0x38, 0x01, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x30,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00,
  0x1C, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0xC0,
  0x00, 0xD8, 0x00, 0x38, 0xC0, 0x01, 0xD8, 0x00, 0x30, 0xC0, 0x01, 0x98,
  0x00, 0x70, 0xC0, 0x03, 0x98, 0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x18, 0x03, 0x80, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x18,
  0x0E, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0xC0,
  0x18, 0x38, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x76, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xC0,
  0x06, 0x07, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x06,
  0x18, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x61, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0,
  0x01, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x1C,
  0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC1, 0xC1, 0x83, 0x83,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC3, 0x00,
  0xF9, 0xE6, 0x01, 0xC0, 0x66, 0x03, 0x80, 0x36, 0x07, 0x00, 0x16, 0x06,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18,
  0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x60, 0x06, 0xC0, 0x70, 0x0C, 0xC0, 0x38,
  0x19, 0x80, 0x3E, 0xF1, 0x80, 0x1F, 0xE1, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x83, 0xE0, 0x03, 0x8F, 0xF8, 0x03, 0x1C, 0x7C, 0x03,
  0x30, 0x1C, 0x03, 0x60, 0x0E, 0x03, 0xC0, 0x06, 0x06, 0xC0, 0x06, 0x07,
  0x80, 0x06, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x38, 0x30, 0x00, 0x38, 0x78, 0x00, 0x30, 0x78, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0x78, 0x00, 0xC0, 0x4C, 0x01, 0xC0, 0xCE, 0x07, 0x80, 0xC7,
  0xFF, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0x00, 0xF8, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x04, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x06, 0x00, 0x1F, 0xF0, 0xC0,
  0x07, 0xCF, 0x38, 0x01, 0xC0, 0x36, 0x00, 0x70, 0x06, 0xC0, 0x1C, 0x00,
  0x58, 0x03, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x18, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x1F, 0x00,
  0xE0, 0x03, 0xC0, 0x0C, 0x00, 0xD8, 0x01, 0xC0, 0x33, 0x00, 0x1C, 0x0E,
  0x60, 0x03, 0xEF, 0x88, 0x00, 0x3F, 0xC3, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0xF0, 0xE0, 0x1C, 0x07, 0x03, 0x80,
  0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80,
  0x07, 0x18, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x01, 0xC3, 0x00, 0x38, 0x70,
  0x0F, 0x06, 0x0F, 0xC0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x02, 0x01, 0xFB, 0xE0, 0x0F, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xEC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xBE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFC, 0x30, 0x03, 0xE7, 0x8C, 0x01, 0xC0, 0x36, 0x00,
  0xE0, 0x0D, 0x80, 0x70, 0x01, 0x60, 0x18, 0x00, 0x78, 0x0E, 0x00, 0x1E,
  0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x38, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0x80,
  0x0F, 0x80, 0xE0, 0x03, 0xC0, 0x18, 0x01, 0xB0, 0x07, 0x00, 0xCC, 0x00,
  0xE0, 0x77, 0x00, 0x3E, 0xF9, 0x80, 0x07, 0xF8, 0x60, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x1E, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x7C, 0x00, 0xE3, 0xFE, 0x01, 0x8F, 0x1E, 0x03, 0x30, 0x1C, 0x06,
  0xC0, 0x18, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0,
  0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60,
  0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80,
  0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xDE, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x40, 0xE0, 0x07, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x06,
  0x00, 0x0E, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x31, 0xC0, 0x00, 0x67, 0x80,
  0x01, 0xCF, 0x00, 0x03, 0x36, 0x00, 0x06, 0xCE, 0x00, 0x0F, 0x0C, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x70, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0x07, 0xFC, 0x03,
  0x3C, 0x78, 0xF1, 0xE0, 0x37, 0x03, 0x9C, 0x07, 0x03, 0x60, 0x1B, 0x80,
  0x70, 0x3C, 0x01, 0xF0, 0x03, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x70, 0x01,
  0xE0, 0x03, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC0, 0x07, 0x06,
  0x00, 0x18, 0x00, 0x70, 0xE0, 0x01, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x00, 0xE1, 0xC0, 0x03,
  0x00, 0x0C, 0x1C, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x07, 0x00, 0x0C, 0x18,
  0x00, 0x70, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x60, 0x01,
  0x83, 0x80, 0x06, 0x00, 0x18, 0x30, 0x00, 0xE0, 0x01, 0x83, 0x00, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x07,
  0x06, 0x00, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x1F,
  0xF0, 0x0C, 0xF8, 0xF0, 0x1B, 0x80, 0xE0, 0x36, 0x00, 0xC0, 0x78, 0x01,
  0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18,
  0x38, 0x00, 0x30, 0x70, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00,
  0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x03,
  0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x60, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0x0F, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0x60,
  0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x31, 0x80, 0x00,
  0xCE, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60,
  0x03, 0x81, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x7C, 0x00, 0x0C, 0x3F, 0xE0, 0x01,
  0x8E, 0x1E, 0x00, 0x33, 0x81, 0xC0, 0x06, 0xC0, 0x1C, 0x00, 0xF8, 0x01,
  0x80, 0x3E, 0x00, 0x30, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x07,
  0x80, 0x0E, 0x00, 0xF0, 0x01, 0x80, 0x1B, 0x00, 0x70, 0x07, 0x70, 0x3C,
  0x00, 0xC7, 0xFF, 0x00, 0x18, 0x7F, 0x80, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xC3, 0x00, 0xF1, 0xE3, 0x01, 0xC0, 0x76, 0x03, 0x80, 0x36, 0x07, 0x00,
  0x16, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03, 0xC0, 0x60, 0x06, 0xC0, 0x70, 0x0E,
  0xC0, 0x78, 0x1D, 0xC0, 0x3E, 0xF9, 0xC0, 0x1F, 0xE1, 0x80, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x61, 0xF8, 0x0C, 0xF9, 0x01,
  0x98, 0x00, 0x36, 0x00, 0x07, 0x80, 0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xE1, 0xF0, 0x70, 0x02, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0xC0, 0x1C, 0x0F, 0xDF, 0x80, 0x7F, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x3F, 0xFB, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xDC, 0x0F, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x03,
  0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x60, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0,
  0x01, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x1E,
  0x07, 0x00, 0x2C, 0x0E, 0x00, 0xD8, 0x0E, 0x07, 0x30, 0x1F, 0x7C, 0x40,
  0x1F, 0xE1, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0,
  0x00, 0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x86,
  0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0,
  0x60, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x06, 0x03, 0x00, 0x60, 0x70,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x18,
  0x00, 0x71, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x1E,
  0x00, 0x36, 0x00, 0x3C, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0x98, 0x01, 0xB0,
  0x07, 0x30, 0x07, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x19, 0x80,
  0x61, 0x80, 0x63, 0x00, 0xC3, 0x00, 0xC6, 0x03, 0x86, 0x03, 0x0C, 0x06,
  0x0C, 0x06, 0x18, 0x1C, 0x18, 0x1C, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0xC1, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x83, 0x03, 0x0E, 0x03,
  0x0C, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x30, 0x0C, 0x70, 0x18, 0xC0, 0x18,
  0xC0, 0x31, 0x80, 0x33, 0x80, 0x67, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xCC,
  0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0x81, 0xF0,
  0x3C, 0x00, 0xFF, 0xE8, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 44, 13, 1, -44 },
  { 67, 13, 16, 18, 6, -44 },
  { 93, 27, 44, 27, 1, -44 },
  { 242, 24, 50, 25, 1, -46 },
  { 392, 30, 45, 37, 4, -44 },
  { 561, 26, 45, 27, 0, -44 },
  { 708, 6, 16, 10, 6, -44 },
  { 720, 17, 53, 15, 2, -43 },
  { 833, 17, 53, 15, -4, -43 },
  { 946, 19, 20, 24, 7, -46 },
  { 994, 23, 29, 28, 3, -36 },
  { 1078, 9, 14, 11, -3, -6 },
  { 1094, 13, 3, 17, 2, -18 },
  { 1099, 4, 5, 11, 1, -5 },
  { 1102, 26, 44, 19, -3, -44 },
  { 1245, 23, 45, 25, 2, -44 },
  { 1375, 12, 44, 25, 8, -44 },
  { 1441, 25, 44, 25, -1, -44 },
  { 1579, 26, 45, 25, -1, -44 },
  { 1726, 26, 44, 25, -1, -44 },
  { 1869, 25, 45, 25, 0, -44 },
  { 2010, 24, 45, 25, 2, -44 },
  { 2145, 24, 44, 25, 3, -44 },
  { 2277, 25, 45, 25, 0, -44 },
  { 2418, 23, 45, 25, 1, -44 },
  { 2548, 9, 33, 11, 1, -33 },
  { 2586, 13, 41, 11, -3, -33 },
  { 2653, 23, 26, 28, 3, -35 },
  { 2728, 23, 15, 28, 3, -29 },
  { 2772, 23, 26, 28, 3, -35 },
  { 2847, 18, 44, 18, 2, -44 },
  { 2946, 35, 49, 38, 2, -44 },
  { 3161, 25, 44, 25, -4, -44 },
  { 3299, 26, 44, 27, 1, -44 },
  { 3442, 27, 45, 26, 3, -44 },
  { 3594, 28, 44, 30, 1, -44 },
  { 3748, 26, 44, 24, 1, -44 },
  { 3891, 26, 44, 23, 1, -44 },
  { 4034, 30, 45, 32, 3, -44 },
  { 4203, 31, 44, 32, 1, -44 },
  { 4374, 19, 44, 13, -2, -44 },
  { 4479, 22, 55, 11, -9, -44 },
  { 4631, 29, 44, 25, 1, -44 },
  { 4791, 16, 44, 22, 1, -44 },
  { 4879, 40, 44, 40, 1, -44 },
  { 5099, 32, 44, 33, 1, -44 },
  { 5275, 28, 45, 33, 3, -44 },
  { 5433, 25, 44, 26, 1, -44 },
  { 5571, 28, 54, 33, 3, -44 },
  { 5760, 25, 44, 26, 1, -44 },
  { 5898, 26, 45, 24, -1, -44 },
  { 6045, 22, 44, 22, 5, -44 },
  { 6166, 29, 45, 31, 3, -44 },
  { 6330, 25, 44, 25, 5, -44 },
  { 6468, 40, 44, 41, 6, -44 },
  { 6688, 31, 44, 23, -4, -44 },
  { 6859, 22, 44, 22, 5, -44 },
  { 6980, 28, 44, 23, -2, -44 },
  { 7134, 22, 54, 17, -1, -44 },
  { 7283, 9, 44, 20, 6, -44 },
  { 7333, 22, 54, 17, -4, -44 },
  { 7482, 24, 23, 27, 2, -44 },
  { 7551, 19, 2, 18, -5, 6 },
  { 7556, 7, 10, 13, 9, -47 },
  { 7565, 24, 34, 27, 2, -33 },
  { 7667, 24, 47, 27, 1, -46 },
  { 7808, 20, 34, 20, 2, -33 },
  { 7893, 27, 47, 27, 2, -46 },
  { 8052, 20, 34, 23, 2, -33 },
  { 8137, 29, 62, 13, -8, -47 },
  { 8362, 26, 48, 27, 0, -33 },
  { 8518, 23, 46, 26, 1, -46 },
  { 8651, 12, 44, 11, 1, -44 },
  { 8717, 21, 59, 11, -8, -44 },
  { 8872, 23, 46, 21, 1, -46 },
  { 9005, 12, 46, 11, 1, -46 },
  { 9074, 36, 33, 39, 1, -33 },
  { 9223, 23, 33, 26, 1, -33 },
  { 9318, 22, 34, 26, 2, -33 },
  { 9412, 27, 47, 27, -2, -33 },
  { 9571, 24, 47, 27, 2, -33 },
  { 9712, 19, 33, 17, 1, -33 },
  { 9791, 20, 34, 20, 0, -33 },
  { 9876, 13, 41, 14, 2, -40 },
  { 9943, 23, 33, 26, 2, -32 },
  { 10038, 20, 32, 20, 3, -32 },
  { 10118, 31, 32, 33, 4, -32 },
  { 10242, 26, 32, 21, -3, -32 },
  { 10346, 31, 47, 21, -7, -32 },
  { 10529, 22, 32, 18, -2, -32 },
  { 10617, 21, 54, 19, 2, -44 },
  { 10759, 2, 61, 25, 12, -46 },
  { 10775, 22, 54, 19, -4, -44 },
  { 10924, 23, 5, 28, 3, -24 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC61PT7B_H_
