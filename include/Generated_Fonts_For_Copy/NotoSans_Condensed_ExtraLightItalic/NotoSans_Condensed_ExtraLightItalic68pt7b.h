#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC68PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1C, 0x0E, 0x38, 0x18, 0x60, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x38, 0xE0, 0x61, 0x80, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0x67, 0xE0, 0x0E, 0x0C, 0x1C, 0x03, 0x83, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0C, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x30, 0x1C, 0x00, 0x06, 0x07, 0x01, 0x80, 0xC3, 0xC0, 0x3F, 0x1B,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0x00, 0x7F, 0x80, 0x01, 0xC0, 0x38, 0x70, 0x00, 0x60, 0x1C, 0x1C, 0x00,
  0x38, 0x0E, 0x03, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x30,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x70,
  0x03, 0x01, 0x80, 0x18, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0x70, 0x30, 0x01,
  0x80, 0x18, 0x1C, 0x00, 0xE0, 0x06, 0x06, 0x00, 0x38, 0x01, 0x83, 0x80,
  0x0E, 0x00, 0xE0, 0xC0, 0x03, 0x00, 0x30, 0x60, 0x30, 0xC0, 0x0C, 0x38,
  0x7F, 0x30, 0x07, 0x0C, 0x3F, 0xEC, 0x01, 0x87, 0x1C, 0x1F, 0x00, 0xE1,
  0x86, 0x03, 0xC0, 0x30, 0xE3, 0x80, 0xF8, 0x1C, 0x30, 0xC0, 0x3E, 0x06,
  0x18, 0x70, 0x0D, 0xC7, 0x0E, 0x18, 0x03, 0x7F, 0xC3, 0x0E, 0x00, 0xC7,
  0xC1, 0xC3, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x38, 0x70, 0x03,
  0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x03, 0x81, 0x80,
  0x1C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x70, 0x38, 0x01, 0x80, 0x18, 0x0E,
  0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x1C,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0x38, 0x0C, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0xC0, 0x01, 0x83, 0x80, 0x70, 0x00, 0x7B, 0xC0, 0x38, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x10, 0x70,
  0x38, 0x03, 0x07, 0x00, 0xE0, 0x38, 0x70, 0x07, 0x01, 0xC3, 0x80, 0x18,
  0x0C, 0x38, 0x00, 0xE0, 0xE1, 0x80, 0x07, 0x06, 0x1C, 0x00, 0x18, 0x70,
  0xE0, 0x00, 0xE3, 0x06, 0x00, 0x03, 0x38, 0x30, 0x00, 0x1D, 0x83, 0x80,
  0x00, 0xFC, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0xFC, 0x07, 0x00, 0x0E, 0x70,
  0x3C, 0x00, 0xE3, 0x80, 0xF0, 0x1E, 0x0C, 0x03, 0xFF, 0xE0, 0x70, 0x0F,
  0xFC, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3,
  0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x1E, 0x06, 0x00,
  0x3C, 0x30, 0x00, 0x79, 0x01, 0xC0, 0xF9, 0xFE, 0x01, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x00, 0x1C, 0x18, 0x01,
  0xC0, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03,
  0x01, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xFD, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xC7, 0x80, 0x07, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x81,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x78, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x3C, 0xE1, 0xE3, 0x0F, 0x0C, 0xF0, 0x73,
  0x81, 0xC4, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x78, 0x01,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x10, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x40, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x1C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x18,
  0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x08, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x81, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x07, 0xC0, 0x01, 0x87, 0xFE, 0x00, 0x31, 0xFB, 0xE0, 0x0E,
  0x70, 0x0E, 0x01, 0xD8, 0x00, 0xE0, 0x36, 0x00, 0x1C, 0x07, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E,
  0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x06, 0xE0, 0x70, 0x03,
  0xB0, 0x0F, 0x03, 0xCC, 0x01, 0xFF, 0xC7, 0x00, 0x3F, 0xC1, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x08, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xE0, 0xF8,
  0x0C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x01,
  0xF8, 0x03, 0x83, 0x80, 0x0F, 0xFC, 0x07, 0x06, 0x00, 0x7C, 0x38, 0x0E,
  0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x30, 0x03, 0x00, 0xC0, 0x38, 0xE0, 0x0C,
  0x01, 0x80, 0x71, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0x00, 0x60, 0x0E, 0x01,
  0x8E, 0x01, 0xC0, 0x18, 0x03, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x30, 0x0E,
  0x00, 0xE0, 0x0C, 0x60, 0x18, 0x01, 0xC0, 0x39, 0xC0, 0x70, 0x03, 0x00,
  0x73, 0x80, 0xE0, 0x06, 0x00, 0xC6, 0x01, 0x80, 0x1C, 0x01, 0x8C, 0x03,
  0x00, 0x38, 0x07, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x30, 0x1C, 0x01, 0xC0,
  0x18, 0x60, 0x38, 0x03, 0x80, 0x71, 0xC0, 0x70, 0x07, 0x00, 0xC3, 0x80,
  0xE0, 0x1E, 0x03, 0x87, 0x01, 0xC0, 0x2C, 0x06, 0x0E, 0x03, 0x80, 0xD8,
  0x1C, 0x1C, 0x03, 0x03, 0x30, 0x70, 0x38, 0x07, 0x0E, 0x61, 0xC0, 0x70,
  0x07, 0xF8, 0xFF, 0x00, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x10, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x18, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x78, 0x01, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x02, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0x80,
  0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x18, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x04, 0x1C, 0x00, 0x0F, 0xFE, 0x06, 0x00, 0x03, 0xFF, 0x81, 0x80,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xE7, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60,
  0x01, 0xE0, 0x00, 0x60, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x03, 0x1E,
  0x00, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x07, 0x76, 0x00, 0x00, 0x07, 0xE7,
  0x00, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x07, 0x83, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x0D, 0x80, 0x0D, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0x60, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0x38, 0x01, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x00, 0x1C, 0xE0, 0x07, 0x18, 0x00, 0x00,
  0xC7, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x38, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x01,
  0x83, 0x80, 0x01, 0xC1, 0x80, 0x0C, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x38, 0x18,
  0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x60, 0x70, 0x07, 0x00, 0x30, 0x03, 0x03, 0x80, 0x30, 0x01,
  0x80, 0x18, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC1, 0xC0, 0x1C, 0x00, 0xE0,
  0x06, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x8E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x77,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0xB0, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x30, 0x01, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x00, 0x60,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x06, 0x60, 0x00,
  0x0E, 0x00, 0x66, 0x00, 0x00, 0xC0, 0x0E, 0x70, 0x00, 0x0C, 0x00, 0xE7,
  0x00, 0x01, 0xC0, 0x0E, 0x30, 0x00, 0x1C, 0x00, 0xC3, 0x00, 0x01, 0x80,
  0x0C, 0x38, 0x00, 0x18, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x1C, 0x18, 0x00,
  0x38, 0x01, 0x81, 0x80, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x30, 0x01, 0x81,
  0xC0, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x00,
  0x30, 0x0E, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x0C, 0x00,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x01, 0x81,
  0x80, 0x0C, 0x00, 0x18, 0x18, 0x01, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x00,
  0x1C, 0x38, 0x01, 0x80, 0x00, 0xC3, 0x80, 0x18, 0x00, 0x0C, 0x30, 0x01,
  0x80, 0x00, 0xE3, 0x00, 0x38, 0x00, 0x0E, 0x70, 0x03, 0x80, 0x00, 0x67,
  0x00, 0x30, 0x00, 0x06, 0x70, 0x03, 0x00, 0x00, 0x76, 0x00, 0x70, 0x00,
  0x07, 0x60, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x07, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x00, 0x7C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x06,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x03, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x8C, 0x00, 0x06,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC0,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x00, 0xC0, 0x0E,
  0x06, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80,
  0x0C, 0x07, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00,
  0x61, 0xC0, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x00,
  0xCC, 0x00, 0x0E, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x00, 0xD8,
  0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x0C,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x07, 0x06,
  0x06, 0x0C, 0x0C, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFE, 0x1C, 0x00,
  0xFF, 0xE3, 0x00, 0x3C, 0x0E, 0x60, 0x0E, 0x00, 0xCC, 0x03, 0x80, 0x0F,
  0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x3C,
  0x03, 0x80, 0x0D, 0x80, 0x70, 0x03, 0xB0, 0x07, 0x00, 0xE6, 0x00, 0xF0,
  0x39, 0xC0, 0x0F, 0xFE, 0x30, 0x00, 0xFF, 0x06, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x80, 0x01, 0xC3, 0xFE, 0x00, 0x71, 0xFF, 0xC0,
  0x18, 0xE0, 0x78, 0x06, 0x70, 0x0E, 0x01, 0xB0, 0x01, 0xC0, 0xFC, 0x00,
  0x70, 0x36, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xC1, 0xE0,
  0x00, 0x30, 0x78, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x1C, 0x1E, 0x00, 0x06, 0x06, 0xC0, 0x03, 0x81, 0xB0, 0x01,
  0xC0, 0x6E, 0x00, 0xE0, 0x39, 0xC0, 0x70, 0x0C, 0x3F, 0xF8, 0x03, 0x07,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3E, 0x02, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x30, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x1F, 0xF0, 0xE0, 0x00, 0xFF, 0xE3, 0x80, 0x07,
  0x81, 0xCC, 0x00, 0x38, 0x03, 0x30, 0x01, 0xC0, 0x06, 0xC0, 0x0E, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00,
  0x60, 0x00, 0xF8, 0x01, 0x80, 0x03, 0xE0, 0x07, 0x00, 0x1B, 0x80, 0x1C,
  0x00, 0xEC, 0x00, 0x38, 0x07, 0x30, 0x00, 0xF0, 0x38, 0xC0, 0x01, 0xFF,
  0xC3, 0x00, 0x03, 0xFE, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x01, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0E,
  0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0xF0, 0x30, 0x07, 0xC0, 0xE0,
  0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x80,
  0x78, 0x06, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE3,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x87, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xE0, 0xC0, 0x03, 0xFF, 0x86, 0x00, 0x3C, 0x0E, 0x60, 0x03,
  0x80, 0x33, 0x00, 0x38, 0x00, 0xD8, 0x03, 0x80, 0x06, 0xC0, 0x38, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0C, 0x00, 0x1F, 0x00, 0x60, 0x00, 0xF8,
  0x03, 0x80, 0x0D, 0xC0, 0x1C, 0x00, 0xEC, 0x00, 0x70, 0x0E, 0x60, 0x03,
  0xC0, 0xE7, 0x00, 0x0F, 0xFE, 0x38, 0x00, 0x3F, 0xE1, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x3C, 0x07, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x01,
  0xC3, 0xFE, 0x00, 0xE7, 0xFF, 0x80, 0x67, 0x81, 0xE0, 0x37, 0x00, 0x70,
  0x1B, 0x00, 0x38, 0x1F, 0x00, 0x0C, 0x0F, 0x00, 0x06, 0x07, 0x80, 0x03,
  0x03, 0x80, 0x01, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x21, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x01,
  0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0C,
  0x7C, 0x00, 0x06, 0x6E, 0x00, 0x03, 0x63, 0x00, 0x03, 0xF1, 0x80, 0x01,
  0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC3, 0xFC, 0x07,
  0xFC, 0x01, 0x8F, 0xFE, 0x0F, 0xFE, 0x01, 0x9C, 0x0E, 0x1C, 0x0F, 0x01,
  0xB8, 0x07, 0x30, 0x07, 0x03, 0xB0, 0x03, 0x60, 0x07, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x07, 0x80, 0x03, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x00, 0x38, 0x30, 0x00, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x70, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0xE1, 0xFF, 0x00, 0x63, 0xFF, 0xC0, 0x33, 0xC0, 0xF0, 0x1B, 0x80, 0x38,
  0x1D, 0x80, 0x1C, 0x0F, 0x80, 0x06, 0x07, 0x80, 0x03, 0x03, 0xC0, 0x01,
  0x81, 0xC0, 0x00, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x38,
  0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x1C,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE1, 0xFF, 0x00, 0x03,
  0x0F, 0xFE, 0x00, 0x0C, 0x70, 0x3C, 0x00, 0x33, 0x80, 0x70, 0x00, 0xDC,
  0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x06, 0x00, 0x78, 0x00,
  0x18, 0x01, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03,
  0x40, 0x01, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x37, 0x00, 0x70, 0x01, 0xCE,
  0x07, 0x80, 0x07, 0x1F, 0xFC, 0x00, 0x1C, 0x3F, 0xE0, 0x00, 0x60, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0xFF, 0xE1, 0x80, 0x78, 0x0E, 0x60,
  0x0E, 0x00, 0xCC, 0x03, 0x80, 0x0D, 0x80, 0xE0, 0x01, 0xB0, 0x38, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80,
  0xC0, 0x01, 0xF0, 0x18, 0x00, 0x3E, 0x03, 0x80, 0x0F, 0xC0, 0x70, 0x03,
  0xB0, 0x07, 0x00, 0xE6, 0x00, 0xF0, 0x39, 0xC0, 0x0F, 0xFE, 0x38, 0x00,
  0xFF, 0x87, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x1F, 0xC0, 0x63, 0xFC, 0x03, 0x3C, 0x00, 0x1B, 0x80, 0x01, 0xD8,
  0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xF0, 0x07, 0x03, 0x80,
  0x08, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x82, 0x00, 0x1C, 0x0C, 0x01, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x06,
  0x00, 0x07, 0x01, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x7C,
  0x0E, 0x00, 0x1E, 0x03, 0x80, 0x0D, 0x80, 0x70, 0x06, 0x60, 0x1E, 0x07,
  0x18, 0x03, 0xFF, 0x8E, 0x00, 0x7F, 0xC3, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x60, 0x1C, 0x01, 0x80,
  0xE0, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80,
  0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x06,
  0x38, 0x00, 0x18, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1B,
  0x80, 0x07, 0x80, 0x07, 0x70, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x00,
  0x19, 0xC0, 0x06, 0xC0, 0x07, 0x38, 0x00, 0xD8, 0x00, 0xC7, 0x00, 0x3B,
  0x00, 0x38, 0xE0, 0x06, 0x60, 0x07, 0x1C, 0x01, 0xCC, 0x00, 0xC3, 0x80,
  0x31, 0x80, 0x38, 0x70, 0x0E, 0x30, 0x06, 0x0E, 0x01, 0x86, 0x01, 0xC1,
  0xC0, 0x30, 0xC0, 0x30, 0x38, 0x0E, 0x18, 0x06, 0x07, 0x01, 0x83, 0x01,
  0xC0, 0xE0, 0x70, 0x60, 0x30, 0x1C, 0x0C, 0x0C, 0x0E, 0x03, 0x83, 0x81,
  0x81, 0x80, 0x70, 0x60, 0x30, 0x30, 0x0E, 0x0C, 0x06, 0x0E, 0x01, 0xC3,
  0x80, 0xC1, 0x80, 0x38, 0x60, 0x18, 0x70, 0x07, 0x1C, 0x03, 0x0C, 0x00,
  0xE3, 0x00, 0x63, 0x80, 0x1C, 0xE0, 0x0C, 0x60, 0x03, 0x98, 0x01, 0xCC,
  0x00, 0x73, 0x00, 0x33, 0x80, 0x0E, 0xE0, 0x06, 0x60, 0x01, 0xD8, 0x00,
  0xDC, 0x00, 0x3F, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x03, 0x60, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x06,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70,
  0x06, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x30,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x43, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFE,
  0x00, 0x17, 0x87, 0xE0, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x07, 0xFF, 0x20,
  0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 49, 14, 1, -49 },
  { 87, 15, 18, 20, 7, -49 },
  { 121, 31, 49, 31, 1, -49 },
  { 311, 27, 56, 28, 1, -52 },
  { 500, 34, 50, 41, 4, -49 },
  { 713, 29, 50, 30, 0, -49 },
  { 895, 6, 18, 11, 7, -49 },
  { 909, 19, 59, 17, 2, -48 },
  { 1050, 19, 59, 17, -5, -48 },
  { 1191, 21, 22, 26, 8, -52 },
  { 1249, 26, 32, 31, 3, -40 },
  { 1353, 9, 16, 12, -3, -7 },
  { 1371, 15, 3, 19, 2, -20 },
  { 1377, 5, 5, 12, 1, -5 },
  { 1381, 29, 48, 21, -3, -48 },
  { 1555, 25, 50, 28, 2, -49 },
  { 1712, 14, 49, 28, 9, -49 },
  { 1798, 29, 49, 28, -2, -49 },
  { 1976, 29, 50, 28, -1, -49 },
  { 2158, 28, 49, 28, -1, -49 },
  { 2330, 28, 50, 28, 0, -49 },
  { 2505, 27, 50, 28, 2, -49 },
  { 2674, 26, 49, 28, 4, -49 },
  { 2834, 28, 50, 28, 0, -49 },
  { 3009, 26, 50, 28, 1, -49 },
  { 3172, 10, 36, 12, 1, -36 },
  { 3217, 15, 45, 12, -3, -36 },
  { 3302, 26, 29, 31, 3, -39 },
  { 3397, 26, 16, 31, 3, -32 },
  { 3449, 26, 29, 31, 3, -39 },
  { 3544, 21, 49, 20, 2, -49 },
  { 3673, 39, 55, 42, 2, -49 },
  { 3942, 27, 49, 27, -4, -49 },
  { 4108, 29, 49, 31, 1, -49 },
  { 4286, 30, 50, 29, 3, -49 },
  { 4474, 31, 49, 34, 1, -49 },
  { 4664, 29, 49, 27, 1, -49 },
  { 4842, 29, 49, 25, 1, -49 },
  { 5020, 34, 50, 36, 3, -49 },
  { 5233, 35, 49, 35, 1, -49 },
  { 5448, 22, 49, 15, -3, -49 },
  { 5583, 24, 61, 13, -10, -49 },
  { 5766, 32, 49, 28, 1, -49 },
  { 5962, 18, 49, 25, 1, -49 },
  { 6073, 45, 49, 45, 1, -49 },
  { 6349, 36, 49, 36, 1, -49 },
  { 6570, 32, 50, 36, 3, -49 },
  { 6770, 28, 49, 29, 1, -49 },
  { 6942, 32, 61, 36, 3, -49 },
  { 7186, 28, 49, 29, 1, -49 },
  { 7358, 29, 50, 27, -1, -49 },
  { 7540, 24, 49, 24, 6, -49 },
  { 7687, 33, 50, 35, 3, -49 },
  { 7894, 27, 49, 28, 6, -49 },
  { 8060, 44, 49, 46, 7, -49 },
  { 8330, 34, 49, 25, -4, -49 },
  { 8539, 24, 49, 24, 6, -49 },
  { 8686, 31, 49, 26, -2, -49 },
  { 8876, 25, 60, 19, -1, -49 },
  { 9064, 10, 49, 22, 7, -49 },
  { 9126, 24, 60, 19, -4, -49 },
  { 9306, 27, 26, 30, 2, -49 },
  { 9394, 20, 3, 20, -5, 6 },
  { 9402, 7, 11, 15, 10, -52 },
  { 9412, 27, 38, 30, 2, -37 },
  { 9541, 26, 53, 30, 1, -52 },
  { 9714, 22, 38, 23, 2, -37 },
  { 9819, 30, 53, 30, 2, -52 },
  { 10018, 23, 38, 26, 2, -37 },
  { 10128, 32, 68, 15, -9, -52 },
  { 10400, 29, 53, 30, 0, -37 },
  { 10593, 25, 52, 29, 1, -52 },
  { 10756, 13, 49, 12, 1, -49 },
  { 10836, 23, 65, 12, -9, -49 },
  { 11023, 25, 52, 24, 1, -52 },
  { 11186, 13, 52, 12, 1, -52 },
  { 11271, 40, 37, 44, 1, -37 },
  { 11456, 25, 37, 29, 1, -37 },
  { 11572, 25, 38, 29, 2, -37 },
  { 11691, 30, 53, 30, -2, -37 },
  { 11890, 27, 53, 30, 2, -37 },
  { 12069, 21, 37, 19, 1, -37 },
  { 12167, 22, 38, 22, 0, -37 },
  { 12272, 15, 46, 16, 2, -45 },
  { 12359, 26, 37, 29, 2, -36 },
  { 12480, 22, 36, 22, 4, -36 },
  { 12579, 35, 36, 36, 4, -36 },
  { 12737, 28, 36, 24, -3, -36 },
  { 12863, 33, 53, 23, -7, -36 },
  { 13082, 24, 36, 20, -2, -36 },
  { 13190, 24, 60, 22, 2, -49 },
  { 13370, 2, 68, 28, 13, -52 },
  { 13387, 24, 60, 22, -4, -49 },
  { 13567, 26, 6, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC68PT7B_H_
