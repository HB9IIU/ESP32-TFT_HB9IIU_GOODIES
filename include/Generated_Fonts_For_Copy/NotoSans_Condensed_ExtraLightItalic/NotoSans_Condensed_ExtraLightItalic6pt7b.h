#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0x80, 0x7F, 0x40, 0x79, 0xC0, 0xFD, 0xD0, 0xEB, 0xE0, 0x80,
  0x6A, 0x80, 0xF8, 0xB0, 0x5D, 0x00, 0xC0, 0x80, 0x00, 0x5A, 0xFF, 0xF0,
  0x57, 0x57, 0x7D, 0xF7, 0xFA, 0xE0, 0x69, 0x40, 0xDF, 0xF7, 0x00, 0x30,
  0xEC, 0xFC, 0xF8, 0x5A, 0x7F, 0xAC, 0x40, 0x7F, 0xFE, 0xE0, 0x72, 0x60,
  0xF6, 0xE0, 0xFA, 0x60, 0xFA, 0x40, 0x72, 0xF0, 0xBE, 0xD0, 0xEA, 0x55,
  0xC0, 0xBB, 0x60, 0xAB, 0x99, 0xFD, 0xAE, 0xD0, 0xF6, 0xF0, 0xF7, 0x40,
  0xF6, 0xD4, 0xF7, 0x60, 0xF1, 0x60, 0xEA, 0xB6, 0xF0, 0xEA, 0xFF, 0x60,
  0xAA, 0x60, 0xEA, 0x6A, 0x60, 0xEA, 0x80, 0xF0, 0x56, 0x80, 0x54, 0x80,
  0x80, 0xF7, 0x00, 0x6F, 0xC0, 0xEC, 0x2E, 0xDC, 0xEC, 0x2D, 0x25, 0x80,
  0xF7, 0x60, 0x6F, 0xC0, 0x70, 0x15, 0xC0, 0x6E, 0xC0, 0xF8, 0xFD, 0xD0,
  0xFC, 0xFC, 0xFE, 0xF7, 0x20, 0xE8, 0xDC, 0xEA, 0xFC, 0xE8, 0xFF, 0x00,
  0xEC, 0x65, 0x60, 0x68, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 2, 0, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 1, 0, -4 },
  { 14, 1, 5, 1, 0, -4 },
  { 15, 2, 2, 2, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 1, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 1, 4, 2, 1, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 2, 4, 2, 0, -4 },
  { 28, 3, 4, 2, 0, -4 },
  { 30, 3, 4, 2, 0, -4 },
  { 32, 2, 4, 2, 0, -4 },
  { 33, 2, 4, 2, 0, -4 },
  { 34, 1, 3, 1, 0, -3 },
  { 35, 1, 4, 1, 0, -3 },
  { 36, 3, 2, 3, 0, -3 },
  { 37, 3, 2, 3, 0, -3 },
  { 38, 3, 2, 3, 0, -3 },
  { 39, 2, 4, 2, 0, -4 },
  { 40, 4, 5, 4, 0, -4 },
  { 43, 2, 4, 2, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 3, 4, 3, 0, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 3, 4, 2, 0, -4 },
  { 52, 3, 4, 2, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 2, 4, 1, 0, -4 },
  { 59, 2, 5, 1, -1, -4 },
  { 61, 3, 4, 2, 0, -4 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 3, 5, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 2, 0, -4 },
  { 78, 2, 4, 2, 1, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 2, 4, 2, 1, -4 },
  { 82, 3, 4, 4, 1, -4 },
  { 84, 3, 4, 2, 0, -4 },
  { 86, 2, 4, 2, 1, -4 },
  { 87, 3, 4, 2, 0, -4 },
  { 89, 2, 5, 2, 0, -4 },
  { 91, 1, 4, 2, 1, -4 },
  { 92, 2, 5, 2, 0, -4 },
  { 94, 3, 2, 3, 0, -4 },
  { 95, 1, 1, 2, 0, 0 },
  { 96, 1, 1, 1, 1, -5 },
  { 97, 3, 3, 3, 0, -3 },
  { 99, 2, 5, 3, 0, -5 },
  { 101, 2, 3, 2, 0, -3 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 2, 3, 2, 0, -3 },
  { 105, 3, 6, 1, -1, -5 },
  { 108, 3, 4, 3, 0, -3 },
  { 110, 2, 5, 3, 0, -5 },
  { 112, 1, 4, 1, 0, -4 },
  { 113, 2, 5, 1, -1, -4 },
  { 115, 2, 5, 2, 0, -5 },
  { 117, 1, 5, 1, 0, -5 },
  { 118, 4, 3, 4, 0, -3 },
  { 120, 2, 3, 3, 0, -3 },
  { 121, 2, 3, 3, 0, -3 },
  { 122, 2, 4, 3, 0, -3 },
  { 123, 3, 4, 3, 0, -3 },
  { 125, 2, 3, 2, 0, -3 },
  { 126, 2, 3, 2, 0, -3 },
  { 127, 2, 4, 1, 0, -4 },
  { 128, 2, 3, 3, 0, -3 },
  { 129, 2, 3, 2, 0, -3 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 2, 3, 2, 0, -3 },
  { 133, 3, 4, 2, -1, -3 },
  { 135, 2, 3, 2, 0, -3 },
  { 136, 2, 5, 2, 0, -4 },
  { 138, 1, 6, 2, 1, -5 },
  { 139, 2, 5, 2, 0, -4 },
  { 141, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC6PT7B_H_
