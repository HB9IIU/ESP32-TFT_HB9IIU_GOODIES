#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x40, 0x4C, 0x59, 0x99, 0xA0, 0x04,
  0x84, 0x82, 0x41, 0x23, 0xF8, 0x90, 0x48, 0x44, 0x24, 0x7F, 0x89, 0x09,
  0x04, 0x82, 0x40, 0x04, 0x0E, 0x15, 0x24, 0x24, 0x28, 0x28, 0x18, 0x0C,
  0x12, 0x12, 0x12, 0x14, 0xF8, 0x20, 0x20, 0x38, 0xD2, 0x24, 0x92, 0x24,
  0x8A, 0x22, 0xB9, 0x56, 0xA9, 0x4A, 0x44, 0x91, 0x44, 0x91, 0x24, 0x90,
  0xC0, 0x0E, 0x12, 0x12, 0x12, 0x14, 0x18, 0x10, 0x28, 0x49, 0x85, 0x86,
  0x82, 0x86, 0x7A, 0x6A, 0x80, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x80, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21,
  0x10, 0x88, 0x80, 0x12, 0x47, 0x4E, 0x51, 0x20, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x29, 0x28, 0xF0, 0x70, 0x01, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x00, 0x1E, 0x45, 0x0A, 0x14, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x14,
  0x48, 0x9E, 0x00, 0x36, 0xA2, 0x22, 0x44, 0x44, 0x88, 0x88, 0x3E, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFC,
  0x3F, 0x01, 0x01, 0x01, 0x01, 0x02, 0x1C, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x04, 0xF8, 0x03, 0x03, 0x05, 0x0A, 0x0A, 0x12, 0x22, 0x22, 0x44, 0x84,
  0xFF, 0x04, 0x08, 0x08, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x38, 0x04, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x1F, 0x20, 0x20, 0x40, 0x40, 0xB8,
  0xC4, 0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0x70, 0x7F, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1F, 0x21,
  0x21, 0x21, 0x21, 0x16, 0x18, 0x24, 0x42, 0x82, 0x82, 0x82, 0x84, 0x7C,
  0x1E, 0x21, 0x21, 0x41, 0x41, 0x41, 0x43, 0x25, 0x1A, 0x02, 0x04, 0x04,
  0x08, 0xF0, 0x24, 0x00, 0x00, 0x12, 0x00, 0x11, 0x00, 0x00, 0x00, 0x02,
  0x44, 0x88, 0x07, 0x08, 0x30, 0xC0, 0x40, 0x30, 0x0C, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0x18, 0x60, 0x80, 0x78,
  0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x08, 0x00, 0x82, 0x00, 0x0F, 0xC2,
  0x08, 0x80, 0xA0, 0x14, 0x73, 0x12, 0x64, 0x4C, 0x91, 0x92, 0x54, 0x4A,
  0x5A, 0x4C, 0x88, 0x01, 0x00, 0x10, 0x01, 0xE0, 0x02, 0x06, 0x05, 0x09,
  0x09, 0x09, 0x11, 0x11, 0x3F, 0x21, 0x41, 0x41, 0x81, 0x81, 0x1F, 0x08,
  0x44, 0x24, 0x12, 0x09, 0x08, 0xF8, 0x44, 0x41, 0x20, 0x90, 0x48, 0x44,
  0x27, 0xE0, 0x07, 0x04, 0x44, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0xF0, 0x1F, 0x08, 0x44, 0x24, 0x12,
  0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x48, 0x44, 0x47, 0xC0, 0x1F,
  0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0xF8, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x07, 0xE0, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7C,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x00, 0x03, 0x03, 0x31, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x87, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x10,
  0x83, 0xE0, 0x10, 0x22, 0x08, 0x41, 0x10, 0x22, 0x04, 0x41, 0x0F, 0xE1,
  0x04, 0x40, 0x88, 0x11, 0x04, 0x20, 0x88, 0x11, 0x02, 0x00, 0x1E, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x1E, 0x00, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x21, 0x80, 0x10, 0xC4, 0x41, 0x10, 0x88, 0x24, 0x0A, 0x03, 0x80,
  0xA0, 0x48, 0x11, 0x04, 0x41, 0x10, 0x82, 0x20, 0x80, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x83, 0xF0, 0x10, 0x08, 0xC0, 0xC6,
  0x06, 0x50, 0x52, 0x82, 0x94, 0x28, 0xA1, 0x45, 0x12, 0x48, 0x92, 0x48,
  0x92, 0x48, 0x8C, 0x48, 0x62, 0x42, 0x10, 0x10, 0x23, 0x04, 0x61, 0x14,
  0x22, 0x44, 0x48, 0x89, 0x11, 0x24, 0x42, 0x88, 0x51, 0x0A, 0x21, 0x48,
  0x11, 0x02, 0x00, 0x1F, 0x10, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xA0, 0x50, 0x48, 0x23, 0xE0, 0x1F, 0x08, 0x84, 0x24, 0x12,
  0x09, 0x08, 0x88, 0x78, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x00, 0x1F,
  0x10, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50,
  0x48, 0x23, 0xE0, 0x20, 0x10, 0x0C, 0x00, 0x1F, 0x08, 0x84, 0x24, 0x12,
  0x11, 0x08, 0x88, 0x78, 0x44, 0x22, 0x11, 0x08, 0x84, 0x24, 0x10, 0x1F,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x04,
  0xF8, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x00, 0x20, 0xC8, 0x22, 0x09, 0x02, 0x40, 0x90, 0x44, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x22, 0x08, 0x84, 0x1E, 0x00, 0x81, 0x82, 0x82, 0x84,
  0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x82, 0x0C,
  0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x48, 0xA2,
  0x85, 0x14, 0x30, 0xA1, 0x86, 0x08, 0x30, 0x41, 0x00, 0x10, 0xC2, 0x20,
  0x90, 0x24, 0x0A, 0x03, 0x00, 0x40, 0x30, 0x14, 0x05, 0x02, 0x41, 0x08,
  0x42, 0x20, 0x80, 0x83, 0x0A, 0x24, 0x49, 0x12, 0x18, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x00, 0x1F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x3F, 0x80, 0x1E, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0xE0, 0x92, 0x44, 0x92, 0x48, 0x92, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xF0, 0x18, 0x30,
  0x91, 0x24, 0x28, 0x60, 0x80, 0xFC, 0x94, 0x1A, 0x4D, 0x0C, 0x18, 0x30,
  0xA1, 0x42, 0x85, 0x1B, 0xE0, 0x10, 0x10, 0x10, 0x10, 0x2E, 0x31, 0x21,
  0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x44, 0xB8, 0x1C, 0x84, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x07, 0x00, 0x01, 0x80, 0x80, 0x40, 0x21, 0x91, 0x31,
  0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x88, 0x44, 0x63, 0xD0, 0x18, 0x94,
  0x61, 0x8B, 0xC8, 0x20, 0x82, 0x07, 0x80, 0x01, 0xC0, 0x80, 0x20, 0x08,
  0x0F, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x03, 0x00, 0x0C, 0x89, 0x88, 0x48,
  0x24, 0x12, 0x09, 0x08, 0x84, 0x42, 0x23, 0x1E, 0x80, 0x80, 0x40, 0x22,
  0x20, 0xE0, 0x10, 0x10, 0x10, 0x10, 0x2E, 0x31, 0x21, 0x21, 0x21, 0x42,
  0x42, 0x42, 0x42, 0x84, 0x84, 0x10, 0x02, 0x22, 0x24, 0x44, 0x44, 0x88,
  0x02, 0x00, 0x00, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x10, 0x10, 0x10, 0x21, 0x22, 0x24,
  0x28, 0x50, 0x70, 0x48, 0x48, 0x48, 0x84, 0x84, 0x11, 0x11, 0x22, 0x22,
  0x44, 0x44, 0x48, 0x80, 0x2E, 0x63, 0x29, 0x21, 0x12, 0x21, 0x22, 0x14,
  0x21, 0x42, 0x24, 0x22, 0x44, 0x28, 0x42, 0x84, 0x20, 0x2E, 0x31, 0x21,
  0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x18, 0x49, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0x11, 0xC0, 0x17, 0x0C, 0x44, 0x22, 0x11, 0x09,
  0x04, 0x82, 0x42, 0x21, 0x11, 0x17, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x19, 0x26, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x2C, 0xC2, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0x00, 0x1E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x13, 0xC0, 0x24,
  0xF4, 0x44, 0x88, 0x88, 0x88, 0xC0, 0x42, 0x85, 0x0A, 0x18, 0x50, 0xA1,
  0x42, 0x89, 0x13, 0xE0, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0xA0,
  0x81, 0x00, 0x84, 0x30, 0x8A, 0x31, 0x46, 0x49, 0x49, 0x29, 0x29, 0x45,
  0x28, 0xC6, 0x18, 0xC2, 0x10, 0x00, 0x11, 0x11, 0x12, 0x14, 0x0C, 0x08,
  0x18, 0x14, 0x24, 0x44, 0x84, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x02,
  0x80, 0xA0, 0x28, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03,
  0x00, 0x1E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x83, 0xE0, 0x0E,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x80, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0xC0, 0xF1, 0x8E,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 6, 2, -14 },
  { 11, 9, 14, 9, 0, -14 },
  { 27, 8, 16, 8, 0, -15 },
  { 43, 10, 14, 12, 1, -14 },
  { 61, 8, 14, 9, 0, -14 },
  { 75, 2, 5, 3, 2, -14 },
  { 77, 5, 17, 5, 1, -14 },
  { 88, 5, 17, 5, -1, -14 },
  { 99, 6, 6, 8, 2, -15 },
  { 104, 8, 10, 9, 1, -12 },
  { 114, 3, 5, 4, -1, -2 },
  { 116, 4, 1, 6, 1, -6 },
  { 117, 2, 2, 4, 0, -2 },
  { 118, 9, 14, 6, -1, -14 },
  { 134, 7, 14, 8, 1, -14 },
  { 147, 4, 14, 8, 3, -14 },
  { 154, 8, 14, 8, 0, -14 },
  { 168, 8, 14, 8, 0, -14 },
  { 182, 8, 14, 8, 0, -14 },
  { 196, 8, 14, 8, 0, -14 },
  { 210, 8, 14, 8, 1, -14 },
  { 224, 8, 14, 8, 1, -14 },
  { 238, 8, 14, 8, 0, -14 },
  { 252, 8, 14, 8, 0, -14 },
  { 266, 3, 11, 4, 0, -11 },
  { 271, 4, 14, 4, -1, -11 },
  { 278, 8, 8, 9, 1, -11 },
  { 286, 7, 5, 9, 1, -10 },
  { 291, 8, 8, 9, 1, -11 },
  { 299, 6, 14, 6, 1, -14 },
  { 310, 11, 16, 12, 1, -14 },
  { 332, 8, 14, 8, -1, -14 },
  { 346, 9, 14, 9, 0, -14 },
  { 362, 9, 15, 8, 1, -15 },
  { 379, 9, 14, 10, 0, -14 },
  { 395, 9, 14, 8, 0, -14 },
  { 411, 9, 14, 7, 0, -14 },
  { 427, 10, 15, 11, 1, -15 },
  { 446, 11, 14, 10, 0, -14 },
  { 466, 7, 14, 4, -1, -14 },
  { 479, 7, 18, 4, -3, -14 },
  { 495, 10, 14, 8, 0, -14 },
  { 513, 6, 14, 7, 0, -14 },
  { 524, 13, 14, 13, 0, -14 },
  { 547, 11, 14, 11, 0, -14 },
  { 567, 9, 14, 11, 1, -14 },
  { 583, 9, 14, 8, 0, -14 },
  { 599, 9, 17, 11, 1, -14 },
  { 619, 9, 14, 9, 0, -14 },
  { 635, 8, 14, 8, 0, -14 },
  { 649, 7, 14, 7, 2, -14 },
  { 662, 10, 14, 10, 1, -14 },
  { 680, 8, 14, 8, 2, -14 },
  { 694, 13, 14, 14, 2, -14 },
  { 717, 10, 14, 7, -1, -14 },
  { 735, 7, 14, 7, 2, -14 },
  { 748, 10, 14, 8, -1, -14 },
  { 766, 7, 17, 6, 0, -14 },
  { 781, 3, 14, 6, 2, -14 },
  { 787, 7, 17, 6, -1, -14 },
  { 802, 7, 7, 9, 1, -14 },
  { 809, 6, 1, 6, -2, 2 },
  { 810, 2, 3, 4, 3, -15 },
  { 811, 7, 11, 9, 1, -11 },
  { 821, 8, 15, 9, 0, -15 },
  { 836, 6, 11, 7, 1, -11 },
  { 845, 9, 15, 9, 1, -15 },
  { 862, 6, 11, 8, 1, -11 },
  { 871, 10, 20, 4, -3, -15 },
  { 896, 9, 16, 9, 0, -11 },
  { 914, 8, 15, 9, 0, -15 },
  { 929, 4, 14, 4, 0, -14 },
  { 936, 7, 19, 4, -3, -14 },
  { 953, 8, 15, 7, 0, -15 },
  { 968, 4, 15, 4, 0, -15 },
  { 976, 12, 11, 13, 0, -11 },
  { 993, 8, 11, 9, 0, -11 },
  { 1004, 7, 11, 9, 1, -11 },
  { 1014, 9, 16, 9, -1, -11 },
  { 1032, 8, 16, 9, 1, -11 },
  { 1048, 6, 11, 6, 0, -11 },
  { 1057, 7, 11, 7, 0, -11 },
  { 1067, 4, 13, 5, 1, -13 },
  { 1074, 7, 11, 9, 1, -11 },
  { 1084, 7, 11, 7, 1, -11 },
  { 1094, 11, 11, 11, 1, -11 },
  { 1110, 8, 11, 7, -1, -11 },
  { 1121, 10, 16, 7, -2, -11 },
  { 1141, 7, 11, 6, -1, -11 },
  { 1151, 7, 17, 6, 1, -14 },
  { 1166, 1, 20, 8, 4, -15 },
  { 1169, 7, 17, 6, -1, -14 },
  { 1184, 8, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC20PT7B_H_
