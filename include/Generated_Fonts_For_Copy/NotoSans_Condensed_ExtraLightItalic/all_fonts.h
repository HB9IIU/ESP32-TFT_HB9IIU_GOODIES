#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_ExtraLightItalic
// Headers: 67

#include "NotoSans_Condensed_ExtraLightItalic6pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic7pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic8pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic9pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic10pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic11pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic12pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic13pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic14pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic15pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic16pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic17pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic18pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic19pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic20pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic21pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic22pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic23pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic24pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic25pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic26pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic27pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic28pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic29pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic30pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic31pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic32pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic33pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic34pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic35pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic36pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic37pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic38pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic39pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic40pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic41pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic42pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic43pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic44pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic45pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic46pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic47pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic48pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic49pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic50pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic51pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic52pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic53pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic54pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic55pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic56pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic57pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic58pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic59pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic60pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic61pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic62pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic63pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic64pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic65pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic66pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic67pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic68pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic69pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic70pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic71pt7b.h"
#include "NotoSans_Condensed_ExtraLightItalic72pt7b.h"
