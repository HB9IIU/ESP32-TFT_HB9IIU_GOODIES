#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x4A, 0x63, 0x19, 0x4A, 0x40, 0x02, 0x10, 0x22,
  0x02, 0x20, 0x42, 0x04, 0x40, 0x44, 0x3F, 0xF0, 0x88, 0x08, 0x80, 0x88,
  0x11, 0x01, 0x10, 0xFF, 0xC2, 0x10, 0x22, 0x02, 0x20, 0x22, 0x04, 0x40,
  0x44, 0x00, 0x01, 0x00, 0x20, 0x0E, 0x06, 0xB1, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x01, 0x80, 0x10, 0x03, 0x00, 0x50, 0x09, 0x02, 0x20, 0x44,
  0x09, 0x11, 0x61, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x00, 0x18, 0x13, 0x21,
  0x11, 0x09, 0x08, 0x88, 0x44, 0x42, 0x42, 0x24, 0x11, 0x20, 0x8A, 0x74,
  0x94, 0x65, 0x23, 0xCA, 0x10, 0x90, 0x88, 0x88, 0x48, 0x44, 0x42, 0x22,
  0x22, 0x11, 0x30, 0x70, 0x03, 0x00, 0x90, 0x21, 0x04, 0x20, 0x88, 0x11,
  0x02, 0x40, 0x58, 0x0C, 0x01, 0x80, 0x50, 0x11, 0x14, 0x25, 0x84, 0xA0,
  0x64, 0x0C, 0x81, 0x98, 0x51, 0xF3, 0x00, 0x5A, 0xA8, 0x02, 0x08, 0x20,
  0x41, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x30, 0x00, 0x08, 0x08, 0x88, 0x68, 0x1F, 0x28, 0x48, 0x84, 0x04,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x24, 0xA5, 0x00, 0xF8, 0x70, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x07,
  0x02, 0x21, 0x08, 0x82, 0x20, 0xD8, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x28,
  0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x21, 0x07, 0x80, 0x04,
  0x62, 0xB2, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x00, 0x03, 0xC1, 0x8C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0xFE, 0x00, 0x07, 0x03, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x03, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x10, 0x43, 0xF0, 0x00, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xA0, 0x24, 0x05, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x84, 0x20,
  0x84, 0x11, 0x02, 0x3F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0F,
  0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x3E, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x10, 0x43,
  0xF0, 0x00, 0x01, 0xC1, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x5F, 0x28, 0x4C, 0x1A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x82, 0x31,
  0x87, 0xC0, 0x3F, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x0C, 0x00, 0x07, 0x81, 0x08, 0x40, 0x88, 0x11, 0x02, 0x20, 0x84, 0x10,
  0x44, 0x0F, 0x01, 0xC0, 0x4C, 0x30, 0x84, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x80, 0x88, 0x20, 0xF8, 0x00, 0x07, 0x02, 0x31, 0x04, 0x41, 0x20, 0x48,
  0x12, 0x04, 0x81, 0x20, 0x48, 0x33, 0x14, 0x3A, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x0F, 0x80, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCC,
  0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x11, 0x08, 0x80, 0x00,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x1C,
  0x62, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0x06, 0x30, 0x30, 0x10,
  0x80, 0x21, 0x00, 0x44, 0x00, 0x48, 0x78, 0xA1, 0x11, 0x44, 0x45, 0x10,
  0x8A, 0x21, 0x14, 0x42, 0x28, 0x88, 0x91, 0x11, 0x22, 0x64, 0x47, 0x38,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x04, 0x40, 0x84,
  0x20, 0x87, 0xF1, 0x02, 0x20, 0x4C, 0x09, 0x01, 0x60, 0x28, 0x07, 0x00,
  0x80, 0x0F, 0x80, 0x86, 0x08, 0x20, 0x81, 0x10, 0x11, 0x02, 0x10, 0x21,
  0x06, 0x10, 0xC3, 0xF0, 0x20, 0xC2, 0x04, 0x20, 0x42, 0x04, 0x40, 0x44,
  0x04, 0x40, 0x84, 0x10, 0xFE, 0x00, 0x01, 0xE0, 0x63, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x8E, 0x08, 0x20, 0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10,
  0x12, 0x01, 0x20, 0x12, 0x03, 0x20, 0x22, 0x02, 0x40, 0x44, 0x0C, 0x41,
  0x84, 0x30, 0xFC, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x07, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0xFC, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFE, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00, 0x01, 0xE0,
  0x30, 0xC2, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x79, 0x00, 0x48, 0x02, 0x40, 0x12, 0x01, 0x08, 0x08,
  0x40, 0x41, 0x02, 0x07, 0xF0, 0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02,
  0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0xFF, 0xC2, 0x01,
  0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01,
  0x0C, 0x04, 0x00, 0x0F, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x42, 0xC0,
  0xC0, 0x08, 0x08, 0x40, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0xC0, 0x4C,
  0x02, 0x40, 0x14, 0x01, 0x60, 0x0C, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x30, 0x20, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83,
  0xF8, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0A, 0x14, 0x02,
  0x85, 0x01, 0x41, 0x40, 0x50, 0x50, 0x24, 0x14, 0x09, 0x08, 0x84, 0x42,
  0x21, 0x20, 0x88, 0x88, 0x22, 0x22, 0x08, 0x90, 0x84, 0x24, 0x21, 0x0A,
  0x10, 0x42, 0x84, 0x10, 0xC1, 0x0C, 0x30, 0x40, 0x08, 0x04, 0x30, 0x10,
  0xC0, 0x43, 0x01, 0x14, 0x08, 0x48, 0x21, 0x20, 0x84, 0x82, 0x12, 0x10,
  0x84, 0x42, 0x11, 0x08, 0x44, 0x21, 0x10, 0x82, 0x84, 0x0A, 0x10, 0x28,
  0x40, 0xA1, 0x01, 0x8C, 0x04, 0x00, 0x03, 0xC0, 0x42, 0x08, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x18, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x0E,
  0x01, 0x18, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x10, 0x44,
  0x10, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x00, 0x03, 0xC0, 0x42, 0x08, 0x11, 0x01, 0x20, 0x12, 0x01, 0x60,
  0x14, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x48, 0x04, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x0E, 0x01, 0x18, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08, 0x83,
  0x10, 0x44, 0x30, 0xF8, 0x11, 0x02, 0x20, 0x42, 0x10, 0x42, 0x08, 0x41,
  0x08, 0x33, 0x02, 0x00, 0x07, 0xC1, 0x0C, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x10, 0x43, 0xF0, 0x00, 0xFF, 0x84, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x00, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x18, 0x80,
  0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x82, 0x08, 0x0F, 0x80,
  0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x41, 0x10, 0x22, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x28, 0x28,
  0x14, 0x14, 0x12, 0x12, 0x09, 0x09, 0x05, 0x0C, 0x84, 0x84, 0x42, 0x42,
  0x22, 0x22, 0x11, 0x11, 0x09, 0x09, 0x04, 0x84, 0x82, 0x42, 0x41, 0x41,
  0x40, 0xA0, 0xA0, 0x20, 0x60, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x10, 0x20,
  0x41, 0x00, 0x84, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x01, 0x40, 0x04, 0x80, 0x22, 0x01, 0x08, 0x04, 0x20,
  0x20, 0x81, 0x82, 0x0C, 0x04, 0x00, 0x80, 0xE0, 0x24, 0x11, 0x04, 0x42,
  0x10, 0x84, 0x41, 0x30, 0x48, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xFF, 0x80, 0x0F,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x03,
  0xC0, 0x92, 0x49, 0x12, 0x49, 0x24, 0x49, 0x24, 0x80, 0x07, 0xC0, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x0F, 0x80, 0x04, 0x01, 0x80, 0xA0, 0x28, 0x11, 0x0C, 0x42, 0x09, 0x02,
  0x40, 0xA0, 0x10, 0xFF, 0x91, 0x30, 0x0E, 0x44, 0x52, 0x0D, 0x02, 0x40,
  0x90, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x86, 0x1E, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0xE0, 0xA2, 0x18,
  0x42, 0x08, 0xC1, 0x90, 0x22, 0x04, 0x40, 0x90, 0x12, 0x06, 0x40, 0x88,
  0x31, 0x84, 0x4F, 0x00, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x7C, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x83, 0xD0, 0x8A, 0x20, 0xC8, 0x11, 0x02, 0x20, 0x48, 0x09,
  0x03, 0x20, 0x44, 0x08, 0x83, 0x10, 0x62, 0x14, 0x3D, 0x00, 0x0F, 0x11,
  0x21, 0x41, 0x41, 0x42, 0x9C, 0xE0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x7C,
  0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x07, 0xC0, 0xA0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x0E, 0x00, 0x07, 0xA1, 0x14, 0x41, 0x90, 0x22, 0x04, 0x40, 0x90,
  0x12, 0x06, 0x40, 0x88, 0x11, 0x06, 0x20, 0xC4, 0x28, 0x7A, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x18, 0x7E, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x38, 0x71, 0x18, 0x44, 0x12, 0x04, 0x81, 0x20, 0x88,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x44, 0x12, 0x04, 0x08, 0x40, 0x00, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x20, 0x01, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x04, 0x42, 0x11, 0x04, 0x82, 0x60, 0x90,
  0x2C, 0x0D, 0x06, 0x41, 0x10, 0x42, 0x10, 0x84, 0x22, 0x0C, 0x08, 0x42,
  0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11, 0x00, 0x17,
  0x9E, 0x18, 0xA3, 0x10, 0x41, 0x10, 0x41, 0x20, 0x81, 0x20, 0x82, 0x20,
  0x82, 0x20, 0x82, 0x40, 0x82, 0x41, 0x04, 0x41, 0x04, 0x41, 0x04, 0x41,
  0x04, 0x83, 0x04, 0x13, 0x87, 0x11, 0x84, 0x41, 0x20, 0x48, 0x12, 0x08,
  0x82, 0x40, 0x90, 0x24, 0x09, 0x04, 0x41, 0x20, 0x40, 0x0F, 0x08, 0xC8,
  0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x4C, 0x63,
  0xE0, 0x09, 0xC0, 0xA2, 0x0C, 0x20, 0x81, 0x18, 0x11, 0x02, 0x10, 0x21,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x42, 0x0C, 0x30, 0x84, 0xF0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x44, 0x52, 0x0D, 0x02,
  0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x85, 0x1E,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x13, 0x1C, 0x18, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1F, 0x21,
  0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8,
  0x10, 0x42, 0x1F, 0xA0, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20,
  0xE0, 0x20, 0x48, 0x22, 0x09, 0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0x81,
  0x20, 0x48, 0x22, 0x08, 0x86, 0x3E, 0x80, 0x80, 0xC0, 0x90, 0x48, 0x44,
  0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x02, 0x00, 0x82,
  0x0C, 0x30, 0xA1, 0x85, 0x14, 0x28, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x48,
  0xA2, 0x45, 0x14, 0x30, 0xA1, 0x86, 0x08, 0x30, 0x41, 0x00, 0x10, 0x62,
  0x08, 0x22, 0x04, 0x80, 0x90, 0x14, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x40,
  0x88, 0x11, 0x04, 0x11, 0x02, 0x00, 0x04, 0x08, 0x20, 0xC1, 0x04, 0x08,
  0x20, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x40,
  0x0A, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x01, 0xC0, 0x00, 0x1F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10,
  0x18, 0x08, 0x08, 0x04, 0x04, 0x07, 0xF0, 0x01, 0x83, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x18, 0x06, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x04, 0x01, 0x80, 0x40, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x30, 0x30, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x83, 0x80, 0xFC, 0x61, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 19, 6, 0, -19 },
  { 16, 5, 7, 8, 3, -19 },
  { 21, 12, 19, 12, 0, -19 },
  { 50, 11, 22, 11, 0, -20 },
  { 81, 13, 19, 16, 2, -19 },
  { 112, 11, 19, 12, 0, -19 },
  { 139, 2, 7, 4, 3, -19 },
  { 141, 7, 23, 6, 1, -19 },
  { 162, 7, 23, 6, -2, -19 },
  { 183, 8, 9, 10, 3, -20 },
  { 192, 10, 12, 12, 1, -15 },
  { 207, 3, 6, 5, -1, -3 },
  { 210, 5, 1, 7, 1, -8 },
  { 211, 2, 2, 5, 0, -2 },
  { 212, 11, 19, 8, -1, -19 },
  { 239, 10, 19, 11, 1, -19 },
  { 263, 6, 19, 11, 3, -19 },
  { 278, 11, 19, 11, -1, -19 },
  { 305, 11, 19, 11, 0, -19 },
  { 332, 11, 19, 11, 0, -19 },
  { 359, 11, 19, 11, 0, -19 },
  { 386, 10, 19, 11, 1, -19 },
  { 410, 10, 19, 11, 1, -19 },
  { 434, 11, 19, 11, 0, -19 },
  { 461, 10, 19, 11, 0, -19 },
  { 485, 4, 14, 5, 0, -14 },
  { 492, 5, 17, 5, -1, -14 },
  { 503, 10, 11, 12, 1, -15 },
  { 517, 10, 6, 12, 1, -12 },
  { 525, 10, 11, 12, 1, -15 },
  { 539, 8, 19, 8, 1, -19 },
  { 558, 15, 21, 16, 1, -19 },
  { 598, 11, 19, 11, -2, -19 },
  { 625, 12, 19, 12, 0, -19 },
  { 654, 12, 19, 11, 1, -19 },
  { 683, 12, 19, 13, 0, -19 },
  { 712, 11, 19, 10, 0, -19 },
  { 739, 11, 19, 10, 0, -19 },
  { 766, 13, 19, 14, 1, -19 },
  { 797, 14, 19, 13, 0, -19 },
  { 831, 8, 19, 6, -1, -19 },
  { 850, 9, 24, 5, -4, -19 },
  { 877, 13, 19, 11, 0, -19 },
  { 908, 7, 19, 9, 0, -19 },
  { 925, 18, 19, 17, 0, -19 },
  { 968, 14, 19, 14, 0, -19 },
  { 1002, 12, 19, 14, 1, -19 },
  { 1031, 11, 19, 11, 0, -19 },
  { 1058, 12, 23, 14, 1, -19 },
  { 1093, 11, 19, 11, 0, -19 },
  { 1120, 11, 19, 10, 0, -19 },
  { 1147, 9, 19, 9, 2, -19 },
  { 1169, 13, 19, 13, 1, -19 },
  { 1200, 11, 19, 11, 2, -19 },
  { 1227, 17, 19, 18, 2, -19 },
  { 1268, 14, 19, 10, -2, -19 },
  { 1302, 10, 19, 9, 2, -19 },
  { 1326, 12, 19, 10, -1, -19 },
  { 1355, 9, 23, 7, 0, -19 },
  { 1381, 3, 19, 8, 3, -19 },
  { 1389, 10, 23, 7, -2, -19 },
  { 1418, 10, 10, 11, 1, -19 },
  { 1431, 8, 1, 8, -2, 2 },
  { 1432, 3, 4, 6, 4, -20 },
  { 1434, 10, 14, 11, 1, -14 },
  { 1452, 11, 20, 11, 0, -20 },
  { 1480, 8, 14, 9, 1, -14 },
  { 1494, 11, 20, 11, 1, -20 },
  { 1522, 8, 14, 10, 1, -14 },
  { 1536, 12, 26, 6, -3, -20 },
  { 1575, 11, 20, 11, 0, -14 },
  { 1603, 10, 20, 11, 0, -20 },
  { 1628, 5, 19, 5, 0, -19 },
  { 1640, 8, 25, 5, -3, -19 },
  { 1665, 10, 20, 9, 0, -20 },
  { 1690, 5, 20, 5, 0, -20 },
  { 1703, 16, 14, 17, 0, -14 },
  { 1731, 10, 14, 11, 0, -14 },
  { 1749, 9, 14, 11, 1, -14 },
  { 1765, 12, 20, 11, -1, -14 },
  { 1795, 10, 20, 12, 1, -14 },
  { 1820, 8, 14, 7, 0, -14 },
  { 1834, 8, 14, 8, 0, -14 },
  { 1848, 6, 17, 6, 1, -17 },
  { 1861, 10, 14, 11, 1, -14 },
  { 1879, 9, 14, 8, 1, -14 },
  { 1895, 13, 14, 14, 2, -14 },
  { 1918, 11, 14, 9, -1, -14 },
  { 1938, 13, 20, 9, -3, -14 },
  { 1971, 9, 14, 8, -1, -14 },
  { 1987, 9, 23, 8, 1, -19 },
  { 2013, 1, 26, 11, 5, -20 },
  { 2017, 9, 23, 8, -2, -19 },
  { 2043, 10, 2, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC26PT7B_H_
