#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x31, 0x90, 0xC8, 0x4C, 0x26, 0x32,
  0x19, 0x08, 0x84, 0xC2, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01,
  0x82, 0x00, 0x20, 0x40, 0x04, 0x18, 0x01, 0x82, 0x00, 0x30, 0x40, 0x04,
  0x18, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x04, 0x18, 0x00, 0x83, 0x00, 0x30,
  0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0x83,
  0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x83, 0x00, 0x10, 0x60, 0x06, 0x08,
  0x00, 0x81, 0x00, 0x10, 0x60, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x60,
  0x06, 0x08, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0F, 0x80,
  0x1F, 0xF8, 0x18, 0x8C, 0x18, 0xC0, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x10,
  0x03, 0x08, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x0D, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x26, 0x00, 0x13, 0x00, 0x18, 0xC0,
  0x08, 0x60, 0x04, 0x30, 0x02, 0x18, 0x01, 0x0C, 0x01, 0x84, 0x00, 0x86,
  0x1C, 0x4E, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x01, 0x86, 0x30, 0x18, 0x20, 0x80,
  0x83, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x08, 0x20, 0x60,
  0xC2, 0x02, 0x06, 0x30, 0x10, 0x31, 0x00, 0x81, 0x18, 0x0C, 0x08, 0x8F,
  0x60, 0xCC, 0xFF, 0x04, 0x4C, 0x78, 0x64, 0x41, 0x46, 0x66, 0x0B, 0xE2,
  0x20, 0x46, 0x33, 0x02, 0x01, 0x18, 0x30, 0x18, 0x81, 0x80, 0x84, 0x0C,
  0x08, 0x20, 0x40, 0xC3, 0x02, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x06,
  0x08, 0x30, 0x30, 0xC1, 0x00, 0x8C, 0x18, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x30, 0x20, 0x18, 0x30, 0x08, 0x18,
  0x04, 0x0C, 0x02, 0x04, 0x01, 0x06, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x16,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x0C, 0xC0, 0x0C, 0x20, 0x4C,
  0x18, 0x64, 0x0C, 0x26, 0x02, 0x32, 0x01, 0x9B, 0x00, 0x59, 0x80, 0x38,
  0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x0F, 0x0C, 0x0C, 0x87, 0x0C, 0x61, 0xFC,
  0x30, 0x32, 0x26, 0x64, 0x44, 0xC8, 0x00, 0x70, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10,
  0x02, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x02, 0x08, 0x20, 0xE2, 0x03,
  0xA3, 0x0F, 0xF0, 0xE0, 0x1A, 0x03, 0x10, 0x61, 0x0C, 0x18, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x21, 0x86, 0x30, 0xC2, 0x18, 0xC0, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x03, 0x86, 0x02,
  0x06, 0x06, 0x02, 0x0C, 0x02, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10,
  0x02, 0x30, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x40, 0x20, 0x40, 0x60, 0x60,
  0xC0, 0x31, 0x80, 0x1F, 0x00, 0x03, 0x83, 0x87, 0x46, 0x66, 0x36, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x80, 0xE0, 0xC0, 0x40, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xC0,
  0xC0, 0x80, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x0C, 0x0E, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xD8, 0x00,
  0xC8, 0x00, 0x44, 0x00, 0x66, 0x00, 0x63, 0x00, 0x21, 0x00, 0x20, 0x80,
  0x30, 0x40, 0x10, 0x60, 0x10, 0x30, 0x18, 0x10, 0x18, 0x08, 0x08, 0x0C,
  0x0C, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x06, 0x00, 0x8B, 0xFF, 0xF8, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x10, 0x01, 0xFF, 0x00, 0x41, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x1C, 0x18,
  0x1C, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x33, 0xE0, 0x27, 0x78, 0x28, 0x18, 0x70, 0x0C,
  0x60, 0x0C, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x08, 0x40, 0x18, 0x40, 0x18, 0x60, 0x30, 0x60, 0x60,
  0x30, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x60,
  0x18, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x82, 0x00, 0x81,
  0x80, 0xC0, 0xC0, 0xC0, 0x30, 0xC0, 0x0D, 0x80, 0x03, 0x80, 0x07, 0xC0,
  0x0E, 0x30, 0x0C, 0x0C, 0x0C, 0x02, 0x0C, 0x01, 0x84, 0x00, 0x42, 0x00,
  0x23, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x06, 0x10, 0x02, 0x0C,
  0x03, 0x03, 0x07, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x01, 0xFC, 0x03, 0x06,
  0x06, 0x03, 0x04, 0x03, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01,
  0x18, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x18, 0x07,
  0x18, 0x0E, 0x0C, 0x1A, 0x07, 0xF6, 0x03, 0x86, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x83, 0x80, 0xFE, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0E,
  0x1C, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x02, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x03, 0x80, 0xFF, 0x04,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x18, 0x0F, 0x83,
  0x10, 0x18, 0xC3, 0x10, 0x20, 0x83, 0x30, 0x60, 0x82, 0x20, 0xC1, 0x82,
  0x20, 0x81, 0x82, 0x61, 0x81, 0x02, 0x61, 0x81, 0x06, 0x41, 0x03, 0x06,
  0x41, 0x03, 0x04, 0x43, 0x02, 0x0C, 0xC3, 0x06, 0x08, 0xC3, 0x06, 0x08,
  0xC3, 0x0A, 0x10, 0xC1, 0x1A, 0x30, 0xC1, 0xF3, 0xE0, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00,
  0xC8, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0x80, 0x18, 0x40,
  0x18, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x06, 0x04, 0x02, 0x02, 0x03, 0x01,
  0x01, 0xFF, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x60,
  0x06, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x18, 0x03, 0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x40,
  0x08, 0x20, 0x04, 0x30, 0x02, 0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0x82,
  0x00, 0xC3, 0x00, 0xC1, 0x81, 0xC0, 0xFF, 0x80, 0x41, 0xE0, 0x20, 0x18,
  0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x18, 0x80, 0x08, 0x40, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x18,
  0x7C, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x1C, 0x08, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x10, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x01, 0x83, 0xC0, 0x60, 0x38, 0x18, 0x06, 0x04, 0x00, 0xC1,
  0x00, 0x30, 0xC0, 0x04, 0x30, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x04, 0x60, 0x01, 0x18, 0x00, 0x46, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0x8C, 0x00, 0x62, 0x00, 0x18, 0x80, 0x04, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x61, 0x00, 0x30, 0x40, 0x1C, 0x30, 0x0E, 0x0C, 0x07,
  0x03, 0x1F, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x83, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xE0,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x83, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xFE, 0x01, 0xC0, 0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x01, 0xFC, 0xC0, 0x1F, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x06, 0x00, 0x20, 0x60, 0x02, 0x03, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0xFF,
  0xC0, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x60,
  0x40, 0x03, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x40, 0x03, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0F,
  0xFF, 0xE0, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x0C,
  0x08, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x08, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x08, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x08, 0xC0, 0x3E, 0x00, 0x02, 0x00, 0x60,
  0xC0, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0x40, 0x60, 0x08, 0x18, 0x03,
  0x02, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x23, 0x00, 0x0C,
  0xC0, 0x01, 0xB0, 0x00, 0x27, 0x00, 0x05, 0x60, 0x01, 0xC4, 0x00, 0x38,
  0xC0, 0x06, 0x18, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x02, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x08, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x0F, 0xFE, 0x03, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x05, 0x03, 0x80, 0x01, 0xE0,
  0x50, 0x00, 0x2C, 0x0B, 0x00, 0x0D, 0x03, 0x60, 0x01, 0x20, 0x6C, 0x00,
  0x6C, 0x0D, 0x80, 0x09, 0x81, 0x30, 0x03, 0x30, 0x22, 0x00, 0x44, 0x0C,
  0x40, 0x18, 0x81, 0x88, 0x02, 0x30, 0x21, 0x00, 0xC6, 0x04, 0x20, 0x10,
  0x81, 0x84, 0x06, 0x10, 0x30, 0x80, 0x86, 0x06, 0x18, 0x30, 0xC0, 0x83,
  0x04, 0x18, 0x10, 0x61, 0x82, 0x06, 0x0C, 0x20, 0x40, 0xC1, 0x8C, 0x18,
  0x18, 0x11, 0x03, 0x02, 0x02, 0x60, 0x60, 0x40, 0x48, 0x08, 0x18, 0x0B,
  0x01, 0x03, 0x01, 0x40, 0x60, 0x40, 0x38, 0x0C, 0x08, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x08, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0F, 0x00, 0x30, 0x58,
  0x01, 0x02, 0x40, 0x08, 0x32, 0x00, 0xC1, 0x98, 0x06, 0x0C, 0xC0, 0x20,
  0x42, 0x01, 0x02, 0x10, 0x18, 0x30, 0xC0, 0xC1, 0x86, 0x06, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x06, 0x06, 0x18, 0x30, 0x30, 0xC1, 0x80, 0x86, 0x08,
  0x04, 0x20, 0x40, 0x31, 0x06, 0x01, 0x98, 0x30, 0x04, 0xC1, 0x80, 0x24,
  0x08, 0x01, 0xA0, 0x40, 0x0D, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x00,
  0x0C, 0x08, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x06, 0x06,
  0x01, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x10, 0x00, 0x66, 0x00, 0x0C, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xD0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C, 0x03,
  0x87, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0x07, 0x01, 0x80, 0xC0,
  0xC0, 0x20, 0x40, 0x18, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0x84, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x60, 0x40,
  0x60, 0x7F, 0xE0, 0x3F, 0x80, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0,
  0x06, 0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x10, 0x00, 0x66, 0x00, 0x0C, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x30,
  0x0C, 0x03, 0x87, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x03,
  0xFC, 0x03, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x20, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC3, 0x00,
  0x41, 0x80, 0x60, 0xC0, 0x60, 0x41, 0xE0, 0x7F, 0xC0, 0x30, 0xC0, 0x18,
  0x20, 0x08, 0x18, 0x04, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80,
  0x80, 0x60, 0x40, 0x30, 0x60, 0x18, 0x30, 0x04, 0x18, 0x03, 0x08, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x18, 0x0C, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0xE0, 0x70, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00,
  0x61, 0x80, 0x04, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x10, 0x00, 0xC1, 0x00,
  0x08, 0x30, 0x00, 0x83, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x18, 0x60,
  0x01, 0x06, 0x00, 0x10, 0x60, 0x03, 0x04, 0x00, 0x30, 0x40, 0x02, 0x0C,
  0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x07, 0x07, 0x00, 0x1F, 0xC0,
  0x00, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x08, 0x80, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0xC1, 0x80, 0xC1, 0x00, 0xC3,
  0x00, 0xC2, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x4C, 0x00, 0x4C, 0x00, 0x48,
  0x00, 0x58, 0x00, 0x50, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x1A, 0x00, 0x70, 0x03, 0x40, 0x0A, 0x00,
  0xC8, 0x01, 0x40, 0x19, 0x00, 0x68, 0x02, 0x20, 0x09, 0x00, 0xC4, 0x03,
  0x20, 0x10, 0x80, 0x44, 0x06, 0x10, 0x08, 0x80, 0xC2, 0x03, 0x10, 0x10,
  0x40, 0x42, 0x06, 0x08, 0x18, 0x40, 0x81, 0x02, 0x08, 0x30, 0x20, 0xC1,
  0x06, 0x04, 0x18, 0x21, 0x80, 0x82, 0x04, 0x30, 0x10, 0xC0, 0x84, 0x02,
  0x10, 0x11, 0x80, 0x46, 0x02, 0x20, 0x08, 0x80, 0x4C, 0x01, 0x10, 0x09,
  0x80, 0x26, 0x01, 0x20, 0x04, 0x80, 0x2C, 0x00, 0xB0, 0x05, 0x00, 0x14,
  0x00, 0xE0, 0x02, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x30, 0x18, 0x06, 0x01, 0x80, 0x40, 0x08, 0x0C, 0x00,
  0x80, 0x80, 0x08, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x46, 0x00,
  0x04, 0xC0, 0x00, 0x48, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xB0, 0x00, 0x19, 0x00, 0x03, 0x10,
  0x00, 0x21, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80,
  0x80, 0x10, 0x08, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0xC0, 0xC0,
  0x04, 0x00, 0x80, 0x0E, 0x00, 0x2C, 0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x01,
  0x84, 0x04, 0x10, 0x30, 0x40, 0x81, 0x86, 0x06, 0x30, 0x18, 0x80, 0x26,
  0x00, 0x90, 0x02, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFE, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFC, 0x00, 0xC3, 0x04, 0x10, 0x41,
  0x06, 0x18, 0x20, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x06, 0x18,
  0x60, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xA0, 0x01, 0xB0, 0x03, 0x10, 0x02, 0x18,
  0x06, 0x18, 0x04, 0x08, 0x0C, 0x0C, 0x18, 0x04, 0x18, 0x06, 0x30, 0x06,
  0x20, 0x02, 0x60, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0xC4, 0x62, 0x31, 0x01,
  0xF1, 0x03, 0x99, 0x06, 0x0F, 0x0C, 0x07, 0x18, 0x06, 0x10, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40,
  0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x40, 0x38, 0x40,
  0x70, 0x60, 0x50, 0x71, 0x90, 0x3F, 0x30, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0xF8, 0x09, 0x9C, 0x0B, 0x06, 0x1E, 0x02, 0x1C, 0x02, 0x18,
  0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20,
  0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x08, 0xE0,
  0x18, 0xE0, 0x10, 0xA0, 0x30, 0x90, 0xE0, 0x9F, 0x80, 0x01, 0xF8, 0x1C,
  0x41, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x04, 0x0F, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x7C, 0x40, 0x39, 0x90, 0x18, 0x34,
  0x0C, 0x07, 0x06, 0x01, 0xC1, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x08,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x04, 0x00,
  0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x04, 0x03, 0x81, 0x01, 0xE0,
  0x60, 0x50, 0x1C, 0x64, 0x03, 0xF1, 0x00, 0x01, 0xF0, 0x0E, 0x60, 0x60,
  0xC3, 0x03, 0x18, 0x0C, 0x40, 0x33, 0x00, 0x88, 0x06, 0x60, 0x31, 0x83,
  0x87, 0xF8, 0x1F, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x60, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x80, 0xE6, 0x40, 0xC1, 0xA0, 0xC0, 0x70, 0xC0, 0x38, 0x40,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x84,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C,
  0x10, 0x0E, 0x08, 0x0F, 0x06, 0x05, 0x03, 0x8C, 0x80, 0xFC, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x04, 0x06, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x19, 0xF0, 0x27, 0x70, 0x50, 0x31, 0xC0, 0x63, 0x80, 0xC6, 0x01,
  0x8C, 0x03, 0x10, 0x04, 0x60, 0x08, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4,
  0x01, 0x18, 0x02, 0x30, 0x0C, 0x40, 0x18, 0x80, 0x33, 0x00, 0x46, 0x00,
  0x8C, 0x03, 0x10, 0x06, 0x20, 0x08, 0x00, 0x06, 0x0C, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x81,
  0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x00, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x03, 0x04, 0x06, 0x04, 0x0C, 0x0C,
  0x18, 0x0C, 0x10, 0x0C, 0x30, 0x08, 0x60, 0x08, 0xC0, 0x19, 0x80, 0x1B,
  0x80, 0x13, 0x80, 0x14, 0x80, 0x18, 0x80, 0x30, 0xC0, 0x30, 0xC0, 0x20,
  0x40, 0x20, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x40, 0x30, 0xC0,
  0x30, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x00,
  0x08, 0xF8, 0x7C, 0x09, 0x9C, 0xCE, 0x0A, 0x0D, 0x83, 0x1C, 0x07, 0x03,
  0x1C, 0x06, 0x03, 0x18, 0x06, 0x03, 0x18, 0x0C, 0x03, 0x10, 0x0C, 0x02,
  0x30, 0x0C, 0x02, 0x30, 0x08, 0x06, 0x30, 0x08, 0x06, 0x20, 0x18, 0x06,
  0x20, 0x18, 0x04, 0x60, 0x18, 0x04, 0x60, 0x10, 0x0C, 0x40, 0x10, 0x0C,
  0x40, 0x30, 0x0C, 0xC0, 0x30, 0x08, 0xC0, 0x20, 0x08, 0xC0, 0x20, 0x18,
  0x80, 0x60, 0x18, 0x80, 0x60, 0x10, 0x04, 0x7C, 0x04, 0xEE, 0x05, 0x03,
  0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x02, 0x18, 0x02,
  0x18, 0x06, 0x10, 0x06, 0x10, 0x06, 0x30, 0x04, 0x30, 0x04, 0x30, 0x0C,
  0x20, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x60, 0x08, 0x60, 0x18, 0x40, 0x18,
  0xC0, 0x10, 0x01, 0xF0, 0x07, 0x38, 0x18, 0x30, 0x60, 0x31, 0x80, 0x62,
  0x00, 0xCC, 0x00, 0x98, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1A, 0x00,
  0x34, 0x00, 0x48, 0x00, 0xB0, 0x03, 0x60, 0x04, 0xC0, 0x18, 0x80, 0x31,
  0x00, 0xC3, 0x03, 0x03, 0x0C, 0x03, 0xF0, 0x00, 0x02, 0x3E, 0x00, 0x99,
  0xC0, 0x2C, 0x18, 0x1E, 0x02, 0x07, 0x00, 0x81, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x06, 0x08,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x02, 0x0E, 0x01,
  0x83, 0x80, 0x40, 0xE0, 0x30, 0x24, 0x38, 0x09, 0xF8, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF1, 0x03, 0x99, 0x06, 0x0D,
  0x0C, 0x07, 0x18, 0x07, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0x40, 0x38, 0x40, 0x78, 0x60, 0x50, 0x71, 0x90,
  0x3F, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x08, 0xF0,
  0x9D, 0x0A, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x03, 0xF0, 0x71, 0xC6, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x88, 0x18, 0x7F, 0x80, 0x06, 0x02, 0x01, 0x01, 0x80,
  0xC1, 0xFD, 0xFE, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x1E, 0x00, 0x08, 0x03, 0x08, 0x02, 0x18, 0x02, 0x18, 0x02, 0x18, 0x06,
  0x10, 0x06, 0x10, 0x04, 0x30, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C,
  0x20, 0x08, 0x60, 0x08, 0x60, 0x18, 0x60, 0x18, 0x40, 0x18, 0x40, 0x30,
  0xC0, 0x30, 0xC0, 0x50, 0x40, 0xF0, 0x61, 0xA0, 0x3F, 0x20, 0xC0, 0x0E,
  0x00, 0xF0, 0x05, 0x80, 0x6C, 0x02, 0x20, 0x31, 0x01, 0x08, 0x18, 0x40,
  0x82, 0x0C, 0x10, 0x60, 0x86, 0x04, 0x30, 0x23, 0x01, 0x18, 0x08, 0x80,
  0x6C, 0x03, 0x40, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x30,
  0x0F, 0x00, 0xC0, 0x2C, 0x07, 0x01, 0xB0, 0x14, 0x04, 0x40, 0x50, 0x31,
  0x03, 0x40, 0x84, 0x09, 0x06, 0x10, 0x64, 0x18, 0x41, 0x10, 0x41, 0x0C,
  0x43, 0x04, 0x21, 0x08, 0x11, 0x84, 0x60, 0x46, 0x11, 0x81, 0x10, 0x44,
  0x04, 0xC1, 0x30, 0x12, 0x04, 0x80, 0x58, 0x16, 0x01, 0x40, 0x50, 0x07,
  0x01, 0x40, 0x18, 0x07, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x81, 0x00, 0xC0, 0x80, 0xC0, 0x60, 0xC0, 0x30, 0x40, 0x08, 0x60,
  0x04, 0x60, 0x03, 0x20, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1B, 0x00, 0x09, 0x80, 0x0C, 0x40, 0x0C, 0x30, 0x0C,
  0x18, 0x04, 0x04, 0x06, 0x02, 0x06, 0x01, 0x86, 0x00, 0xC0, 0x00, 0x80,
  0x18, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x40, 0x0C, 0x06, 0x00,
  0x60, 0x20, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x01,
  0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x01, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x0F, 0x00, 0x00, 0x7E, 0x03, 0x87, 0x0E, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 9, 10, 12, 4, -29 },
  { 42, 19, 29, 18, 0, -29 },
  { 111, 17, 33, 17, 0, -31 },
  { 182, 21, 30, 25, 2, -30 },
  { 261, 17, 30, 18, 0, -30 },
  { 325, 4, 10, 7, 4, -29 },
  { 330, 12, 35, 10, 1, -29 },
  { 383, 12, 35, 10, -3, -29 },
  { 436, 12, 13, 16, 5, -31 },
  { 456, 15, 19, 19, 2, -24 },
  { 492, 6, 9, 7, -2, -4 },
  { 499, 9, 2, 11, 1, -12 },
  { 502, 2, 3, 7, 1, -3 },
  { 503, 18, 29, 13, -2, -29 },
  { 569, 16, 30, 17, 1, -30 },
  { 629, 9, 29, 17, 5, -29 },
  { 662, 17, 30, 17, -1, -30 },
  { 726, 17, 30, 17, 0, -30 },
  { 790, 17, 30, 17, 0, -30 },
  { 854, 17, 29, 17, 0, -29 },
  { 916, 16, 30, 17, 1, -30 },
  { 976, 16, 29, 17, 2, -29 },
  { 1034, 17, 30, 17, 0, -30 },
  { 1098, 16, 30, 17, 0, -30 },
  { 1158, 7, 22, 7, 0, -22 },
  { 1178, 9, 27, 7, -2, -22 },
  { 1209, 15, 17, 19, 2, -23 },
  { 1241, 15, 10, 19, 2, -19 },
  { 1260, 15, 17, 19, 2, -23 },
  { 1292, 13, 30, 12, 1, -30 },
  { 1341, 24, 33, 25, 1, -29 },
  { 1440, 17, 29, 17, -3, -29 },
  { 1502, 17, 29, 18, 1, -29 },
  { 1564, 18, 30, 17, 2, -30 },
  { 1632, 18, 29, 20, 1, -29 },
  { 1698, 17, 29, 16, 1, -29 },
  { 1760, 17, 29, 15, 1, -29 },
  { 1822, 20, 30, 22, 2, -30 },
  { 1897, 21, 29, 21, 1, -29 },
  { 1974, 13, 29, 9, -2, -29 },
  { 2022, 14, 36, 8, -6, -29 },
  { 2085, 19, 29, 17, 1, -29 },
  { 2154, 11, 29, 15, 1, -29 },
  { 2194, 27, 29, 27, 1, -29 },
  { 2292, 21, 29, 22, 1, -29 },
  { 2369, 19, 30, 22, 2, -30 },
  { 2441, 17, 29, 17, 1, -29 },
  { 2503, 19, 37, 22, 2, -30 },
  { 2591, 17, 29, 18, 1, -29 },
  { 2653, 18, 30, 16, -1, -30 },
  { 2721, 14, 29, 15, 4, -29 },
  { 2772, 20, 29, 21, 2, -29 },
  { 2845, 16, 29, 17, 4, -29 },
  { 2903, 27, 29, 28, 4, -29 },
  { 3001, 20, 29, 15, -2, -29 },
  { 3074, 14, 29, 15, 4, -29 },
  { 3125, 19, 29, 16, -1, -29 },
  { 3194, 15, 35, 12, -1, -29 },
  { 3260, 6, 29, 13, 4, -29 },
  { 3282, 15, 35, 12, -3, -29 },
  { 3348, 16, 15, 18, 1, -29 },
  { 3378, 12, 1, 12, -3, 4 },
  { 3380, 4, 6, 9, 6, -31 },
  { 3383, 16, 22, 18, 1, -22 },
  { 3427, 16, 31, 18, 1, -31 },
  { 3489, 13, 22, 14, 1, -22 },
  { 3525, 18, 31, 18, 1, -31 },
  { 3595, 14, 22, 16, 1, -22 },
  { 3634, 19, 41, 9, -5, -31 },
  { 3732, 17, 32, 18, 0, -22 },
  { 3800, 15, 31, 17, 1, -31 },
  { 3859, 7, 29, 7, 1, -29 },
  { 3885, 15, 39, 7, -6, -29 },
  { 3959, 16, 31, 14, 0, -31 },
  { 4021, 9, 31, 7, 0, -31 },
  { 4056, 24, 22, 26, 1, -22 },
  { 4122, 16, 22, 17, 0, -22 },
  { 4166, 15, 22, 18, 1, -22 },
  { 4208, 18, 31, 18, -1, -22 },
  { 4278, 16, 32, 18, 1, -22 },
  { 4342, 12, 22, 12, 1, -22 },
  { 4375, 13, 22, 13, 0, -22 },
  { 4411, 9, 27, 9, 1, -27 },
  { 4442, 16, 22, 17, 1, -22 },
  { 4486, 13, 22, 13, 2, -22 },
  { 4522, 22, 22, 22, 2, -22 },
  { 4583, 17, 22, 14, -2, -22 },
  { 4630, 21, 32, 14, -5, -22 },
  { 4714, 14, 22, 12, -1, -22 },
  { 4753, 15, 35, 13, 1, -29 },
  { 4819, 1, 41, 17, 8, -31 },
  { 4825, 14, 35, 13, -2, -29 },
  { 4887, 15, 3, 19, 2, -16 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC41PT7B_H_
