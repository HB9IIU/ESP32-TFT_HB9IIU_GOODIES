#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xE0, 0x37, 0x67, 0xAA, 0x27, 0x44, 0x66, 0xC4, 0x8D,
  0xEF, 0xDB, 0xA0, 0x25, 0x64, 0xBA, 0xE0, 0xC0, 0x6A, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x00, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00,
  0x25, 0x99, 0x9A, 0xE0, 0xD6, 0xA0, 0x61, 0x12, 0x24, 0xE0, 0x61, 0x16,
  0x22, 0xE0, 0x35, 0x6A, 0x62, 0x74, 0x62, 0x2E, 0x34, 0x46, 0x9A, 0xE0,
  0xE9, 0x49, 0x00, 0x25, 0x56, 0xAA, 0xE0, 0x25, 0x99, 0x72, 0xC0, 0x40,
  0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x44, 0xA4, 0x20, 0x7A,
  0xEF, 0xBF, 0xC1, 0x80, 0x13, 0x33, 0x59, 0x75, 0x69, 0x9E, 0x34, 0x48,
  0x88, 0x60, 0x75, 0x59, 0x9E, 0x74, 0x68, 0x8E, 0x74, 0x68, 0x88, 0x3A,
  0x11, 0x09, 0x49, 0xC0, 0x4A, 0x5D, 0x29, 0x48, 0x69, 0x49, 0x00, 0x24,
  0xA4, 0x94, 0x56, 0x4A, 0xAA, 0x49, 0x49, 0xC0, 0x45, 0x14, 0xAD, 0xAA,
  0xA0, 0x4A, 0x5B, 0x6B, 0x48, 0x32, 0x53, 0x18, 0xCB, 0xC0, 0x75, 0x5A,
  0x88, 0x32, 0x53, 0x18, 0xCB, 0x44, 0x20, 0x75, 0x5A, 0xAA, 0x34, 0x84,
  0x22, 0xE0, 0xF2, 0x49, 0x00, 0x4A, 0x65, 0x29, 0x70, 0xB7, 0x69, 0x00,
  0xA7, 0xAE, 0xAC, 0x92, 0x80, 0x29, 0x88, 0x45, 0x48, 0xBA, 0x49, 0x00,
  0x72, 0x44, 0x8E, 0x69, 0x49, 0x30, 0xFC, 0x31, 0x22, 0x22, 0xE0, 0x65,
  0x90, 0xE0, 0xC0, 0x79, 0x9A, 0xE0, 0x44, 0x75, 0x99, 0xE0, 0x72, 0x4C,
  0x11, 0x79, 0x9A, 0xE0, 0x77, 0x4E, 0x32, 0x62, 0x44, 0x44, 0x80, 0x79,
  0x9A, 0xE2, 0xE0, 0x49, 0xBB, 0x68, 0x56, 0xA0, 0x24, 0xA4, 0x94, 0x44,
  0x56, 0x4A, 0xA0, 0x55, 0xA8, 0x7A, 0xEB, 0x5A, 0x80, 0x6E, 0xDA, 0x69,
  0x99, 0xE0, 0x75, 0x99, 0xE8, 0x80, 0x79, 0x9A, 0xE2, 0x20, 0x6A, 0x48,
  0x71, 0x1C, 0x5A, 0xA0, 0x59, 0x9A, 0xE0, 0xB6, 0xA8, 0xDD, 0xDA, 0xA0,
  0xA9, 0x6A, 0x4A, 0x94, 0xC2, 0x23, 0x00, 0x65, 0x4C, 0x29, 0x45, 0x30,
  0xFF, 0x80, 0x32, 0x21, 0x22, 0xC0, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 4, 7, 5, 1, -7 },
  { 15, 4, 7, 4, 0, -7 },
  { 19, 1, 2, 1, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 4, 1, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 2, 6, 4, 1, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 3, 6, 4, 1, -6 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 2, 5, 2, 0, -5 },
  { 73, 2, 6, 2, 0, -5 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 4, 2, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 3, 7, 3, 0, -7 },
  { 83, 5, 7, 6, 0, -6 },
  { 88, 4, 6, 4, -1, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 7, 4, 0, -7 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 4, 6, 3, 0, -6 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 3, 6, 2, 0, -6 },
  { 119, 3, 8, 2, -1, -6 },
  { 122, 4, 6, 4, 0, -6 },
  { 125, 3, 6, 3, 0, -6 },
  { 128, 6, 6, 6, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 5, 9, 5, 0, -7 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 4, 7, 4, 0, -7 },
  { 158, 3, 6, 3, 1, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 3, 6, 4, 1, -6 },
  { 168, 6, 6, 6, 1, -6 },
  { 173, 5, 6, 3, -1, -6 },
  { 177, 3, 6, 3, 1, -6 },
  { 180, 4, 6, 3, 0, -6 },
  { 183, 3, 7, 3, 0, -6 },
  { 186, 1, 6, 3, 1, -6 },
  { 187, 4, 7, 3, -1, -6 },
  { 191, 4, 3, 4, 0, -6 },
  { 193, 3, 1, 3, -1, 0 },
  { 194, 1, 2, 2, 1, -7 },
  { 195, 4, 5, 4, 0, -5 },
  { 198, 4, 7, 4, 0, -7 },
  { 202, 3, 5, 3, 0, -5 },
  { 204, 4, 7, 4, 0, -7 },
  { 208, 3, 5, 3, 0, -5 },
  { 210, 4, 9, 2, -1, -7 },
  { 215, 4, 7, 4, 0, -5 },
  { 219, 3, 7, 4, 0, -7 },
  { 222, 2, 6, 2, 0, -6 },
  { 224, 3, 8, 2, -1, -6 },
  { 227, 4, 7, 3, 0, -7 },
  { 231, 2, 7, 2, 0, -7 },
  { 233, 5, 5, 6, 0, -5 },
  { 237, 3, 5, 4, 0, -5 },
  { 239, 4, 5, 4, 0, -5 },
  { 242, 4, 7, 4, 0, -5 },
  { 246, 4, 7, 4, 0, -5 },
  { 250, 3, 5, 3, 0, -5 },
  { 252, 3, 5, 3, 0, -5 },
  { 254, 2, 6, 2, 0, -6 },
  { 256, 4, 5, 4, 0, -5 },
  { 259, 3, 5, 3, 0, -5 },
  { 261, 4, 5, 5, 1, -5 },
  { 264, 3, 5, 3, 0, -5 },
  { 266, 5, 7, 3, -1, -5 },
  { 271, 3, 5, 3, 0, -5 },
  { 273, 3, 7, 3, 0, -6 },
  { 276, 1, 9, 4, 1, -7 },
  { 278, 4, 7, 3, -1, -6 },
  { 282, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC9PT7B_H_
