#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x84,
  0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x66, 0x89, 0x12, 0x24, 0x48, 0xA2,
  0x44, 0x00, 0x8C, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x10, 0x08, 0x41,
  0xFF, 0xC9, 0x08, 0x04, 0x20, 0x10, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40,
  0x21, 0x0F, 0xFF, 0x04, 0x20, 0x10, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40,
  0x62, 0x01, 0x08, 0x00, 0x00, 0x40, 0x02, 0x00, 0x20, 0x07, 0xE0, 0xC9,
  0x84, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x02, 0x40, 0x1A, 0x00,
  0x60, 0x01, 0xC0, 0x0B, 0x00, 0x48, 0x04, 0x60, 0x23, 0x01, 0x10, 0x08,
  0x80, 0x4C, 0x75, 0xC0, 0x70, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x1E,
  0x06, 0x22, 0x0C, 0x62, 0x08, 0x42, 0x10, 0x42, 0x10, 0x82, 0x20, 0x82,
  0x20, 0x82, 0x40, 0x84, 0xC4, 0x84, 0x9E, 0x85, 0x22, 0x89, 0x23, 0xF2,
  0x43, 0x02, 0x42, 0x04, 0x42, 0x0C, 0x82, 0x08, 0x82, 0x18, 0x86, 0x10,
  0x84, 0x20, 0x84, 0x20, 0x88, 0x40, 0x70, 0x03, 0xE0, 0x31, 0x01, 0x08,
  0x08, 0x40, 0xC2, 0x06, 0x10, 0x31, 0x00, 0x98, 0x05, 0x80, 0x38, 0x01,
  0x80, 0x34, 0x03, 0x30, 0x90, 0x8D, 0x06, 0x48, 0x12, 0xC0, 0xA4, 0x07,
  0x20, 0x11, 0x81, 0xC4, 0x12, 0x3F, 0x18, 0x6D, 0x24, 0xA4, 0x01, 0x81,
  0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x08, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x20, 0x20, 0x00,
  0x08, 0x06, 0x02, 0x11, 0x06, 0x88, 0xFC, 0x60, 0x48, 0xC4, 0x41, 0x00,
  0x80, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F,
  0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x32, 0x26,
  0x48, 0x80, 0xFE, 0xE0, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x00, 0x07, 0xC0, 0xC2, 0x08, 0x21, 0x02, 0x10, 0x32,
  0x03, 0x20, 0x26, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x68,
  0x04, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x08, 0x81, 0x0C, 0x10, 0x42, 0x07,
  0xC0, 0x0C, 0x72, 0x73, 0x88, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x21, 0x84, 0x10, 0x43, 0x00, 0x03, 0xF0, 0x20, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x40, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x03, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x08, 0x18, 0x7F, 0x00, 0x00, 0x38, 0x01, 0x80, 0x14, 0x01,
  0x20, 0x0B, 0x00, 0x90, 0x08, 0x80, 0x44, 0x04, 0x20, 0x42, 0x06, 0x10,
  0x20, 0x82, 0x04, 0x30, 0x61, 0x02, 0x10, 0x10, 0xFF, 0xF0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF8, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x08, 0x10, 0x7F, 0x00, 0x01, 0xF0, 0x60, 0x0C, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x63, 0x05, 0xD8, 0x60, 0x46, 0x04,
  0xC0, 0x4C, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x8C, 0x18,
  0x43, 0x03, 0xE0, 0x7F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x03, 0xE0, 0x60, 0x82, 0x06, 0x10, 0x11, 0x80, 0x8C, 0x0C, 0x20, 0x41,
  0x06, 0x0C, 0x60, 0x34, 0x01, 0xC0, 0x1B, 0x03, 0x0C, 0x30, 0x21, 0x01,
  0x98, 0x04, 0x80, 0x24, 0x01, 0x20, 0x18, 0x80, 0x86, 0x08, 0x1F, 0x80,
  0x07, 0xE0, 0xC3, 0x08, 0x11, 0x01, 0x10, 0x13, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x03, 0x30, 0x31, 0x07, 0x1F, 0xA0, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x08, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x04, 0x10, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x21, 0x04, 0x20, 0x80,
  0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x08, 0x00, 0x3F, 0x10, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0x84, 0x00, 0x23, 0x07, 0x8C, 0x82,
  0x23, 0x21, 0x08, 0xD0, 0x84, 0x24, 0x21, 0x09, 0x10, 0x42, 0xC4, 0x10,
  0xA1, 0x08, 0x68, 0x42, 0x12, 0x11, 0x84, 0x84, 0x62, 0x21, 0xE7, 0x08,
  0x30, 0x82, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x61,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x03, 0x80, 0x14, 0x00, 0xA0, 0x09,
  0x00, 0x48, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x81, 0x84, 0x08, 0x20,
  0xC1, 0x07, 0xF8, 0x60, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80,
  0x34, 0x01, 0xE0, 0x0C, 0x0F, 0xE0, 0x41, 0x82, 0x06, 0x30, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x62, 0x02, 0x30, 0x21, 0x06, 0x0F, 0xC0, 0x41, 0x82,
  0x06, 0x30, 0x11, 0x00, 0x88, 0x04, 0x40, 0x26, 0x03, 0x20, 0x11, 0x01,
  0x88, 0x38, 0x7F, 0x00, 0x03, 0xF8, 0x30, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x08, 0x30, 0x10, 0x30, 0x60, 0x20,
  0x80, 0x41, 0x00, 0xC2, 0x01, 0x84, 0x03, 0x18, 0x06, 0x20, 0x0C, 0x40,
  0x10, 0x80, 0x23, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x10,
  0xC0, 0x61, 0x01, 0x82, 0x06, 0x04, 0x38, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0xFE, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x07, 0xF8, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x0C, 0x08, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x07, 0xC8, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x31,
  0x00, 0x42, 0x00, 0x82, 0x01, 0x06, 0x02, 0x07, 0xF8, 0x00, 0x04, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x0C, 0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02,
  0x08, 0x02, 0x18, 0x06, 0x10, 0x04, 0x1F, 0xFC, 0x10, 0x04, 0x30, 0x04,
  0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x60, 0x18, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x0F, 0xC0, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x3E, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x83, 0xE0, 0x00,
  0x04, 0x06, 0x08, 0x18, 0x10, 0x20, 0x60, 0x80, 0x82, 0x01, 0x0C, 0x02,
  0x30, 0x04, 0xC0, 0x1B, 0x00, 0x24, 0x00, 0x58, 0x00, 0xD8, 0x03, 0x10,
  0x04, 0x20, 0x08, 0x60, 0x10, 0x40, 0x20, 0x80, 0xC1, 0x81, 0x01, 0x02,
  0x02, 0x04, 0x04, 0x18, 0x0C, 0x00, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x07, 0xFC, 0x06, 0x00, 0x18, 0x30, 0x01,
  0xC1, 0x80, 0x0C, 0x1C, 0x00, 0xA0, 0xA0, 0x05, 0x05, 0x00, 0x58, 0x28,
  0x02, 0x81, 0x60, 0x24, 0x1B, 0x01, 0x20, 0x88, 0x11, 0x04, 0x40, 0x98,
  0x22, 0x08, 0x83, 0x10, 0x44, 0x10, 0x84, 0x20, 0x84, 0x21, 0x04, 0x22,
  0x18, 0x21, 0x10, 0x83, 0x09, 0x04, 0x10, 0x48, 0x20, 0x83, 0x81, 0x04,
  0x1C, 0x18, 0x60, 0x40, 0x80, 0x06, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x41,
  0xC0, 0x20, 0x90, 0x10, 0x48, 0x08, 0x24, 0x08, 0x12, 0x04, 0x18, 0x82,
  0x08, 0x41, 0x04, 0x21, 0x82, 0x10, 0x83, 0x04, 0x41, 0x02, 0x20, 0x81,
  0x10, 0x40, 0x98, 0x20, 0x28, 0x30, 0x14, 0x10, 0x0A, 0x08, 0x05, 0x04,
  0x03, 0x86, 0x00, 0x80, 0x03, 0xF8, 0x0C, 0x18, 0x30, 0x10, 0x40, 0x21,
  0x00, 0x62, 0x00, 0x48, 0x00, 0x90, 0x03, 0x60, 0x06, 0x80, 0x0D, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0xB0, 0x02, 0x60, 0x04, 0x40, 0x18,
  0x80, 0x21, 0x00, 0xC3, 0x03, 0x02, 0x0C, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x20, 0x81, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x18,
  0x18, 0x80, 0x84, 0x08, 0x23, 0x83, 0xF0, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x00, 0x03, 0xF8,
  0x0C, 0x18, 0x30, 0x10, 0x40, 0x21, 0x00, 0x62, 0x00, 0x48, 0x00, 0x90,
  0x03, 0x60, 0x06, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01,
  0xB0, 0x02, 0x60, 0x04, 0x40, 0x18, 0x80, 0x21, 0x00, 0xC3, 0x03, 0x02,
  0x0C, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0xE0, 0x20, 0x81, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x01, 0x18, 0x18, 0x81, 0x84, 0x18, 0x3F, 0x83, 0x10, 0x10, 0xC0,
  0x82, 0x04, 0x10, 0x20, 0x83, 0x06, 0x10, 0x30, 0x80, 0x84, 0x04, 0x60,
  0x30, 0x07, 0xF8, 0x60, 0x46, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x08, 0x18, 0x7F,
  0x00, 0xFF, 0xE1, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x08, 0x02, 0x10, 0x04,
  0x60, 0x08, 0x80, 0x31, 0x00, 0x42, 0x00, 0x84, 0x01, 0x18, 0x06, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x46, 0x01, 0x88, 0x02, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x31, 0x80, 0x41, 0x00, 0x82, 0x02, 0x06, 0x0C, 0x07,
  0xE0, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48, 0x0C, 0x80,
  0x88, 0x18, 0x81, 0x08, 0x10, 0x82, 0x08, 0x20, 0x84, 0x08, 0x40, 0x88,
  0x08, 0x80, 0xD8, 0x0D, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xA0, 0x28, 0x0A, 0x06, 0x80, 0xA0, 0x48,
  0x12, 0x04, 0x81, 0x20, 0x88, 0x32, 0x08, 0x82, 0x21, 0x88, 0x22, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x20, 0x88, 0x22, 0x08, 0x82, 0x60, 0x98, 0x24,
  0x09, 0x02, 0xC0, 0x90, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x02, 0x03, 0x02, 0x06, 0x02, 0x04,
  0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x04, 0x40,
  0x0C, 0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x60, 0x20, 0x20, 0x40, 0x20,
  0xC0, 0x20, 0x80, 0x70, 0x0A, 0x02, 0x40, 0xCC, 0x10, 0x86, 0x10, 0x82,
  0x20, 0x44, 0x09, 0x01, 0x60, 0x38, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0xFF, 0x00,
  0x03, 0xF0, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xFC, 0x00, 0x84, 0x10, 0x84, 0x21, 0x08, 0x61, 0x08,
  0x42, 0x10, 0x82, 0x10, 0x84, 0x21, 0x0C, 0x07, 0xE0, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xF0, 0x00, 0x03, 0x00, 0x30,
  0x05, 0x80, 0x48, 0x08, 0x81, 0x84, 0x10, 0x42, 0x06, 0x20, 0x24, 0x02,
  0x40, 0x18, 0x01, 0xFF, 0x80, 0x93, 0x22, 0x03, 0x00, 0xCD, 0x18, 0x53,
  0x02, 0x20, 0x26, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x4C, 0x04, 0x80, 0x48,
  0x0C, 0x80, 0xC8, 0x18, 0xC1, 0x84, 0x28, 0x7C, 0x80, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x18, 0x0B, 0x70,
  0xE0, 0x86, 0x04, 0x30, 0x31, 0x01, 0x88, 0x08, 0xC0, 0x44, 0x02, 0x20,
  0x11, 0x01, 0x88, 0x08, 0xC0, 0x46, 0x06, 0x30, 0x21, 0xC2, 0x13, 0xE0,
  0x03, 0x83, 0x91, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x3E, 0x00, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0xC4,
  0x0C, 0xD0, 0x61, 0x43, 0x03, 0x08, 0x08, 0x60, 0x21, 0x00, 0x84, 0x02,
  0x30, 0x18, 0xC0, 0x42, 0x01, 0x08, 0x0C, 0x20, 0x30, 0x81, 0x83, 0x06,
  0x04, 0x28, 0x1F, 0x20, 0x03, 0x03, 0x31, 0x84, 0xC1, 0x20, 0x58, 0x14,
  0x09, 0x0C, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x04,
  0x3F, 0x00, 0x00, 0x0C, 0x00, 0x64, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0xF0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0x80, 0x33, 0x43, 0x0A, 0x30, 0x31, 0x01, 0x18, 0x08, 0x80,
  0x44, 0x02, 0x60, 0x33, 0x01, 0x10, 0x08, 0x80, 0xC4, 0x06, 0x20, 0x61,
  0x83, 0x04, 0x28, 0x3E, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x82, 0x0C, 0x1F, 0xC0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x8C, 0x0B, 0x71, 0xC1, 0x18, 0x11, 0x81, 0x10, 0x11,
  0x03, 0x30, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x66, 0x04, 0x40, 0x44,
  0x04, 0x40, 0xCC, 0x08, 0x04, 0x10, 0x00, 0x00, 0x00, 0x86, 0x10, 0x41,
  0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x43, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0xF0, 0x00, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x81, 0x08, 0x21,
  0x84, 0x10, 0xC1, 0x18, 0x11, 0x01, 0x20, 0x36, 0x02, 0xA0, 0x32, 0x02,
  0x20, 0x23, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x8C, 0x08, 0x06, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x60, 0x00, 0xC3, 0x81, 0x4C, 0xD8,
  0x50, 0xA1, 0x8C, 0x18, 0x11, 0x83, 0x02, 0x20, 0x40, 0xC4, 0x08, 0x11,
  0x81, 0x02, 0x20, 0x60, 0x44, 0x08, 0x08, 0x81, 0x03, 0x10, 0x20, 0x46,
  0x04, 0x08, 0x81, 0x81, 0x10, 0x20, 0x62, 0x04, 0x08, 0xC0, 0x81, 0x00,
  0x00, 0xC0, 0xB7, 0x14, 0x11, 0x81, 0x18, 0x11, 0x01, 0x10, 0x33, 0x02,
  0x20, 0x22, 0x02, 0x20, 0x22, 0x04, 0x60, 0x44, 0x04, 0x40, 0x44, 0x0C,
  0xC0, 0x80, 0x03, 0x01, 0x98, 0x61, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0A,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0x40, 0x28, 0x05, 0x01, 0x30, 0x62, 0x18,
  0x3E, 0x00, 0x00, 0x60, 0x16, 0xE0, 0xE0, 0x83, 0x82, 0x0C, 0x0C, 0x20,
  0x30, 0x80, 0xC6, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x04, 0x30,
  0x10, 0xC0, 0xC3, 0x02, 0x0E, 0x10, 0x2F, 0x81, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0x00, 0xCD, 0x18,
  0x53, 0x03, 0x20, 0x26, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x04, 0x80,
  0x48, 0x0C, 0x80, 0xC8, 0x1C, 0xC1, 0x84, 0x28, 0x7C, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x00, 0xC2, 0xD1, 0x40,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x07, 0x06, 0x73, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x32, 0x08, 0xFC, 0x00, 0x08, 0x20, 0x40, 0x87, 0xE4, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x07, 0x80, 0x10, 0x33,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x66, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44,
  0x0C, 0xC0, 0x88, 0x08, 0x81, 0x88, 0x18, 0xC2, 0x87, 0xD0, 0x80, 0xE0,
  0x68, 0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0x88, 0x22, 0x09, 0x02,
  0x40, 0xA0, 0x28, 0x0E, 0x03, 0x00, 0x81, 0x83, 0x81, 0x82, 0x82, 0x86,
  0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88, 0x98, 0x98, 0x90,
  0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x80, 0x08, 0x18, 0x41, 0x02, 0x18, 0x08, 0x80, 0x48, 0x02, 0xC0,
  0x14, 0x00, 0x40, 0x06, 0x00, 0x78, 0x02, 0x40, 0x22, 0x02, 0x10, 0x30,
  0xC1, 0x02, 0x10, 0x10, 0x04, 0x06, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40,
  0x60, 0x80, 0xC2, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80, 0x09,
  0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x3C, 0x00, 0x60,
  0x00, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x07, 0xF8, 0x01,
  0xE0, 0x60, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x03, 0x01, 0x80, 0x08, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x0E, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x10, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x40, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x06, 0x03, 0x80, 0x00, 0x7C, 0x18, 0x3F,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 7, 8, 9, 3, -22 },
  { 25, 14, 22, 14, 0, -22 },
  { 64, 13, 26, 13, 0, -24 },
  { 107, 16, 22, 19, 2, -22 },
  { 151, 13, 22, 14, 0, -22 },
  { 187, 3, 8, 5, 3, -22 },
  { 190, 9, 27, 8, 1, -22 },
  { 221, 9, 27, 8, -2, -22 },
  { 252, 9, 11, 12, 4, -24 },
  { 265, 12, 14, 14, 1, -18 },
  { 286, 4, 7, 5, -1, -3 },
  { 290, 7, 1, 9, 1, -9 },
  { 291, 2, 2, 6, 1, -2 },
  { 292, 13, 22, 9, -1, -22 },
  { 328, 12, 22, 13, 1, -22 },
  { 361, 6, 22, 13, 4, -22 },
  { 378, 13, 22, 13, -1, -22 },
  { 414, 13, 22, 13, 0, -22 },
  { 450, 13, 22, 13, 0, -22 },
  { 486, 13, 22, 13, 0, -22 },
  { 522, 12, 22, 13, 1, -22 },
  { 555, 12, 22, 13, 2, -22 },
  { 588, 13, 22, 13, 0, -22 },
  { 624, 12, 22, 13, 0, -22 },
  { 657, 5, 17, 6, 0, -17 },
  { 668, 6, 21, 6, -1, -17 },
  { 684, 12, 14, 14, 1, -18 },
  { 705, 12, 8, 14, 1, -15 },
  { 717, 12, 14, 14, 1, -18 },
  { 738, 9, 22, 9, 1, -22 },
  { 763, 18, 25, 19, 1, -22 },
  { 820, 13, 22, 13, -2, -22 },
  { 856, 13, 22, 14, 1, -22 },
  { 892, 13, 22, 13, 2, -22 },
  { 928, 15, 22, 15, 0, -22 },
  { 970, 14, 22, 12, 0, -22 },
  { 1009, 14, 22, 11, 0, -22 },
  { 1048, 15, 22, 16, 2, -22 },
  { 1090, 16, 22, 16, 0, -22 },
  { 1134, 10, 22, 7, -1, -22 },
  { 1162, 11, 27, 6, -5, -22 },
  { 1200, 15, 22, 13, 0, -22 },
  { 1242, 9, 22, 11, 0, -22 },
  { 1267, 21, 22, 21, 0, -22 },
  { 1325, 17, 22, 17, 0, -22 },
  { 1372, 15, 22, 17, 1, -22 },
  { 1414, 13, 22, 13, 0, -22 },
  { 1450, 15, 27, 17, 1, -22 },
  { 1501, 13, 22, 13, 0, -22 },
  { 1537, 13, 22, 12, 0, -22 },
  { 1573, 11, 22, 11, 3, -22 },
  { 1604, 15, 22, 16, 1, -22 },
  { 1646, 12, 22, 13, 3, -22 },
  { 1679, 20, 22, 21, 3, -22 },
  { 1734, 16, 22, 12, -2, -22 },
  { 1778, 11, 22, 11, 3, -22 },
  { 1809, 14, 22, 12, -1, -22 },
  { 1848, 12, 27, 9, -1, -22 },
  { 1889, 5, 22, 10, 3, -22 },
  { 1903, 11, 27, 9, -2, -22 },
  { 1941, 12, 12, 14, 1, -22 },
  { 1959, 9, 1, 9, -2, 3 },
  { 1961, 3, 5, 7, 5, -24 },
  { 1963, 12, 17, 14, 1, -17 },
  { 1989, 13, 24, 14, 0, -24 },
  { 2028, 10, 17, 10, 1, -17 },
  { 2050, 14, 24, 14, 1, -24 },
  { 2092, 10, 17, 12, 1, -17 },
  { 2114, 15, 31, 7, -4, -24 },
  { 2173, 13, 24, 14, 0, -17 },
  { 2212, 12, 24, 13, 0, -24 },
  { 2248, 6, 22, 6, 0, -22 },
  { 2265, 10, 29, 6, -4, -22 },
  { 2302, 12, 24, 11, 0, -24 },
  { 2338, 7, 24, 5, 0, -24 },
  { 2359, 19, 17, 20, 0, -17 },
  { 2400, 12, 17, 13, 0, -17 },
  { 2426, 11, 17, 13, 1, -17 },
  { 2450, 14, 24, 14, -1, -17 },
  { 2492, 12, 24, 14, 1, -17 },
  { 2528, 10, 17, 9, 0, -17 },
  { 2550, 10, 17, 10, 0, -17 },
  { 2572, 7, 20, 7, 1, -20 },
  { 2590, 12, 16, 13, 1, -16 },
  { 2614, 10, 16, 10, 2, -16 },
  { 2634, 16, 16, 17, 2, -16 },
  { 2666, 13, 16, 11, -1, -16 },
  { 2692, 15, 24, 11, -3, -16 },
  { 2737, 11, 16, 9, -1, -16 },
  { 2759, 11, 27, 10, 1, -22 },
  { 2797, 1, 32, 13, 6, -24 },
  { 2801, 11, 27, 10, -2, -22 },
  { 2839, 12, 2, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC31PT7B_H_
