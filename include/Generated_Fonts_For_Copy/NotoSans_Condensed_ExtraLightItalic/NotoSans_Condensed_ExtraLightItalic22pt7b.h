#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x80, 0x01, 0x18, 0x4A,
  0x52, 0xA9, 0x48, 0x04, 0x41, 0x20, 0x48, 0x22, 0x08, 0x8F, 0xF1, 0x10,
  0x44, 0x12, 0x04, 0x8F, 0xF8, 0x90, 0x24, 0x11, 0x04, 0x41, 0x20, 0x02,
  0x01, 0x03, 0xC2, 0x92, 0x41, 0x20, 0x90, 0x28, 0x18, 0x06, 0x02, 0x81,
  0x40, 0x90, 0x90, 0x49, 0xF8, 0x10, 0x10, 0x00, 0x18, 0x24, 0x89, 0x11,
  0x22, 0x44, 0x51, 0x12, 0x22, 0x94, 0x55, 0x95, 0x2C, 0xA4, 0x28, 0x89,
  0x11, 0x22, 0x44, 0x48, 0x92, 0x1C, 0x06, 0x04, 0x84, 0x42, 0x21, 0x10,
  0x90, 0x50, 0x10, 0x38, 0x12, 0x51, 0x30, 0xA8, 0x34, 0x12, 0x14, 0xF2,
  0x55, 0xA0, 0x04, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x0C, 0x00, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x43, 0x00, 0x10, 0x49,
  0x1F, 0x21, 0x48, 0x80, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08,
  0x08, 0x08, 0x25, 0x28, 0xF0, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x0E, 0x11, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x88, 0x70, 0x13, 0x59, 0x22, 0x22, 0x24, 0x44, 0x44, 0x88,
  0x0F, 0x08, 0x80, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x01, 0xFC, 0x0F, 0x08, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x3C, 0x06, 0x01, 0x00, 0x40, 0x20, 0x20, 0x10, 0x11, 0xF0,
  0x00, 0x80, 0xC0, 0xC0, 0xA0, 0x50, 0x48, 0x44, 0x24, 0x22, 0x21, 0x10,
  0x9F, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x0F, 0x88, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x7C, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x11, 0xF0,
  0x07, 0x18, 0x20, 0x20, 0x40, 0x40, 0x58, 0xA6, 0xC2, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x78, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0F, 0x08,
  0x44, 0x24, 0x12, 0x08, 0x88, 0x4C, 0x18, 0x14, 0x31, 0x10, 0x50, 0x28,
  0x14, 0x09, 0x08, 0xF8, 0x0E, 0x08, 0x88, 0x24, 0x12, 0x0A, 0x05, 0x02,
  0x82, 0x23, 0x0E, 0x80, 0x40, 0x40, 0x20, 0x20, 0x31, 0xE0, 0x13, 0x00,
  0x00, 0x00, 0x00, 0x48, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84,
  0x22, 0x00, 0x01, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0x04,
  0x18, 0x60, 0x80, 0x39, 0x10, 0x41, 0x04, 0x10, 0x84, 0x21, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x03, 0xC0, 0xC2, 0x10, 0x12, 0x01, 0x20, 0x14, 0x79,
  0x48, 0x98, 0x89, 0x91, 0x19, 0x11, 0x91, 0x29, 0x32, 0x97, 0x48, 0x88,
  0x80, 0x08, 0x00, 0x40, 0x03, 0xE0, 0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50,
  0x48, 0x24, 0x22, 0x11, 0x0F, 0x88, 0x44, 0x24, 0x12, 0x0A, 0x03, 0x01,
  0x0F, 0x04, 0x21, 0x04, 0x41, 0x10, 0x48, 0x22, 0x08, 0xFC, 0x21, 0x08,
  0x44, 0x09, 0x02, 0x41, 0x10, 0x44, 0x23, 0xF0, 0x07, 0xC2, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x00, 0xF0, 0x0F, 0x04, 0x21, 0x04, 0x41, 0x10, 0x48, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x02, 0x40, 0x90, 0x44, 0x63, 0xE0,
  0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0xFC, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0xF0, 0x0F, 0xC4, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x3F, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x07, 0xC1, 0x04, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x83, 0xD0, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x10,
  0x41, 0xF8, 0x08, 0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x22, 0x02, 0x20,
  0x43, 0xFC, 0x20, 0x42, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x08, 0x40,
  0x88, 0x10, 0x1E, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x78, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xE0,
  0x08, 0x22, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48, 0x09, 0x01, 0x40, 0x38,
  0x04, 0x81, 0x10, 0x22, 0x04, 0x20, 0x84, 0x10, 0x84, 0x08, 0x08, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x3F, 0x08, 0x06,
  0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x45, 0x02, 0x8A, 0x09, 0x12,
  0x14, 0x24, 0x48, 0x48, 0x91, 0x12, 0x22, 0x24, 0x44, 0x51, 0x08, 0xA2,
  0x11, 0x84, 0x43, 0x08, 0x08, 0x11, 0x81, 0x18, 0x11, 0x42, 0x14, 0x22,
  0x42, 0x24, 0x22, 0x22, 0x22, 0x42, 0x24, 0x42, 0x44, 0x14, 0x41, 0x84,
  0x18, 0x41, 0x88, 0x08, 0x07, 0x06, 0x22, 0x04, 0x81, 0x40, 0x50, 0x14,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x44, 0x20, 0xF0,
  0x0F, 0x04, 0x21, 0x08, 0x41, 0x10, 0x48, 0x22, 0x08, 0x84, 0x26, 0x0E,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x07, 0x06, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80,
  0xA0, 0x44, 0x21, 0xF0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x0F, 0x08, 0x44,
  0x22, 0x11, 0x09, 0x04, 0x82, 0x42, 0x3E, 0x12, 0x11, 0x08, 0x84, 0x22,
  0x11, 0x09, 0x06, 0x0F, 0x88, 0x48, 0x04, 0x02, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x11, 0xF0, 0xFF, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x20, 0x24, 0x08, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x22, 0x04,
  0x40, 0x88, 0x12, 0x04, 0x40, 0x88, 0x11, 0x04, 0x20, 0x83, 0xE0, 0x80,
  0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x08, 0x88, 0x44, 0x24, 0x12,
  0x0A, 0x05, 0x01, 0x00, 0x80, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x42,
  0x85, 0x0A, 0x14, 0x48, 0x91, 0x22, 0x44, 0x91, 0x22, 0x44, 0x89, 0x14,
  0x28, 0x50, 0xA1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x08, 0x21, 0x08,
  0x22, 0x04, 0x40, 0x90, 0x12, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x48,
  0x09, 0x02, 0x20, 0x84, 0x10, 0x84, 0x08, 0x81, 0x82, 0x82, 0x84, 0x88,
  0x48, 0x50, 0x50, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0F,
  0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x03, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0xF0, 0x92, 0x24, 0x92, 0x44, 0x92, 0x49, 0x1F, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0xF0, 0x08, 0x0C, 0x14, 0x14, 0x22, 0x42, 0x41, 0x81, 0x81,
  0xFE, 0x89, 0x10, 0x1D, 0x23, 0x41, 0x41, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x8C, 0x74, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0xB8, 0xA4, 0x61,
  0x20, 0x90, 0x48, 0x28, 0x14, 0x12, 0x09, 0x05, 0x84, 0xBC, 0x00, 0x1E,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0xC0, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0xE8, 0x8C, 0x82, 0x41, 0x40, 0xA0, 0x90, 0x48,
  0x24, 0x12, 0x11, 0x18, 0x74, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x53, 0x38,
  0x40, 0x81, 0x02, 0x03, 0xC0, 0x00, 0xE0, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x1F, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x01, 0xC0, 0x00,
  0x0E, 0x88, 0xC8, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x43, 0x21, 0x11,
  0x87, 0x40, 0x20, 0x10, 0x10, 0x08, 0xF8, 0x00, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xB8, 0xA4, 0x61, 0x21, 0x10, 0x88, 0x48, 0x24, 0x12, 0x11,
  0x09, 0x04, 0x82, 0x00, 0x18, 0x80, 0x01, 0x10, 0x84, 0x21, 0x10, 0x84,
  0x22, 0x10, 0x01, 0x02, 0x00, 0x00, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x8C, 0x84, 0x44, 0x24, 0x14, 0x0E, 0x0D,
  0x04, 0x82, 0x21, 0x11, 0x08, 0x84, 0x00, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x08, 0x84, 0x21, 0x10, 0x80, 0x16, 0x39, 0xCA, 0x4C, 0x62, 0x42,
  0x12, 0x10, 0x90, 0x85, 0x04, 0x28, 0x42, 0x42, 0x12, 0x10, 0xA0, 0x85,
  0x08, 0x20, 0x17, 0x14, 0x8C, 0x24, 0x22, 0x11, 0x09, 0x04, 0x82, 0x42,
  0x21, 0x20, 0x90, 0x40, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x78, 0x0B, 0x85, 0x21, 0x84, 0x41, 0x10, 0x44, 0x12,
  0x04, 0x82, 0x20, 0x88, 0x26, 0x11, 0x78, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x00, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x8C, 0x74, 0x04, 0x04, 0x08, 0x08, 0x08, 0x16, 0x50, 0xC1, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x1C, 0x45, 0x02, 0x02, 0x06, 0x06,
  0x04, 0x04, 0x08, 0x27, 0xC0, 0x21, 0x3E, 0x84, 0x21, 0x10, 0x84, 0x21,
  0x08, 0x60, 0x21, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84,
  0x8C, 0xF4, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA0, 0xC1, 0x02,
  0x00, 0x82, 0x18, 0x62, 0x86, 0x28, 0xA4, 0x8A, 0x49, 0x24, 0x92, 0x8A,
  0x28, 0xA3, 0x0A, 0x30, 0xC2, 0x0C, 0x20, 0x10, 0x88, 0x84, 0x41, 0x40,
  0xC0, 0x60, 0x20, 0x28, 0x24, 0x12, 0x10, 0x90, 0x40, 0x10, 0x22, 0x08,
  0x21, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0xE0, 0x00, 0x1F, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x06, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x21, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x08, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x0C, 0x10, 0x40, 0x82, 0x04, 0x08, 0x10, 0x43, 0x80, 0x71, 0x8F,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 6, 2, -16 },
  { 15, 10, 16, 10, 0, -16 },
  { 35, 9, 18, 9, 0, -17 },
  { 56, 11, 16, 13, 1, -16 },
  { 78, 9, 16, 10, 0, -16 },
  { 96, 2, 6, 4, 2, -16 },
  { 98, 6, 19, 5, 1, -16 },
  { 113, 7, 19, 5, -2, -16 },
  { 130, 6, 7, 9, 3, -17 },
  { 136, 8, 10, 10, 1, -13 },
  { 146, 3, 5, 4, -1, -2 },
  { 148, 4, 1, 6, 1, -6 },
  { 149, 2, 2, 4, 0, -2 },
  { 150, 9, 16, 7, -1, -16 },
  { 168, 8, 16, 9, 1, -16 },
  { 184, 4, 16, 9, 3, -16 },
  { 192, 9, 16, 9, 0, -16 },
  { 210, 9, 16, 9, 0, -16 },
  { 228, 9, 16, 9, 0, -16 },
  { 246, 9, 16, 9, 0, -16 },
  { 264, 8, 16, 9, 1, -16 },
  { 280, 9, 16, 9, 1, -16 },
  { 298, 9, 16, 9, 0, -16 },
  { 316, 9, 16, 9, 0, -16 },
  { 334, 4, 12, 4, 0, -12 },
  { 340, 5, 15, 4, -1, -12 },
  { 350, 8, 10, 10, 1, -13 },
  { 360, 8, 5, 10, 1, -10 },
  { 365, 8, 10, 10, 1, -13 },
  { 375, 6, 16, 7, 1, -16 },
  { 387, 12, 18, 14, 1, -16 },
  { 414, 9, 16, 9, -1, -16 },
  { 432, 10, 16, 10, 0, -16 },
  { 452, 10, 16, 9, 1, -16 },
  { 472, 10, 16, 11, 0, -16 },
  { 492, 10, 16, 9, 0, -16 },
  { 512, 10, 16, 8, 0, -16 },
  { 532, 11, 16, 12, 1, -16 },
  { 554, 12, 16, 11, 0, -16 },
  { 578, 7, 16, 5, -1, -16 },
  { 592, 8, 20, 4, -3, -16 },
  { 612, 11, 16, 9, 0, -16 },
  { 634, 6, 16, 8, 0, -16 },
  { 646, 15, 16, 15, 0, -16 },
  { 676, 12, 16, 12, 0, -16 },
  { 700, 10, 16, 12, 1, -16 },
  { 720, 10, 16, 9, 0, -16 },
  { 740, 10, 20, 12, 1, -16 },
  { 765, 9, 16, 9, 0, -16 },
  { 783, 9, 16, 9, 0, -16 },
  { 801, 8, 16, 8, 2, -16 },
  { 817, 11, 16, 11, 1, -16 },
  { 839, 9, 16, 9, 2, -16 },
  { 857, 14, 16, 15, 2, -16 },
  { 885, 11, 16, 8, -1, -16 },
  { 907, 8, 16, 8, 2, -16 },
  { 923, 10, 16, 8, -1, -16 },
  { 943, 8, 19, 6, 0, -16 },
  { 962, 3, 16, 7, 2, -16 },
  { 968, 8, 19, 6, -1, -16 },
  { 987, 8, 9, 10, 1, -16 },
  { 996, 7, 1, 7, -2, 2 },
  { 997, 3, 4, 5, 3, -17 },
  { 999, 8, 12, 10, 1, -12 },
  { 1011, 9, 17, 10, 0, -17 },
  { 1031, 7, 12, 7, 1, -12 },
  { 1042, 9, 17, 10, 1, -17 },
  { 1062, 7, 12, 8, 1, -12 },
  { 1073, 11, 22, 5, -3, -17 },
  { 1104, 9, 17, 10, 0, -12 },
  { 1124, 9, 17, 9, 0, -17 },
  { 1144, 5, 16, 4, 0, -16 },
  { 1154, 8, 21, 4, -3, -16 },
  { 1175, 9, 17, 8, 0, -17 },
  { 1195, 5, 17, 4, 0, -17 },
  { 1206, 13, 12, 14, 0, -12 },
  { 1226, 9, 12, 9, 0, -12 },
  { 1240, 8, 12, 9, 1, -12 },
  { 1252, 10, 17, 10, -1, -12 },
  { 1274, 8, 17, 10, 1, -12 },
  { 1291, 7, 12, 6, 0, -12 },
  { 1302, 7, 12, 7, 0, -12 },
  { 1313, 5, 14, 5, 1, -14 },
  { 1322, 8, 12, 9, 1, -12 },
  { 1334, 7, 12, 7, 1, -12 },
  { 1345, 12, 12, 12, 1, -12 },
  { 1363, 9, 12, 8, -1, -12 },
  { 1377, 11, 17, 7, -2, -12 },
  { 1401, 8, 12, 7, -1, -12 },
  { 1413, 7, 19, 7, 1, -16 },
  { 1430, 1, 22, 9, 4, -17 },
  { 1433, 7, 19, 7, -1, -16 },
  { 1450, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC22PT7B_H_
