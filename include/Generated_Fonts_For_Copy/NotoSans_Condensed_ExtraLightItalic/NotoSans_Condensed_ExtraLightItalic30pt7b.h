#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x00, 0x00, 0x20, 0x80, 0x66, 0x89, 0x12, 0x24, 0x91, 0x22, 0x00,
  0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08, 0x83, 0xFF,
  0xC1, 0x08, 0x04, 0x20, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x83, 0xFF,
  0xC1, 0x08, 0x04, 0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x10, 0x80, 0x42,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x80, 0x7F, 0x08, 0x91, 0x90, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x90, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x38, 0x02, 0xC0,
  0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x88, 0xEB, 0x03, 0xC0, 0x08, 0x00,
  0x80, 0x10, 0x00, 0x0C, 0x00, 0x6C, 0x18, 0x88, 0x22, 0x10, 0x84, 0x21,
  0x18, 0x44, 0x20, 0x88, 0x43, 0x20, 0x84, 0x81, 0x09, 0x3A, 0x34, 0x8C,
  0x4A, 0x19, 0x24, 0x2C, 0x48, 0x41, 0x20, 0x86, 0x41, 0x08, 0x84, 0x21,
  0x08, 0x42, 0x11, 0x04, 0x42, 0x08, 0x88, 0x1E, 0x00, 0x01, 0x80, 0x13,
  0x01, 0x08, 0x08, 0x40, 0x82, 0x04, 0x30, 0x21, 0x01, 0x18, 0x05, 0x80,
  0x38, 0x01, 0x80, 0x14, 0x01, 0x20, 0x90, 0x89, 0x04, 0x48, 0x34, 0x80,
  0xA4, 0x06, 0x20, 0x31, 0x81, 0x84, 0x36, 0x3F, 0x10, 0x69, 0x25, 0x20,
  0x03, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x06, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10,
  0x30, 0x20, 0x40, 0x80, 0x08, 0x04, 0x02, 0x19, 0x02, 0xB8, 0xE0, 0xA0,
  0x88, 0x84, 0x03, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x32, 0x24, 0x48, 0x80, 0xFC, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x00, 0x03, 0x80, 0xD8, 0x21, 0x88, 0x11, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x40, 0x28, 0x05, 0x01, 0xA0, 0x2C, 0x05, 0x00, 0xA0, 0x14,
  0x04, 0x80, 0x90, 0x32, 0x04, 0x41, 0x84, 0x60, 0xF8, 0x00, 0x0C, 0xF6,
  0xA2, 0x08, 0x21, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x10, 0xC0, 0x00, 0xC0, 0x39, 0x81, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x7F, 0xE0, 0x03, 0xC1, 0xE6, 0x08, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x0C, 0x0F, 0x80, 0x38, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x81, 0x0F, 0xE0, 0x00,
  0x10, 0x03, 0x00, 0x50, 0x0E, 0x00, 0xA0, 0x12, 0x03, 0x20, 0x22, 0x04,
  0x40, 0xC4, 0x08, 0x41, 0x04, 0x20, 0xC2, 0x08, 0x40, 0x88, 0x08, 0xFF,
  0xE0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x07, 0xF0, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x3F, 0x01, 0x18, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x88, 0x30, 0xFE, 0x00, 0x00, 0xE0, 0x31, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0xF8, 0x50, 0x86, 0x04, 0xC0, 0x4C,
  0x04, 0x80, 0x48, 0x04, 0x80, 0xC8, 0x08, 0x80, 0x8C, 0x10, 0x43, 0x03,
  0xE0, 0x7F, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x00, 0x01, 0xC0, 0x66, 0x08, 0x10, 0x81,
  0x10, 0x11, 0x01, 0x10, 0x10, 0x83, 0x08, 0x60, 0x4C, 0x03, 0x00, 0xD0,
  0x10, 0x82, 0x0C, 0x40, 0x4C, 0x04, 0x80, 0x68, 0x04, 0x80, 0x4C, 0x04,
  0x60, 0x83, 0xF0, 0x01, 0x80, 0x66, 0x08, 0x21, 0x81, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x03, 0x20, 0x33, 0x06, 0x19, 0xA0, 0xE2,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x06, 0x0F, 0xC0,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0x04, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x08, 0x41, 0x08,
  0x20, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x10, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x00, 0x0E, 0x19, 0x80, 0x60, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x00,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xFC, 0x01, 0x01, 0x81, 0x00, 0x41,
  0x00, 0x31, 0x00, 0x08, 0x80, 0x04, 0x83, 0xE2, 0x42, 0x21, 0x42, 0x10,
  0xA1, 0x08, 0x51, 0x04, 0x30, 0x84, 0x28, 0x42, 0x14, 0x41, 0x0A, 0x21,
  0x89, 0x18, 0xC4, 0x85, 0xA4, 0x41, 0x8C, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x63, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x11, 0x03, 0x10, 0x21, 0x06,
  0x10, 0x41, 0x0C, 0x10, 0xFF, 0x08, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20,
  0x16, 0x01, 0x40, 0x1C, 0x01, 0x0F, 0xE0, 0x83, 0x18, 0x11, 0x01, 0x10,
  0x11, 0x01, 0x10, 0x12, 0x02, 0x20, 0x63, 0xF8, 0x21, 0x86, 0x04, 0x40,
  0x64, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x48, 0x04, 0x80, 0x88, 0x30, 0xFE,
  0x00, 0x00, 0xF0, 0x0E, 0x30, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x10, 0x60, 0xC0, 0x82, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x4C,
  0x03, 0x20, 0x08, 0x80, 0x22, 0x01, 0x88, 0x04, 0x60, 0x31, 0x01, 0x84,
  0x0C, 0x10, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0xFF, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF0, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x1C, 0x18, 0x08, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x07, 0xC4, 0x00, 0x88, 0x01, 0x30, 0x02, 0x60, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x43, 0x01, 0x83, 0x02, 0x03, 0xFC, 0x00, 0x04, 0x01, 0x04,
  0x02, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x1F, 0xFC, 0x10, 0x0C, 0x30, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x30, 0xC0, 0x20, 0x0F, 0x81, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x0F, 0x80, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x1F, 0x00, 0x04, 0x06, 0x08, 0x10, 0x30, 0x40, 0x41, 0x00, 0x86,
  0x01, 0x18, 0x02, 0x60, 0x08, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x68, 0x01,
  0x98, 0x02, 0x10, 0x04, 0x20, 0x08, 0x60, 0x10, 0x40, 0x60, 0x80, 0x81,
  0x01, 0x01, 0x02, 0x02, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x0F, 0xF8, 0x06, 0x00, 0x30, 0x60, 0x07,
  0x0A, 0x00, 0x70, 0xA0, 0x0E, 0x0A, 0x00, 0xA0, 0xA0, 0x1A, 0x0A, 0x01,
  0x21, 0x20, 0x36, 0x12, 0x02, 0x41, 0x20, 0x64, 0x13, 0x04, 0x43, 0x10,
  0xC4, 0x21, 0x08, 0x82, 0x11, 0x88, 0x21, 0x10, 0x82, 0x12, 0x08, 0x61,
  0x21, 0x84, 0x14, 0x10, 0x41, 0x41, 0x04, 0x18, 0x10, 0xC1, 0x81, 0x00,
  0x06, 0x01, 0x06, 0x01, 0x0A, 0x01, 0x0A, 0x03, 0x0B, 0x02, 0x09, 0x02,
  0x09, 0x02, 0x11, 0x02, 0x11, 0x84, 0x10, 0x84, 0x10, 0x84, 0x30, 0x84,
  0x20, 0xCC, 0x20, 0x48, 0x20, 0x48, 0x20, 0x48, 0x60, 0x68, 0x40, 0x38,
  0x40, 0x30, 0x40, 0x30, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0xE0, 0x40, 0x82,
  0x01, 0x18, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x60, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x40, 0x0D, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x11,
  0x00, 0x44, 0x02, 0x10, 0x18, 0x20, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x20,
  0x83, 0x06, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x22, 0x02, 0x10, 0x10,
  0x81, 0x04, 0x30, 0x7F, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0xE0,
  0x40, 0x82, 0x01, 0x18, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x60, 0x05,
  0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x0D, 0x00, 0x2C, 0x00, 0xB0, 0x06,
  0xC0, 0x11, 0x00, 0x44, 0x02, 0x10, 0x18, 0x20, 0xC0, 0x7C, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x20, 0x83,
  0x06, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x62, 0x02, 0x10, 0x30, 0x81,
  0x07, 0xF0, 0x7E, 0x02, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10, 0x60, 0x82,
  0x04, 0x10, 0x30, 0x80, 0x8C, 0x04, 0x00, 0x01, 0xE0, 0x31, 0xC2, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x08, 0x10, 0x7F, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x08, 0x06,
  0x30, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x8C, 0x02, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02,
  0x10, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x80, 0xC1, 0x01, 0x03, 0x04, 0x03,
  0xF0, 0x00, 0x80, 0x38, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81,
  0x88, 0x10, 0x83, 0x08, 0x20, 0x86, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88,
  0x09, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x00, 0x80, 0x40,
  0x30, 0x18, 0x0E, 0x03, 0x01, 0x40, 0x60, 0x28, 0x14, 0x09, 0x02, 0x81,
  0x20, 0x90, 0x64, 0x12, 0x08, 0x86, 0x41, 0x10, 0x88, 0x42, 0x11, 0x08,
  0x44, 0x22, 0x08, 0x84, 0x41, 0x20, 0x98, 0x24, 0x12, 0x05, 0x82, 0x40,
  0xA0, 0x50, 0x14, 0x0A, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x31, 0x00, 0x26, 0x00,
  0x48, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28,
  0x00, 0x98, 0x03, 0x10, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x81, 0x02,
  0x03, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x28, 0x1A, 0x04, 0x83, 0x10, 0x84,
  0x41, 0x10, 0x48, 0x16, 0x05, 0x01, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x07, 0xC1, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x3E, 0x00, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22,
  0x23, 0x11, 0x11, 0x10, 0x07, 0xE0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x1F, 0x00, 0x03, 0x00, 0x50, 0x05, 0x00, 0x88, 0x08, 0x81,
  0x0C, 0x30, 0x42, 0x04, 0x40, 0x24, 0x02, 0x80, 0x30, 0xFF, 0x80, 0xC4,
  0x62, 0x10, 0x07, 0x91, 0x8E, 0x10, 0x62, 0x06, 0x60, 0x64, 0x06, 0x40,
  0x4C, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x08, 0x81, 0x88, 0x18, 0x42,
  0x87, 0xD0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xBE, 0x1E, 0x21, 0x41, 0x18, 0x11, 0x01, 0x10, 0x13, 0x01, 0x20,
  0x12, 0x03, 0x20, 0x22, 0x02, 0x60, 0x66, 0x04, 0x60, 0xC6, 0x18, 0x9F,
  0x00, 0x07, 0xC6, 0x01, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0xF8, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0xF2, 0x18, 0x70,
  0x83, 0x08, 0x18, 0xC0, 0x44, 0x06, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x06, 0x20, 0x21, 0x03, 0x08, 0x18, 0x21, 0x41, 0xF2, 0x00, 0x07,
  0x86, 0x31, 0x04, 0x81, 0x60, 0xD0, 0x24, 0x13, 0x78, 0xE0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x10, 0xFC, 0x00, 0x1C, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x03, 0x80, 0x00,
  0x03, 0xC8, 0x61, 0x42, 0x0C, 0x20, 0x63, 0x01, 0x10, 0x18, 0x80, 0x8C,
  0x04, 0x40, 0x22, 0x03, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x20, 0x60, 0x85,
  0x07, 0xD8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x41, 0x03,
  0xF0, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xBE, 0x1C, 0x21, 0x83, 0x18, 0x31, 0x02, 0x10, 0x23, 0x02, 0x20,
  0x22, 0x06, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC4, 0x08, 0xC0,
  0x80, 0x04, 0x30, 0x40, 0x00, 0x00, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x43, 0x00, 0x00, 0x40, 0x10, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0x18, 0x61, 0x0C, 0x11, 0x81,
  0x10, 0x12, 0x02, 0x40, 0x2C, 0x03, 0x20, 0x32, 0x02, 0x20, 0x43, 0x04,
  0x10, 0x41, 0x04, 0x10, 0xC1, 0x80, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x84, 0x10, 0x41, 0x0C, 0x00,
  0x0B, 0xC7, 0x85, 0x0A, 0x11, 0x83, 0x04, 0x60, 0xC1, 0x10, 0x20, 0x44,
  0x08, 0x13, 0x06, 0x0C, 0x81, 0x02, 0x20, 0x40, 0x88, 0x10, 0x22, 0x04,
  0x09, 0x03, 0x06, 0x40, 0x81, 0x10, 0x20, 0x44, 0x08, 0x13, 0x06, 0x0C,
  0x0B, 0xE1, 0x42, 0x18, 0x31, 0x83, 0x10, 0x21, 0x02, 0x30, 0x22, 0x02,
  0x20, 0x62, 0x04, 0x20, 0x44, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x8C, 0x08,
  0x07, 0x83, 0x08, 0x41, 0x10, 0x36, 0x02, 0x80, 0x50, 0x0E, 0x03, 0x80,
  0x50, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x82, 0x10, 0xC1, 0xF0, 0x04, 0xF0,
  0x58, 0x82, 0x82, 0x18, 0x10, 0x80, 0x84, 0x04, 0x60, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x84, 0x04, 0x60, 0x23, 0x02, 0x18, 0x30, 0xC3, 0x0D, 0xF0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x07, 0x91, 0x85, 0x10, 0x62, 0x06, 0x60, 0x24, 0x06, 0x40, 0x44, 0x04,
  0x80, 0x48, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x88, 0x18, 0x42, 0x87, 0xD8,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x0B,
  0xC5, 0x81, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x0F, 0x84, 0x12, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00,
  0x88, 0x23, 0xF0, 0x08, 0x20, 0x40, 0x87, 0xE4, 0x08, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x07, 0x80, 0x10, 0x24, 0x04,
  0x80, 0x90, 0x32, 0x04, 0xC0, 0x90, 0x12, 0x02, 0x40, 0x88, 0x13, 0x02,
  0x40, 0xC8, 0x19, 0x06, 0x21, 0xC3, 0xE8, 0x80, 0xC0, 0xE0, 0x50, 0x68,
  0x24, 0x32, 0x11, 0x08, 0x88, 0x44, 0x24, 0x12, 0x0A, 0x05, 0x03, 0x01,
  0x80, 0x81, 0x03, 0x06, 0x06, 0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0xA1,
  0x22, 0x46, 0x44, 0x88, 0x91, 0x11, 0x22, 0x42, 0x44, 0x85, 0x0B, 0x0A,
  0x14, 0x18, 0x28, 0x30, 0x60, 0x40, 0xC0, 0x18, 0x10, 0x82, 0x08, 0x60,
  0x84, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0B, 0x01,
  0x10, 0x21, 0x06, 0x10, 0x40, 0x88, 0x08, 0x04, 0x06, 0x08, 0x08, 0x10,
  0x30, 0x20, 0x40, 0x41, 0x80, 0x82, 0x01, 0x0C, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x07,
  0xF8, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x10, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0E, 0x03, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x30,
  0x18, 0x00, 0x7C, 0x1C, 0x63, 0x81, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 21, 6, 1, -21 },
  { 17, 7, 7, 9, 3, -21 },
  { 24, 14, 21, 14, 0, -21 },
  { 61, 12, 25, 12, 0, -23 },
  { 99, 15, 22, 18, 2, -22 },
  { 141, 13, 22, 13, 0, -22 },
  { 177, 3, 7, 5, 3, -21 },
  { 180, 8, 26, 7, 1, -21 },
  { 206, 8, 26, 7, -2, -21 },
  { 232, 9, 10, 12, 4, -23 },
  { 244, 12, 14, 14, 1, -18 },
  { 265, 4, 7, 5, -1, -3 },
  { 269, 6, 1, 8, 1, -9 },
  { 270, 1, 2, 5, 1, -2 },
  { 271, 12, 21, 9, -1, -21 },
  { 303, 11, 22, 12, 1, -22 },
  { 334, 6, 21, 12, 4, -21 },
  { 350, 13, 22, 12, -1, -22 },
  { 386, 12, 22, 12, 0, -22 },
  { 419, 12, 22, 12, 0, -22 },
  { 452, 12, 21, 12, 0, -21 },
  { 484, 12, 22, 12, 1, -22 },
  { 517, 11, 21, 12, 2, -21 },
  { 546, 12, 22, 12, 0, -22 },
  { 579, 12, 22, 12, 0, -22 },
  { 612, 5, 16, 5, 0, -16 },
  { 622, 6, 20, 5, -1, -16 },
  { 637, 12, 13, 14, 1, -17 },
  { 657, 12, 7, 14, 1, -14 },
  { 668, 12, 13, 14, 1, -17 },
  { 688, 9, 22, 9, 1, -22 },
  { 713, 17, 24, 19, 1, -21 },
  { 764, 12, 22, 12, -2, -22 },
  { 797, 12, 21, 13, 1, -21 },
  { 829, 14, 22, 13, 1, -22 },
  { 868, 14, 21, 15, 0, -21 },
  { 905, 13, 21, 12, 0, -21 },
  { 940, 13, 21, 11, 0, -21 },
  { 975, 15, 22, 16, 1, -22 },
  { 1017, 16, 21, 16, 0, -21 },
  { 1059, 9, 21, 6, -1, -21 },
  { 1083, 11, 26, 6, -5, -21 },
  { 1119, 15, 21, 12, 0, -21 },
  { 1159, 9, 21, 11, 0, -21 },
  { 1183, 20, 21, 20, 0, -21 },
  { 1236, 16, 21, 16, 0, -21 },
  { 1278, 14, 22, 16, 1, -22 },
  { 1317, 13, 21, 13, 0, -21 },
  { 1352, 14, 27, 16, 1, -22 },
  { 1400, 13, 21, 13, 0, -21 },
  { 1435, 13, 22, 12, 0, -22 },
  { 1471, 10, 21, 11, 3, -21 },
  { 1498, 15, 21, 15, 1, -21 },
  { 1538, 12, 21, 12, 3, -21 },
  { 1570, 19, 21, 20, 3, -21 },
  { 1620, 15, 21, 11, -2, -21 },
  { 1660, 10, 21, 11, 3, -21 },
  { 1687, 14, 21, 11, -1, -21 },
  { 1724, 10, 26, 8, 0, -21 },
  { 1757, 4, 21, 10, 3, -21 },
  { 1768, 11, 26, 8, -2, -21 },
  { 1804, 12, 11, 13, 1, -21 },
  { 1821, 9, 1, 9, -2, 3 },
  { 1823, 4, 5, 7, 4, -23 },
  { 1826, 12, 16, 13, 1, -16 },
  { 1850, 12, 23, 13, 0, -23 },
  { 1885, 10, 16, 10, 1, -16 },
  { 1905, 13, 23, 13, 1, -23 },
  { 1943, 10, 16, 12, 1, -16 },
  { 1963, 14, 30, 7, -4, -23 },
  { 2016, 13, 23, 13, 0, -16 },
  { 2054, 12, 23, 13, 0, -23 },
  { 2089, 6, 22, 5, 0, -22 },
  { 2106, 10, 29, 5, -4, -22 },
  { 2143, 12, 23, 11, 0, -23 },
  { 2178, 6, 23, 5, 0, -23 },
  { 2196, 18, 16, 19, 0, -16 },
  { 2232, 12, 16, 13, 0, -16 },
  { 2256, 11, 16, 13, 1, -16 },
  { 2278, 13, 23, 13, -1, -16 },
  { 2316, 12, 23, 13, 1, -16 },
  { 2351, 10, 16, 8, 0, -16 },
  { 2371, 10, 16, 10, 0, -16 },
  { 2391, 7, 20, 7, 1, -20 },
  { 2409, 11, 16, 13, 1, -16 },
  { 2431, 9, 16, 10, 2, -16 },
  { 2449, 15, 16, 16, 2, -16 },
  { 2479, 12, 16, 10, -1, -16 },
  { 2503, 15, 23, 10, -3, -16 },
  { 2547, 11, 16, 9, -1, -16 },
  { 2569, 10, 26, 10, 1, -21 },
  { 2602, 1, 30, 12, 6, -23 },
  { 2606, 11, 26, 10, -2, -21 },
  { 2642, 12, 3, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC30PT7B_H_
