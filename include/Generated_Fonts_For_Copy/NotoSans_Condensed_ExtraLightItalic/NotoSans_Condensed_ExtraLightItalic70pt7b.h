#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0,
  0x61, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x31,
  0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x38, 0xC0,
  0x61, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0C, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x61, 0xF0, 0x07, 0x06, 0x02, 0x00, 0xE0,
  0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xF0, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x38,
  0x08, 0x03, 0x07, 0x00, 0xC0, 0x61, 0xE0, 0x0F, 0xE7, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x07, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x38, 0x03, 0x80, 0x70, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x03,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x07, 0x03, 0x80, 0x06,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0x07, 0x06, 0x00, 0x0E, 0x00, 0x60, 0xE0,
  0x00, 0xE0, 0x0E, 0x0C, 0x02, 0x0E, 0x00, 0xE1, 0xC1, 0xF8, 0xC0, 0x0C,
  0x18, 0x7F, 0xCC, 0x01, 0xC3, 0x8F, 0x0E, 0xC0, 0x1C, 0x70, 0xE0, 0x6E,
  0x03, 0x86, 0x1C, 0x06, 0xE0, 0x38, 0xE1, 0x80, 0x6E, 0x07, 0x0C, 0x38,
  0x07, 0x70, 0xE1, 0xC3, 0x00, 0x77, 0xFC, 0x18, 0x70, 0x07, 0x3F, 0x83,
  0x86, 0x00, 0x60, 0x60, 0x70, 0x60, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x60,
  0x00, 0xE0, 0xC0, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0xC0,
  0x0E, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x0C, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x18, 0x01, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x03, 0x00, 0x70, 0x01, 0x80, 0x70, 0x06, 0x00,
  0x18, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x0C, 0x00, 0x1C, 0x1C, 0x01,
  0xC0, 0x00, 0xFF, 0x80, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x30,
  0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC0,
  0xC0, 0x0C, 0x1C, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x1C, 0x00, 0xE0,
  0x30, 0xC0, 0x07, 0x03, 0x8E, 0x00, 0x18, 0x18, 0x60, 0x00, 0xE1, 0xC7,
  0x00, 0x07, 0x0C, 0x38, 0x00, 0x1C, 0xE1, 0x80, 0x00, 0xE6, 0x0C, 0x00,
  0x03, 0x70, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x3B, 0x81,
  0xC0, 0x03, 0x8C, 0x07, 0x00, 0x38, 0x70, 0x3C, 0x07, 0x83, 0x80, 0xFF,
  0xF8, 0x0C, 0x03, 0xFF, 0x80, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x71,
  0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x60, 0x06, 0x03, 0x80, 0x3E, 0x0C, 0x00, 0x1E, 0x30, 0x00, 0x1C,
  0xC0, 0xE0, 0x1F, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x40,
  0x00, 0x39, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x38, 0x07,
  0x80, 0x60, 0x0C, 0x01, 0xC0, 0x20, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x73, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xD8, 0x3C, 0xE1, 0xE3, 0x8F, 0x0E, 0x70,
  0x33, 0x80, 0xC4, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x20, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x10, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x27, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x33, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x40, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x02, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x70, 0xFF, 0xC0, 0x0C, 0x7F, 0xFC, 0x01, 0x9E,
  0x03, 0xC0, 0x77, 0x00, 0x38, 0x0F, 0xC0, 0x03, 0x81, 0xB0, 0x00, 0x70,
  0x3C, 0x00, 0x06, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x38, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x06,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0xC1,
  0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x36, 0x03, 0x80, 0x0C, 0xC0, 0x3C, 0x07,
  0xB8, 0x03, 0xFF, 0xC7, 0x00, 0x3F, 0xF0, 0xC0, 0x01, 0xF0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0x81,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x0E, 0x01, 0xE0, 0x40, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x03, 0xF0, 0x07, 0x07, 0x00, 0x1F, 0xFC, 0x03, 0x06, 0x00, 0x3E,
  0x3C, 0x03, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x0E, 0x00, 0xE0, 0x18, 0x07,
  0x0C, 0x01, 0xC0, 0x18, 0x07, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x18, 0x03, 0x00, 0x30, 0x07, 0x38, 0x07, 0x00, 0x30,
  0x06, 0x38, 0x06, 0x00, 0x70, 0x06, 0x30, 0x0E, 0x00, 0x60, 0x06, 0x30,
  0x0C, 0x00, 0x60, 0x0E, 0x70, 0x0C, 0x00, 0xE0, 0x0E, 0x70, 0x1C, 0x00,
  0xE0, 0x0C, 0x70, 0x1C, 0x00, 0xC0, 0x0C, 0x60, 0x18, 0x00, 0xC0, 0x1C,
  0x60, 0x18, 0x01, 0xC0, 0x18, 0x60, 0x18, 0x01, 0xC0, 0x38, 0x60, 0x18,
  0x01, 0xC0, 0x30, 0xE0, 0x18, 0x03, 0x80, 0x30, 0xE0, 0x18, 0x03, 0x80,
  0x70, 0xE0, 0x18, 0x07, 0x80, 0xE0, 0xE0, 0x18, 0x0D, 0x80, 0xC0, 0xE0,
  0x1C, 0x0C, 0xC1, 0xC0, 0xE0, 0x1E, 0x38, 0xC3, 0x80, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x60, 0x07, 0xE0, 0x7C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xF0, 0x07,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x38,
  0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x18, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x38, 0x3F, 0xE0, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x30,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0, 0x18, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x30, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x70, 0x03,
  0xE0, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xF8, 0x38, 0x00, 0x0F, 0xFE, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x30, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x08, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x06, 0x7E,
  0x00, 0x00, 0x03, 0x37, 0x00, 0x00, 0x03, 0xB3, 0x80, 0x00, 0x01, 0xF0,
  0xC0, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78,
  0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xD8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0x60, 0x00, 0x00, 0x1B, 0x80, 0x1D, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x30, 0x01, 0x98, 0x00, 0x00, 0x1D, 0xC0, 0x0E,
  0x60, 0x00, 0x00, 0x67, 0x00, 0x39, 0x80, 0x00, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x00, 0x0C, 0x60, 0x03, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x0C, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x00, 0x30, 0xE0, 0x07, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x70, 0x03, 0x83, 0x00, 0x00,
  0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x38, 0x30, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x80, 0x03, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x60, 0x38,
  0x01, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x70, 0x03,
  0x80, 0x60, 0x0E, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x00, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x60, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC1, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x33, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0xDC, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x70, 0x00,
  0xE0, 0x06, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x01, 0xD8, 0x00, 0x01, 0xC0, 0x0E, 0xE0,
  0x00, 0x0E, 0x00, 0x67, 0x00, 0x00, 0x60, 0x03, 0x38, 0x00, 0x07, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x01, 0xC0, 0x0E, 0x38, 0x00,
  0x0C, 0x00, 0x61, 0xC0, 0x00, 0x60, 0x03, 0x06, 0x00, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0x60, 0x38,
  0x01, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x00,
  0xE0, 0xE0, 0x07, 0x00, 0x03, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x38, 0x01,
  0xC0, 0x00, 0xE1, 0x80, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x60, 0x00, 0x18,
  0xE0, 0x07, 0x00, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x07, 0x38, 0x01, 0xC0,
  0x00, 0x39, 0x80, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00,
  0x07, 0x80, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0E, 0x0F, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x0F, 0x00, 0x38,
  0x01, 0xF0, 0x01, 0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0E, 0x0F,
  0xF0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0x60, 0x00, 0xF0, 0x03, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x08, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x73, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x98, 0x00, 0x07, 0x60, 0x00,
  0x38, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x98, 0x00, 0x0C,
  0x30, 0x00, 0x1D, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x0C,
  0x00, 0x0E, 0x70, 0x00, 0x70, 0x60, 0x00, 0x63, 0x80, 0x03, 0x83, 0x00,
  0x07, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x30, 0xE0, 0x01, 0xC0, 0xC0, 0x03,
  0x87, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xC1,
  0xC0, 0x07, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x70,
  0x03, 0x80, 0x60, 0x07, 0x03, 0x80, 0x18, 0x03, 0x00, 0x38, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x0E, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x70, 0x18, 0x00, 0x60,
  0x38, 0x03, 0x81, 0xC0, 0x03, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x18, 0x1C,
  0x00, 0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x70, 0x01, 0xC3, 0x80, 0x01, 0x83, 0x00, 0x0E,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x8E,
  0x00, 0x03, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xE7, 0x00,
  0x00, 0xCE, 0x00, 0x07, 0x30, 0x00, 0x06, 0x70, 0x00, 0x3B, 0x80, 0x00,
  0x33, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCC, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x06,
  0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFE, 0x0C, 0x00, 0xFF, 0xF1, 0x80, 0x3C, 0x0E, 0x30, 0x0F, 0x00, 0xEE,
  0x03, 0x80, 0x0D, 0xC0, 0xE0, 0x00, 0xB0, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78,
  0x18, 0x00, 0x1E, 0x03, 0x80, 0x06, 0xC0, 0x70, 0x00, 0xD8, 0x0E, 0x00,
  0x37, 0x00, 0xE0, 0x0C, 0xC0, 0x1E, 0x07, 0x18, 0x01, 0xFF, 0xC3, 0x00,
  0x1F, 0xF0, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0xC1, 0xFE, 0x00, 0x38, 0xFF, 0xF0, 0x07, 0x3C, 0x0E, 0x00,
  0xEE, 0x00, 0xE0, 0x1B, 0x80, 0x1C, 0x03, 0x60, 0x01, 0xC0, 0xF8, 0x00,
  0x38, 0x1F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x1E,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x03, 0x60, 0x01,
  0xC0, 0x6C, 0x00, 0x78, 0x0C, 0xC0, 0x1E, 0x03, 0x9C, 0x07, 0x80, 0x61,
  0xFF, 0xE0, 0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3C, 0x02, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x0F, 0xF8, 0x70, 0x00, 0x7F, 0xF8, 0xE0, 0x01, 0xE0, 0x39, 0x80,
  0x07, 0x80, 0x33, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0xE0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x06, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0xEC, 0x00, 0x70, 0x01, 0x98, 0x00, 0x70, 0x0E, 0x70, 0x00,
  0xF0, 0x3C, 0xE0, 0x00, 0xFF, 0xE1, 0x80, 0x00, 0xFF, 0x83, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x00, 0xC1,
  0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x01, 0xC6, 0x00,
  0x07, 0x38, 0x00, 0x38, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x78,
  0x60, 0x07, 0xC1, 0x80, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x08, 0x0F, 0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0x10, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0xFF, 0xF1, 0xC0, 0x07, 0x80, 0xE6,
  0x00, 0x3C, 0x01, 0x98, 0x01, 0xC0, 0x07, 0x60, 0x0E, 0x00, 0x0F, 0x80,
  0x38, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x06, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x06,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x7C, 0x01, 0x80, 0x01, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x76,
  0x00, 0x70, 0x03, 0xB8, 0x00, 0xE0, 0x1E, 0xE0, 0x03, 0xC0, 0xF3, 0x80,
  0x07, 0xFF, 0x8C, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x08, 0x00, 0x38, 0x00, 0x38, 0x03, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0xC3, 0xFF, 0x00, 0x71, 0xFF, 0xE0, 0x1C,
  0xE0, 0x38, 0x07, 0x60, 0x07, 0x01, 0xB0, 0x01, 0xC0, 0x7C, 0x00, 0x70,
  0x3E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x30,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x7C, 0x00, 0x03,
  0xBB, 0x00, 0x00, 0xDC, 0xC0, 0x00, 0x36, 0x38, 0x00, 0x1F, 0x0E, 0x00,
  0x07, 0x81, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00,
  0x60, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x61, 0xFF, 0x01, 0xFF,
  0x00, 0x71, 0xFF, 0xC3, 0xFF, 0xC0, 0x33, 0x80, 0xE3, 0xC0, 0xF0, 0x19,
  0x80, 0x39, 0x80, 0x38, 0x0D, 0x80, 0x1D, 0x80, 0x0C, 0x07, 0x80, 0x0F,
  0x80, 0x06, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x81, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x00, 0x03, 0x83, 0x80,
  0x01, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC0, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x38, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x30, 0xFF, 0xC0,
  0x1C, 0x7F, 0xF8, 0x06, 0x38, 0x0E, 0x01, 0x9C, 0x01, 0xC0, 0x6C, 0x00,
  0x70, 0x1F, 0x00, 0x1C, 0x0F, 0x80, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x18,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x38,
  0x00, 0x03, 0x98, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0x8E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x03, 0x8F, 0xFF, 0x00, 0x0C,
  0x78, 0x1C, 0x00, 0x33, 0x80, 0x38, 0x00, 0xDC, 0x00, 0xE0, 0x03, 0x60,
  0x01, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x30, 0x07, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x0F,
  0x80, 0x07, 0x00, 0x36, 0x00, 0x3C, 0x00, 0xCC, 0x01, 0xE0, 0x07, 0x38,
  0x0F, 0x00, 0x1C, 0x7F, 0xF8, 0x00, 0x70, 0xFF, 0x80, 0x01, 0x80, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0x83, 0x00, 0x3F, 0xFC, 0x70, 0x07, 0x81, 0xE6,
  0x00, 0xE0, 0x06, 0x60, 0x1C, 0x00, 0x76, 0x03, 0x80, 0x03, 0xE0, 0x38,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x3C, 0x06, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C, 0x07, 0x00,
  0x0F, 0x80, 0x70, 0x01, 0xD8, 0x07, 0x00, 0x1B, 0x80, 0x38, 0x03, 0xB8,
  0x03, 0xC0, 0xF3, 0x80, 0x1F, 0xFC, 0x30, 0x00, 0xFF, 0x83, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x06, 0x1F,
  0xC0, 0x71, 0xFE, 0x03, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0xDC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0x00, 0xE0, 0x38,
  0x00, 0x40, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x02, 0x00, 0x1C, 0x07, 0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x3F, 0xFF,
  0x3F, 0xFE, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x07,
  0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x3C,
  0x06, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00,
  0x0D, 0x80, 0x60, 0x03, 0x70, 0x0E, 0x00, 0xEE, 0x01, 0xE0, 0x79, 0x80,
  0x1F, 0xFE, 0x30, 0x01, 0xFF, 0x06, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x01, 0x80,
  0x1C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x06,
  0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x6E, 0x00, 0x0F, 0x00, 0x0E, 0xE0,
  0x01, 0xB0, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x1C, 0xE0, 0x03, 0xB0, 0x01,
  0xCE, 0x00, 0x33, 0x00, 0x38, 0xE0, 0x07, 0x30, 0x03, 0x8E, 0x00, 0x63,
  0x00, 0x30, 0xE0, 0x06, 0x30, 0x07, 0x0E, 0x00, 0xE3, 0x00, 0x60, 0xE0,
  0x0C, 0x30, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0xE0, 0xE0, 0x18, 0x30, 0x0C,
  0x0E, 0x03, 0x83, 0x01, 0xC0, 0xE0, 0x30, 0x30, 0x18, 0x0E, 0x07, 0x03,
  0x03, 0x80, 0xE0, 0x60, 0x30, 0x38, 0x0E, 0x06, 0x03, 0x03, 0x00, 0xE0,
  0xE0, 0x30, 0x70, 0x0E, 0x0C, 0x03, 0x06, 0x00, 0xE1, 0xC0, 0x30, 0xE0,
  0x0E, 0x18, 0x03, 0x0C, 0x00, 0xE3, 0x80, 0x30, 0xC0, 0x0E, 0x30, 0x03,
  0x1C, 0x00, 0x63, 0x00, 0x31, 0x80, 0x06, 0x70, 0x03, 0x38, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x06, 0xE0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x37, 0x00,
  0x07, 0xC0, 0x03, 0x60, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x77, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x20,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x10, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x27, 0xFF, 0x00, 0x05, 0xF3, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7F, 0xFD, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 50, 15, 1, -50 },
  { 89, 15, 18, 20, 7, -50 },
  { 123, 32, 50, 32, 1, -50 },
  { 323, 28, 57, 29, 1, -53 },
  { 523, 36, 52, 43, 4, -51 },
  { 757, 29, 52, 31, 0, -51 },
  { 946, 6, 18, 11, 7, -50 },
  { 960, 19, 61, 17, 2, -50 },
  { 1105, 20, 61, 17, -5, -50 },
  { 1258, 22, 23, 27, 8, -53 },
  { 1322, 27, 32, 32, 3, -41 },
  { 1430, 10, 16, 12, -3, -7 },
  { 1450, 15, 2, 19, 2, -20 },
  { 1454, 5, 5, 13, 1, -5 },
  { 1458, 29, 50, 21, -3, -50 },
  { 1640, 26, 52, 29, 2, -51 },
  { 1809, 14, 50, 29, 9, -50 },
  { 1897, 30, 51, 29, -2, -51 },
  { 2089, 29, 52, 29, -1, -51 },
  { 2278, 29, 50, 29, -1, -50 },
  { 2460, 29, 51, 29, 0, -50 },
  { 2645, 27, 52, 29, 3, -51 },
  { 2821, 27, 50, 29, 4, -50 },
  { 2990, 29, 52, 29, 0, -51 },
  { 3179, 27, 52, 29, 1, -51 },
  { 3355, 11, 37, 13, 1, -37 },
  { 3406, 15, 46, 13, -3, -37 },
  { 3493, 27, 30, 32, 3, -40 },
  { 3595, 27, 17, 32, 3, -33 },
  { 3653, 27, 30, 32, 3, -40 },
  { 3755, 21, 51, 21, 2, -51 },
  { 3889, 40, 56, 43, 2, -50 },
  { 4169, 28, 50, 28, -4, -50 },
  { 4344, 30, 50, 31, 1, -50 },
  { 4532, 31, 52, 29, 3, -51 },
  { 4734, 32, 50, 35, 1, -50 },
  { 4934, 30, 50, 28, 1, -50 },
  { 5122, 30, 50, 26, 1, -50 },
  { 5310, 35, 52, 37, 3, -51 },
  { 5538, 36, 50, 36, 1, -50 },
  { 5763, 22, 50, 15, -3, -50 },
  { 5901, 25, 62, 13, -11, -50 },
  { 6095, 33, 50, 29, 1, -50 },
  { 6302, 19, 50, 25, 1, -50 },
  { 6421, 46, 50, 46, 1, -50 },
  { 6709, 37, 50, 37, 1, -50 },
  { 6941, 33, 52, 37, 3, -51 },
  { 7156, 29, 50, 30, 1, -50 },
  { 7338, 33, 63, 37, 3, -51 },
  { 7598, 29, 50, 30, 1, -50 },
  { 7780, 30, 52, 28, -1, -51 },
  { 7975, 25, 50, 25, 6, -50 },
  { 8132, 34, 51, 36, 3, -50 },
  { 8349, 28, 50, 29, 6, -50 },
  { 8524, 45, 50, 47, 7, -50 },
  { 8806, 35, 50, 26, -4, -50 },
  { 9025, 25, 50, 25, 6, -50 },
  { 9182, 32, 50, 27, -2, -50 },
  { 9382, 25, 61, 20, -1, -50 },
  { 9573, 10, 50, 22, 7, -50 },
  { 9636, 26, 61, 20, -5, -50 },
  { 9835, 28, 26, 31, 2, -50 },
  { 9926, 22, 2, 21, -6, 7 },
  { 9932, 8, 11, 15, 10, -53 },
  { 9943, 27, 39, 31, 2, -38 },
  { 10075, 27, 54, 31, 1, -53 },
  { 10258, 22, 39, 23, 3, -38 },
  { 10366, 31, 54, 31, 2, -53 },
  { 10576, 22, 39, 27, 3, -38 },
  { 10684, 33, 71, 15, -9, -54 },
  { 10977, 30, 55, 31, 0, -38 },
  { 11184, 26, 53, 30, 1, -53 },
  { 11357, 13, 50, 13, 1, -50 },
  { 11439, 24, 67, 13, -9, -50 },
  { 11640, 26, 53, 25, 1, -53 },
  { 11813, 14, 53, 12, 1, -53 },
  { 11906, 41, 38, 45, 1, -38 },
  { 12101, 26, 38, 30, 1, -38 },
  { 12225, 25, 39, 30, 2, -38 },
  { 12347, 30, 54, 31, -2, -38 },
  { 12550, 28, 54, 31, 2, -38 },
  { 12739, 21, 38, 20, 1, -38 },
  { 12839, 23, 39, 23, 0, -38 },
  { 12952, 16, 47, 16, 2, -46 },
  { 13046, 27, 38, 30, 2, -37 },
  { 13175, 22, 37, 23, 4, -37 },
  { 13277, 36, 37, 37, 4, -37 },
  { 13444, 29, 37, 24, -3, -37 },
  { 13579, 35, 54, 24, -8, -37 },
  { 13816, 25, 37, 21, -2, -37 },
  { 13932, 24, 61, 22, 2, -50 },
  { 14115, 3, 70, 28, 13, -53 },
  { 14142, 24, 61, 22, -4, -50 },
  { 14325, 27, 7, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC70PT7B_H_
