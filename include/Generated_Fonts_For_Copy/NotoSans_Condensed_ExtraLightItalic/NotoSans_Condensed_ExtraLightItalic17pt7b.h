#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x44, 0x40, 0x08, 0xB6, 0xD0, 0x09, 0x0A, 0x12,
  0x7F, 0x14, 0x24, 0x24, 0xBE, 0x48, 0x48, 0x50, 0x90, 0x04, 0x18, 0xE9,
  0x44, 0x86, 0x04, 0x0C, 0x14, 0x28, 0x97, 0xC2, 0x04, 0x00, 0x71, 0x29,
  0x24, 0x92, 0x89, 0x55, 0x56, 0xD2, 0xA9, 0x28, 0x94, 0x92, 0x48, 0xC0,
  0x1C, 0x48, 0x91, 0x22, 0x82, 0x0C, 0x25, 0x8B, 0x0A, 0x33, 0xA0, 0xF0,
  0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x04, 0x21, 0x00, 0x10, 0x82,
  0x10, 0x84, 0x22, 0x10, 0x88, 0x44, 0x22, 0x00, 0x25, 0x1E, 0xC9, 0x08,
  0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x29, 0x40, 0xF0, 0x80, 0x02, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x39, 0x14, 0x61,
  0x86, 0x18, 0x62, 0x8A, 0x29, 0x38, 0x36, 0xA2, 0x22, 0x44, 0x44, 0x48,
  0x3C, 0x04, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x82, 0x07, 0xC0, 0x3C,
  0x04, 0x08, 0x10, 0x47, 0x02, 0x02, 0x04, 0x08, 0x27, 0x80, 0x02, 0x0C,
  0x30, 0xA1, 0x44, 0x91, 0x44, 0xFC, 0x10, 0x20, 0x40, 0x3E, 0x40, 0x81,
  0x04, 0x0F, 0x01, 0x02, 0x04, 0x08, 0x27, 0x80, 0x1C, 0x84, 0x10, 0xB3,
  0x28, 0xA2, 0x8A, 0x28, 0xBC, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x00, 0x1E, 0x44, 0x89, 0x12, 0x43, 0x0A, 0x22, 0x85,
  0x0A, 0x13, 0xC0, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0x4B, 0x0A, 0x04, 0x10,
  0x27, 0x80, 0x20, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x02, 0x44, 0x80,
  0x04, 0x23, 0x30, 0x40, 0xC0, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0x03, 0x03,
  0x08, 0xC4, 0x20, 0x70, 0x42, 0x21, 0x11, 0x10, 0x80, 0x01, 0x00, 0x1F,
  0x10, 0x50, 0x29, 0xD9, 0x2C, 0xA6, 0x93, 0x49, 0xA5, 0x5F, 0x20, 0x10,
  0x04, 0x01, 0xC0, 0x04, 0x08, 0x28, 0x51, 0x22, 0x48, 0x9F, 0x42, 0x86,
  0x0C, 0x10, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x44, 0x42, 0x42, 0x42,
  0x84, 0xF8, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03,
  0xC0, 0x1E, 0x21, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x84,
  0xF8, 0x1E, 0x40, 0x81, 0x02, 0x07, 0x90, 0x20, 0x40, 0x82, 0x07, 0xC0,
  0x1E, 0x40, 0x81, 0x02, 0x08, 0x1F, 0x20, 0x40, 0x82, 0x04, 0x00, 0x1F,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x82, 0x84, 0x7C, 0x10,
  0x90, 0x48, 0x24, 0x22, 0x11, 0xF9, 0x04, 0x82, 0x42, 0x21, 0x20, 0x90,
  0x40, 0x1C, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x38, 0x02, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x38, 0x00,
  0x11, 0x22, 0x24, 0x28, 0x28, 0x50, 0x70, 0x48, 0x48, 0x48, 0x84, 0x84,
  0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0xF0, 0x10, 0x26, 0x04, 0xC1,
  0x98, 0x53, 0x0A, 0xA2, 0x92, 0x52, 0x52, 0x4A, 0x49, 0x8A, 0x32, 0x44,
  0x40, 0x10, 0x98, 0x4C, 0x25, 0x12, 0x92, 0x49, 0x24, 0x8A, 0x45, 0x23,
  0x20, 0x90, 0x40, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x78, 0x1E, 0x44, 0x89, 0x12, 0x28, 0xDE, 0x20, 0x40, 0x82,
  0x04, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84,
  0x84, 0x78, 0x10, 0x10, 0x08, 0x1E, 0x44, 0x89, 0x12, 0x28, 0x9E, 0x24,
  0x48, 0x92, 0x14, 0x20, 0x3E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x27, 0x80, 0xFC, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0x70,
  0x86, 0x18, 0xA2, 0x92, 0x4A, 0x28, 0xA3, 0x08, 0x20, 0x84, 0x31, 0x8A,
  0x31, 0x4A, 0x49, 0x49, 0x49, 0x29, 0x46, 0x28, 0xC6, 0x10, 0xC2, 0x10,
  0x42, 0x00, 0x11, 0x88, 0x84, 0x81, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x24,
  0x22, 0x11, 0x10, 0x80, 0x86, 0x89, 0x22, 0x45, 0x0C, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x1F, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0xFC, 0x1C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x0E, 0x00, 0xAA, 0xA5, 0x55, 0x1C, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x10, 0xA2, 0x92, 0x86, 0x10, 0xF8,
  0x94, 0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA6, 0xE8, 0x10, 0x40, 0x81, 0x03,
  0xC4, 0x48, 0xA1, 0x42, 0x85, 0x12, 0x2B, 0x80, 0x3A, 0x21, 0x08, 0x42,
  0x10, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xC8, 0xA1, 0x42, 0x89, 0x12, 0x24,
  0xCE, 0x80, 0x3A, 0x63, 0x2E, 0x42, 0x10, 0xF0, 0x07, 0x04, 0x08, 0x08,
  0x1C, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0xC0, 0x1E, 0x45, 0x0A, 0x14, 0x50, 0xA1, 0x26, 0x74, 0x10, 0x20, 0x4F,
  0x00, 0x10, 0x40, 0x81, 0x03, 0xC4, 0x50, 0xA2, 0x44, 0x89, 0x14, 0x28,
  0x80, 0x30, 0x02, 0x24, 0x44, 0x44, 0x88, 0x04, 0x00, 0x02, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x30, 0x10, 0x40, 0x81, 0x02, 0x65,
  0x12, 0x28, 0x70, 0xA1, 0x44, 0x48, 0x80, 0x12, 0x22, 0x22, 0x44, 0x44,
  0x48, 0x80, 0x3D, 0xC8, 0x94, 0x45, 0x11, 0x44, 0x51, 0x14, 0x46, 0x22,
  0x88, 0x80, 0x3C, 0x45, 0x0A, 0x24, 0x48, 0x91, 0x42, 0x88, 0x39, 0x18,
  0x61, 0x86, 0x28, 0xA2, 0xF0, 0x1E, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22,
  0x22, 0x7C, 0x40, 0x40, 0x40, 0x80, 0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA6,
  0xE8, 0x41, 0x04, 0x10, 0x39, 0x10, 0x84, 0x21, 0x10, 0x80, 0x3D, 0x04,
  0x10, 0x20, 0x40, 0x84, 0xF0, 0x22, 0x72, 0x44, 0x44, 0x88, 0xE0, 0x45,
  0x18, 0x62, 0x8A, 0x28, 0xA4, 0xF0, 0x8C, 0x65, 0x2A, 0x53, 0x18, 0x80,
  0x88, 0xCC, 0xA6, 0x55, 0x4A, 0xA5, 0x53, 0x31, 0x18, 0x88, 0x00, 0x22,
  0x28, 0x50, 0xC1, 0x03, 0x0A, 0x24, 0x84, 0x10, 0x88, 0x84, 0x42, 0x41,
  0x20, 0xA0, 0x50, 0x10, 0x08, 0x08, 0x04, 0x04, 0x0C, 0x00, 0x38, 0x44,
  0x22, 0x21, 0x10, 0xF0, 0x0C, 0x41, 0x04, 0x10, 0x82, 0x30, 0x20, 0x84,
  0x10, 0x41, 0x02, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x10, 0x41, 0x08, 0x20, 0x8C, 0x00, 0xE6, 0x70,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 3, 4, 5, 2, -12 },
  { 9, 8, 12, 8, 0, -12 },
  { 21, 7, 14, 7, 0, -13 },
  { 34, 9, 12, 10, 1, -12 },
  { 48, 7, 12, 8, 0, -12 },
  { 59, 1, 4, 3, 2, -12 },
  { 60, 5, 15, 4, 0, -12 },
  { 70, 5, 15, 4, -1, -12 },
  { 80, 5, 6, 7, 2, -13 },
  { 84, 6, 8, 8, 1, -10 },
  { 90, 3, 4, 3, -1, -2 },
  { 92, 4, 1, 5, 0, -5 },
  { 93, 1, 1, 3, 0, -1 },
  { 94, 7, 12, 5, -1, -12 },
  { 105, 6, 12, 7, 1, -12 },
  { 114, 4, 12, 7, 2, -12 },
  { 120, 7, 12, 7, 0, -12 },
  { 131, 7, 12, 7, 0, -12 },
  { 142, 7, 12, 7, 0, -12 },
  { 153, 7, 12, 7, 0, -12 },
  { 164, 6, 12, 7, 1, -12 },
  { 173, 7, 12, 7, 1, -12 },
  { 184, 7, 12, 7, 0, -12 },
  { 195, 7, 12, 7, 0, -12 },
  { 206, 3, 9, 3, 0, -9 },
  { 210, 4, 11, 3, -1, -9 },
  { 216, 6, 8, 8, 1, -10 },
  { 222, 6, 4, 8, 1, -8 },
  { 225, 6, 8, 8, 1, -10 },
  { 231, 5, 12, 5, 1, -12 },
  { 239, 9, 14, 11, 1, -12 },
  { 255, 7, 12, 7, -1, -12 },
  { 266, 8, 12, 8, 0, -12 },
  { 278, 7, 12, 7, 1, -12 },
  { 289, 8, 12, 8, 0, -12 },
  { 301, 7, 12, 7, 0, -12 },
  { 312, 7, 12, 6, 0, -12 },
  { 323, 8, 12, 9, 1, -12 },
  { 335, 9, 12, 9, 0, -12 },
  { 349, 6, 12, 4, -1, -12 },
  { 358, 7, 15, 3, -3, -12 },
  { 372, 8, 12, 7, 0, -12 },
  { 384, 5, 12, 6, 0, -12 },
  { 392, 11, 12, 11, 0, -12 },
  { 409, 9, 12, 9, 0, -12 },
  { 423, 8, 12, 9, 1, -12 },
  { 435, 7, 12, 7, 0, -12 },
  { 446, 8, 15, 9, 1, -12 },
  { 461, 7, 12, 7, 0, -12 },
  { 472, 7, 12, 7, 0, -12 },
  { 483, 6, 12, 6, 1, -12 },
  { 492, 8, 12, 9, 1, -12 },
  { 504, 6, 12, 7, 2, -12 },
  { 513, 11, 12, 11, 2, -12 },
  { 530, 9, 12, 6, -1, -12 },
  { 544, 7, 12, 6, 1, -12 },
  { 555, 8, 12, 6, -1, -12 },
  { 567, 6, 15, 5, 0, -12 },
  { 579, 2, 12, 5, 2, -12 },
  { 582, 6, 15, 5, -1, -12 },
  { 594, 6, 6, 8, 1, -12 },
  { 599, 5, 1, 5, -1, 1 },
  { 600, 2, 3, 4, 2, -13 },
  { 601, 6, 9, 7, 1, -9 },
  { 608, 7, 13, 7, 0, -13 },
  { 620, 5, 9, 6, 1, -9 },
  { 626, 7, 13, 8, 1, -13 },
  { 638, 5, 9, 7, 1, -9 },
  { 644, 8, 17, 4, -2, -13 },
  { 661, 7, 13, 8, 0, -9 },
  { 673, 7, 13, 7, 0, -13 },
  { 685, 4, 12, 3, 0, -12 },
  { 691, 6, 16, 3, -2, -12 },
  { 703, 7, 13, 6, 0, -13 },
  { 715, 4, 13, 3, 0, -13 },
  { 722, 10, 9, 11, 0, -9 },
  { 734, 7, 9, 7, 0, -9 },
  { 742, 6, 9, 7, 1, -9 },
  { 749, 8, 13, 7, -1, -9 },
  { 762, 6, 13, 8, 1, -9 },
  { 772, 5, 9, 5, 0, -9 },
  { 778, 6, 9, 6, 0, -9 },
  { 785, 4, 11, 4, 0, -11 },
  { 791, 6, 9, 7, 1, -9 },
  { 798, 5, 9, 6, 1, -9 },
  { 804, 9, 9, 9, 1, -9 },
  { 815, 7, 9, 6, -1, -9 },
  { 823, 9, 13, 6, -2, -9 },
  { 838, 5, 9, 5, 0, -9 },
  { 844, 6, 15, 5, 0, -12 },
  { 856, 1, 17, 7, 3, -13 },
  { 859, 6, 15, 5, -1, -12 },
  { 871, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC17PT7B_H_
