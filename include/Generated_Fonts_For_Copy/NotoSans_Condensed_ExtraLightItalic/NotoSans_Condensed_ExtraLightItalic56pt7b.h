#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x73, 0x06, 0x30,
  0x63, 0x06, 0x70, 0x66, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0,
  0x8C, 0x18, 0xC1, 0x88, 0x18, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x03, 0x00, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x78, 0x8F, 0x01, 0xC3, 0x02,
  0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00,
  0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06,
  0x08, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x27,
  0x00, 0x00, 0x47, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x08, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x80, 0x02, 0x06, 0x00, 0x04, 0x1C, 0x08, 0x18, 0x70, 0x1F,
  0x3F, 0xC0, 0x5F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x01, 0xCE, 0x00, 0x30, 0x1C, 0x30,
  0x03, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x60, 0x18,
  0x02, 0x06, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x01, 0x83, 0x00, 0x30, 0x0C,
  0x18, 0x01, 0x80, 0x61, 0x80, 0x18, 0x03, 0x0C, 0x00, 0xC0, 0x30, 0xC0,
  0x06, 0x01, 0x8C, 0x3F, 0x30, 0x0C, 0x63, 0xDD, 0x80, 0xC6, 0x38, 0x6C,
  0x06, 0x31, 0x81, 0x60, 0x63, 0x18, 0x0D, 0x87, 0x18, 0xC0, 0x6E, 0x71,
  0x8C, 0x03, 0x3F, 0x1C, 0x60, 0x18, 0x40, 0xC3, 0x00, 0x80, 0x0C, 0x30,
  0x0C, 0x00, 0x61, 0x80, 0x60, 0x06, 0x0C, 0x03, 0x00, 0x30, 0x60, 0x18,
  0x03, 0x06, 0x00, 0xC0, 0x38, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x70, 0x07, 0x0C, 0x03, 0x00, 0x1C, 0xE0,
  0x30, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0x67, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xD8, 0x00, 0x03, 0x18, 0x00, 0x06, 0x0C, 0x07, 0x0C, 0x0C, 0x06, 0x18,
  0x0E, 0x06, 0x38, 0x06, 0x0C, 0x30, 0x06, 0x0C, 0x70, 0x03, 0x1C, 0x60,
  0x03, 0x18, 0x60, 0x03, 0xB8, 0x60, 0x01, 0xB0, 0xE0, 0x01, 0xE0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xE0, 0x01, 0xE0, 0x60, 0x03, 0x60, 0x60,
  0x07, 0x60, 0x70, 0x0C, 0x30, 0x3C, 0x78, 0x30, 0x1F, 0xF0, 0x38, 0x01,
  0x00, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x62, 0x31, 0x8C, 0x40, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x0C, 0x08, 0x07, 0x04, 0x00, 0xE2, 0x00,
  0x1F, 0x1F, 0x03, 0xFF, 0x81, 0xC0, 0x01, 0xA0, 0x01, 0x98, 0x01, 0x84,
  0x01, 0x83, 0x03, 0x80, 0xC0, 0x80, 0x60, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x6F, 0xEE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0x01, 0xC0, 0x18, 0x0C, 0x00,
  0xC0, 0xE0, 0x06, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x18,
  0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x07, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x30,
  0x01, 0x81, 0x80, 0x1C, 0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0xC0,
  0x07, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x03, 0xE0, 0x76, 0x0E, 0x63, 0x8C, 0x70, 0xCE, 0x0C, 0x40, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFB, 0xE0, 0x07, 0x00, 0xE0, 0x04, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x7C, 0x7C, 0x01, 0xE0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xC0, 0x07, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x76, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x10,
  0x01, 0xC0, 0x3E, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0xF0, 0x01, 0xF1, 0x80, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0xC7, 0xF8,
  0x03, 0x3C, 0xF8, 0x0D, 0x80, 0x60, 0x6C, 0x01, 0xC1, 0xE0, 0x03, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00,
  0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x38,
  0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x38, 0x03, 0x01, 0xC0, 0x0F, 0xBE,
  0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x70,
  0x01, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x70, 0x00, 0xC3,
  0x80, 0x01, 0xCE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0xC0,
  0x00, 0xE0, 0xC0, 0x03, 0x80, 0xC0, 0x1C, 0x01, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x80,
  0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x0F, 0x8F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x01,
  0x80, 0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E,
  0x30, 0x00, 0xE1, 0x80, 0x0F, 0x06, 0x00, 0x78, 0x38, 0x0E, 0xC0, 0xF1,
  0xE6, 0x03, 0xFC, 0x60, 0x03, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0xC0, 0x00, 0x30, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x03, 0xFE, 0x07, 0xEF, 0x81, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x78, 0x02, 0x0C, 0x01, 0xFF, 0x03, 0x18, 0x03, 0x86, 0x03, 0x18,
  0x06, 0x06, 0x03, 0x18, 0x0C, 0x06, 0x02, 0x30, 0x18, 0x06, 0x06, 0x30,
  0x18, 0x0C, 0x06, 0x30, 0x30, 0x0C, 0x06, 0x60, 0x30, 0x0C, 0x06, 0x60,
  0x60, 0x0C, 0x06, 0x60, 0x60, 0x18, 0x06, 0x60, 0x60, 0x18, 0x0C, 0xC0,
  0x40, 0x18, 0x0C, 0xC0, 0xC0, 0x38, 0x0C, 0xC0, 0xC0, 0x30, 0x18, 0xC0,
  0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x70, 0x10, 0xC0, 0xC0, 0x70, 0x30, 0xC0,
  0xC0, 0xF0, 0x60, 0xC0, 0xC1, 0xB0, 0x60, 0xC0, 0x63, 0x99, 0xC0, 0xC0,
  0x7F, 0x1F, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80,
  0x60, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x3C, 0x00, 0xC0, 0x0E, 0x01, 0xC0,
  0x07, 0x01, 0x80, 0x07, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x06, 0x00,
  0x38, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0C, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00,
  0x38, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x60, 0x03,
  0x80, 0xE0, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x38, 0x02, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0C,
  0x07, 0xC0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18, 0x00,
  0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x18, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x0F, 0x00, 0x38, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x1C, 0x00, 0x70, 0x0F,
  0x00, 0x04, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x30,
  0x00, 0xFF, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x00, 0x7F, 0x7F, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x08,
  0x70, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x06, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x06,
  0x78, 0x00, 0x00, 0xD9, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1B, 0x00, 0x00, 0x1B,
  0x00, 0xD8, 0x00, 0x00, 0xF8, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x36, 0x00,
  0x00, 0x6C, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x19, 0x80, 0x00, 0x33, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x06, 0x60, 0x00, 0x19, 0x80, 0x33, 0x00, 0x01,
  0x8C, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x18, 0x60, 0x00, 0xC3, 0x00, 0xC3,
  0x00, 0x06, 0x30, 0x06, 0x18, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x03, 0x0C,
  0x03, 0x86, 0x00, 0x30, 0x60, 0x18, 0x30, 0x03, 0x87, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x06, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xE0, 0x60, 0x18, 0x18, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x70,
  0x30, 0x06, 0x03, 0x03, 0x01, 0x80, 0x30, 0x18, 0x38, 0x0C, 0x03, 0x00,
  0xC1, 0x80, 0x60, 0x18, 0x06, 0x1C, 0x06, 0x00, 0xC0, 0x30, 0xC0, 0x30,
  0x06, 0x01, 0x8E, 0x01, 0x80, 0x70, 0x0C, 0x60, 0x0C, 0x03, 0x00, 0x67,
  0x00, 0xE0, 0x18, 0x03, 0x30, 0x06, 0x00, 0xC0, 0x1B, 0x80, 0x30, 0x06,
  0x00, 0xD8, 0x01, 0x80, 0x60, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x30, 0x1B, 0x00, 0x03,
  0x80, 0xD8, 0x00, 0x18, 0x06, 0xC0, 0x00, 0xC0, 0x33, 0x00, 0x06, 0x01,
  0x98, 0x00, 0x30, 0x18, 0xC0, 0x03, 0x00, 0xC6, 0x00, 0x18, 0x06, 0x18,
  0x00, 0xC0, 0x30, 0xC0, 0x06, 0x03, 0x86, 0x00, 0x30, 0x18, 0x30, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x03,
  0x81, 0x80, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x30, 0x70, 0x18, 0x01, 0x83,
  0x00, 0xC0, 0x0C, 0x18, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x01, 0x86, 0x03,
  0x00, 0x0C, 0x60, 0x18, 0x00, 0x63, 0x00, 0xC0, 0x03, 0x18, 0x06, 0x00,
  0x0C, 0xC0, 0x70, 0x00, 0x66, 0x03, 0x00, 0x03, 0x60, 0x18, 0x00, 0x1B,
  0x00, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x60, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x78, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0x01, 0xE0, 0x06, 0x00, 0xE0,
  0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x60, 0x07, 0x00, 0xC0, 0x3C,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x60, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x07,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x78, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03,
  0x01, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x60, 0x0F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0x03, 0x00, 0x0E,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x70, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x70, 0x03,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xFE, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0x60, 0x03, 0x81,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xE0,
  0x06, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x01, 0xB0,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0xCC, 0x00, 0x0F, 0x00,
  0x06, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x06, 0xC0, 0x03, 0x18, 0x00,
  0x36, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01, 0x86, 0x00, 0x19, 0x80, 0x0C,
  0x30, 0x01, 0x8C, 0x00, 0xE1, 0x80, 0x0C, 0x60, 0x06, 0x0C, 0x00, 0xE3,
  0x00, 0x70, 0x60, 0x06, 0x18, 0x03, 0x03, 0x00, 0x30, 0xC0, 0x18, 0x18,
  0x03, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0xE0, 0x30, 0x0C, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x60, 0x30, 0x0C, 0x06,
  0x03, 0x03, 0x00, 0x60, 0x30, 0x18, 0x18, 0x03, 0x03, 0x00, 0xC1, 0xC0,
  0x18, 0x18, 0x06, 0x0C, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0x30, 0x60, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x63, 0x00, 0x0C,
  0x30, 0x03, 0x18, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0xCC,
  0x00, 0x19, 0xC0, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x06, 0x60,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x58, 0x00,
  0x0D, 0x80, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEE, 0x00,
  0x0C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60,
  0x06, 0x06, 0x00, 0xE0, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x38, 0x03,
  0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x0E, 0x06,
  0x00, 0x30, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x01, 0x81,
  0xC0, 0x06, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0x86, 0x0C, 0x30, 0x61, 0x83, 0x04, 0x00, 0x7F, 0x0C, 0x03, 0xFE, 0x20,
  0x1C, 0x19, 0x80, 0xC0, 0x36, 0x06, 0x00, 0x58, 0x38, 0x01, 0xE0, 0xC0,
  0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xE0,
  0xC0, 0x05, 0x83, 0x80, 0x3C, 0x06, 0x01, 0xB0, 0x1C, 0x0C, 0xC0, 0x3C,
  0xE3, 0x00, 0x7F, 0x08, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x3F, 0x00, 0x33,
  0xFE, 0x00, 0xDC, 0x1C, 0x06, 0xE0, 0x38, 0x1B, 0x00, 0x60, 0x78, 0x01,
  0x81, 0xC0, 0x06, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x00, 0x07, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x36, 0x00, 0xC0, 0xCC, 0x0E,
  0x03, 0x3C, 0xF0, 0x0C, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xF0, 0x1C, 0x08, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x20,
  0x3E, 0x78, 0x07, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0xF8, 0x60, 0x03, 0xFE, 0x30, 0x03, 0x83, 0xB0, 0x03, 0x00, 0xD8,
  0x03, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x01, 0x80, 0x0F, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00,
  0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x0E, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x78, 0x06, 0x00, 0x3C, 0x03, 0x80, 0x36, 0x00, 0xC0, 0x36, 0x00,
  0x70, 0x33, 0x00, 0x1E, 0x79, 0x80, 0x07, 0xF0, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1C, 0x1C, 0x0C, 0x03, 0x06, 0x00,
  0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x63,
  0x00, 0x39, 0xC0, 0x1C, 0x60, 0x0E, 0x18, 0x1F, 0x07, 0xFF, 0x03, 0xFC,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x3E, 0x7C, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x84, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0x00, 0x3F, 0xE3, 0x00, 0x70, 0x72, 0x00, 0xE0,
  0x36, 0x01, 0x80, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0x00, 0x1E, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x38, 0x38, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x70, 0x30, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x01,
  0xE0, 0x30, 0x01, 0xE0, 0x38, 0x03, 0x60, 0x18, 0x06, 0xC0, 0x1C, 0x0E,
  0xC0, 0x0F, 0x3C, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x80, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x87, 0xE0, 0x0C,
  0xFF, 0x80, 0x6E, 0x0E, 0x06, 0xC0, 0x30, 0x3C, 0x01, 0xC1, 0xE0, 0x06,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x00, 0xC0, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x0D, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1C,
  0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x01,
  0x86, 0x00, 0x0C, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x78, 0x00, 0x37, 0xC0,
  0x01, 0xB6, 0x00, 0x0F, 0x18, 0x00, 0xF0, 0xC0, 0x07, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0E, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x00, 0x03, 0x0F, 0x80, 0xFC, 0x01, 0x9F, 0xF0, 0xFF,
  0x81, 0x98, 0x38, 0xC1, 0xC0, 0xD8, 0x0C, 0xC0, 0x70, 0x78, 0x03, 0xC0,
  0x18, 0x38, 0x01, 0xC0, 0x0C, 0x1C, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0x60,
  0x03, 0x0E, 0x00, 0x70, 0x01, 0x86, 0x00, 0x30, 0x01, 0xC3, 0x00, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x07,
  0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x18, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x86, 0x00,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x61, 0x80,
  0x0E, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x38, 0x60, 0x03, 0x00, 0x18, 0x30,
  0x01, 0x80, 0x0C, 0x38, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xE0, 0x03, 0x0C,
  0x00, 0x60, 0x03, 0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0x0F, 0xC0, 0x19,
  0xFF, 0x01, 0x9C, 0x1C, 0x0D, 0x80, 0x60, 0x78, 0x03, 0x83, 0xC0, 0x0C,
  0x1C, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC1, 0xC0, 0x30,
  0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x07, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01,
  0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0x60, 0x0E, 0x07, 0x01,
  0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x61, 0xF8,
  0x00, 0x31, 0xFE, 0x00, 0x13, 0x83, 0x80, 0x19, 0x80, 0xE0, 0x0D, 0x80,
  0x30, 0x07, 0x80, 0x18, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0,
  0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x38,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x30,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x18, 0x06, 0xC0, 0x18, 0x03, 0x30, 0x38,
  0x01, 0x9E, 0x78, 0x00, 0xC7, 0xF8, 0x00, 0x60, 0x40, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x0C, 0x03, 0xFE, 0x30, 0x1C, 0x1C, 0x80, 0xC0, 0x36, 0x06,
  0x00, 0x78, 0x38, 0x01, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x0E,
  0x0C, 0x00, 0x38, 0x30, 0x01, 0xE0, 0xC0, 0x07, 0x83, 0x80, 0x36, 0x06,
  0x01, 0xB0, 0x1C, 0x0E, 0xC0, 0x3C, 0xF3, 0x00, 0x7F, 0x0C, 0x00, 0x20,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x0F, 0x81, 0x1F, 0xC1, 0x9C, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x70, 0x0C, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC2, 0x00, 0xE0, 0xF0, 0xF0, 0x1F, 0xF8, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x01,
  0xFF, 0x7F, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x20, 0x7E, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x70, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00,
  0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x58, 0x30, 0x06, 0x81, 0xC0, 0x6C, 0x07,
  0x9E, 0x60, 0x1F, 0xC3, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63,
  0x00, 0x38, 0xE0, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x81, 0x80, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x30,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x6C, 0x00, 0xF0, 0x07, 0x60, 0x07,
  0x80, 0x33, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x60, 0x18, 0xC0, 0x33, 0x00,
  0xC6, 0x01, 0x98, 0x0C, 0x30, 0x18, 0xC0, 0x61, 0x80, 0xC6, 0x07, 0x04,
  0x06, 0x30, 0x30, 0x20, 0x61, 0x81, 0x81, 0x03, 0x0C, 0x18, 0x0C, 0x30,
  0x60, 0xC0, 0x61, 0x83, 0x0E, 0x03, 0x18, 0x18, 0x60, 0x18, 0xC0, 0xC3,
  0x00, 0xC6, 0x06, 0x30, 0x06, 0x60, 0x31, 0x80, 0x33, 0x01, 0x98, 0x01,
  0xB0, 0x04, 0xC0, 0x0D, 0x80, 0x26, 0x00, 0x58, 0x01, 0x60, 0x02, 0xC0,
  0x0B, 0x00, 0x14, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x38, 0x00, 0x70, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x07,
  0x03, 0x00, 0x0C, 0x07, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x80,
  0x18, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x09, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xF0,
  0x1E, 0x1F, 0x00, 0x3F, 0xC8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 40, 12, 1, -40 },
  { 56, 12, 14, 16, 6, -40 },
  { 77, 25, 40, 25, 1, -40 },
  { 202, 23, 46, 23, 0, -43 },
  { 335, 29, 42, 34, 3, -41 },
  { 488, 24, 42, 25, 0, -41 },
  { 614, 5, 14, 9, 6, -40 },
  { 623, 15, 49, 14, 2, -40 },
  { 715, 16, 49, 14, -4, -40 },
  { 813, 17, 18, 22, 7, -42 },
  { 852, 22, 26, 25, 2, -33 },
  { 924, 7, 13, 10, -2, -6 },
  { 936, 13, 2, 16, 1, -16 },
  { 940, 4, 4, 10, 1, -4 },
  { 942, 24, 40, 17, -3, -40 },
  { 1062, 21, 42, 23, 2, -41 },
  { 1173, 12, 40, 23, 7, -40 },
  { 1233, 23, 41, 23, -1, -41 },
  { 1351, 24, 42, 23, -1, -41 },
  { 1477, 24, 40, 23, -1, -40 },
  { 1597, 23, 41, 23, 0, -40 },
  { 1715, 22, 42, 23, 2, -41 },
  { 1831, 22, 40, 23, 3, -40 },
  { 1941, 23, 42, 23, 0, -41 },
  { 2062, 21, 42, 23, 1, -41 },
  { 2173, 8, 30, 10, 1, -30 },
  { 2203, 13, 37, 10, -3, -30 },
  { 2264, 22, 24, 25, 2, -32 },
  { 2330, 22, 14, 25, 2, -27 },
  { 2369, 22, 24, 25, 2, -32 },
  { 2435, 17, 41, 17, 2, -41 },
  { 2523, 32, 45, 35, 2, -40 },
  { 2703, 23, 40, 23, -4, -40 },
  { 2818, 24, 40, 25, 1, -40 },
  { 2938, 24, 42, 24, 3, -41 },
  { 3064, 26, 40, 28, 1, -40 },
  { 3194, 23, 40, 22, 1, -40 },
  { 3309, 24, 40, 21, 1, -40 },
  { 3429, 27, 42, 30, 3, -41 },
  { 3571, 29, 40, 29, 1, -40 },
  { 3716, 18, 40, 12, -2, -40 },
  { 3806, 20, 50, 10, -8, -40 },
  { 3931, 27, 40, 23, 1, -40 },
  { 4066, 15, 40, 20, 1, -40 },
  { 4141, 37, 40, 37, 1, -40 },
  { 4326, 29, 40, 30, 1, -40 },
  { 4471, 26, 42, 30, 3, -41 },
  { 4608, 23, 40, 24, 1, -40 },
  { 4723, 26, 51, 30, 3, -41 },
  { 4889, 23, 40, 24, 1, -40 },
  { 5004, 24, 42, 22, -1, -41 },
  { 5130, 20, 40, 20, 5, -40 },
  { 5230, 26, 41, 29, 3, -40 },
  { 5364, 22, 40, 23, 5, -40 },
  { 5474, 37, 40, 38, 5, -40 },
  { 5659, 28, 40, 21, -3, -40 },
  { 5799, 20, 40, 20, 5, -40 },
  { 5899, 26, 40, 21, -2, -40 },
  { 6029, 20, 49, 16, -1, -40 },
  { 6152, 8, 40, 18, 6, -40 },
  { 6192, 21, 49, 16, -4, -40 },
  { 6321, 22, 21, 25, 2, -40 },
  { 6379, 16, 2, 17, -4, 5 },
  { 6383, 6, 9, 12, 8, -43 },
  { 6390, 22, 31, 24, 2, -30 },
  { 6476, 22, 44, 25, 1, -43 },
  { 6597, 18, 31, 19, 2, -30 },
  { 6667, 25, 44, 25, 2, -43 },
  { 6805, 18, 31, 22, 2, -30 },
  { 6875, 26, 56, 12, -7, -43 },
  { 7057, 24, 43, 25, 0, -30 },
  { 7186, 21, 43, 24, 1, -43 },
  { 7299, 11, 40, 10, 1, -40 },
  { 7354, 20, 53, 10, -8, -40 },
  { 7487, 21, 43, 20, 1, -43 },
  { 7600, 11, 43, 10, 1, -43 },
  { 7660, 33, 30, 36, 1, -30 },
  { 7784, 21, 30, 24, 1, -30 },
  { 7863, 20, 31, 24, 2, -30 },
  { 7941, 25, 43, 25, -2, -30 },
  { 8076, 22, 43, 25, 2, -30 },
  { 8195, 17, 30, 16, 1, -30 },
  { 8259, 18, 31, 18, 0, -30 },
  { 8329, 12, 38, 13, 2, -37 },
  { 8386, 21, 31, 24, 2, -30 },
  { 8468, 18, 30, 18, 3, -30 },
  { 8536, 29, 30, 30, 3, -30 },
  { 8645, 23, 30, 19, -2, -30 },
  { 8732, 28, 44, 19, -6, -30 },
  { 8886, 20, 30, 17, -2, -30 },
  { 8961, 19, 49, 18, 2, -40 },
  { 9078, 2, 57, 23, 11, -43 },
  { 9093, 19, 49, 18, -3, -40 },
  { 9210, 21, 5, 25, 3, -22 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC56PT7B_H_
