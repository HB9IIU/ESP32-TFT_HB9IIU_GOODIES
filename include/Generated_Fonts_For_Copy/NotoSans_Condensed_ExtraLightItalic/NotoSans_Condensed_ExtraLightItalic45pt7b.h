#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81,
  0x80, 0x18, 0xCC, 0x33, 0x0C, 0xC2, 0x20, 0x88, 0x66, 0x19, 0x84, 0x41,
  0x10, 0x4C, 0x30, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x60, 0x40, 0x06,
  0x0C, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00,
  0x81, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x10, 0x20, 0x03, 0x02, 0x00,
  0x30, 0x60, 0x02, 0x04, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x40, 0xC0,
  0x04, 0x08, 0x00, 0xC1, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x18, 0x10,
  0x01, 0x83, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x30, 0x60, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x03,
  0x91, 0xC0, 0xC2, 0x00, 0x30, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x30,
  0x40, 0x06, 0x18, 0x00, 0x43, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x19,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x2C, 0x00, 0x04,
  0xC0, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10,
  0x40, 0x06, 0x18, 0x00, 0x83, 0x00, 0x10, 0xC1, 0x02, 0x38, 0x3F, 0xFC,
  0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x61, 0x8C, 0x03, 0x04,
  0x10, 0x0C, 0x30, 0x40, 0x60, 0x81, 0x01, 0x06, 0x04, 0x0C, 0x10, 0x10,
  0x20, 0x40, 0x41, 0x83, 0x03, 0x0C, 0x0C, 0x0C, 0x30, 0x30, 0x31, 0x80,
  0x80, 0x84, 0x02, 0x02, 0x30, 0xC8, 0x18, 0x8F, 0xA0, 0x46, 0x63, 0x83,
  0x33, 0x06, 0x08, 0xCC, 0x1C, 0x66, 0x60, 0x5F, 0x11, 0x81, 0x10, 0xC4,
  0x04, 0x02, 0x30, 0x10, 0x18, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x08, 0x0C,
  0x18, 0x20, 0x20, 0x40, 0x81, 0x83, 0x02, 0x06, 0x08, 0x08, 0x10, 0x60,
  0x20, 0xC3, 0x00, 0x82, 0x0C, 0x03, 0x18, 0x60, 0x07, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x03, 0x0C, 0x00, 0xC0, 0x80, 0x18,
  0x18, 0x02, 0x03, 0x00, 0x40, 0x40, 0x18, 0x08, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x18, 0x00, 0x86, 0x00, 0x19, 0xC0, 0x03, 0x70, 0x00, 0x7C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xEC, 0x00, 0x31, 0x80, 0x0C, 0x10,
  0x33, 0x03, 0x04, 0x60, 0x61, 0x98, 0x06, 0x33, 0x00, 0xCC, 0x40, 0x09,
  0x98, 0x01, 0xE3, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x34,
  0x18, 0x0C, 0xC3, 0x87, 0x18, 0x3F, 0xC1, 0x80, 0x36, 0x66, 0x44, 0xCC,
  0x88, 0x80, 0x00, 0x18, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x10, 0x40, 0xE1, 0x00, 0xE4, 0x00, 0xD7, 0xC0, 0xF0,
  0x07, 0x00, 0x36, 0x01, 0x88, 0x1C, 0x30, 0x60, 0x40, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x30, 0xC6, 0x18,
  0x43, 0x08, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x70, 0xC0, 0x30, 0x20, 0x30,
  0x18, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x62, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03,
  0x60, 0x01, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x22, 0x00,
  0x31, 0x00, 0x18, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x10, 0x02, 0x08,
  0x03, 0x04, 0x01, 0x03, 0x01, 0x81, 0x81, 0x80, 0x61, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0x83, 0xC3, 0x43, 0x67, 0x36, 0x1A, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x07, 0x07, 0x00, 0x80, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xC0, 0x38, 0x38, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x08, 0x03, 0x83, 0x03, 0xC0, 0xFF, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x04,
  0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x21, 0x00, 0x18, 0xC0,
  0x0C, 0x30, 0x02, 0x0C, 0x01, 0x82, 0x00, 0xC0, 0x80, 0x20, 0x60, 0x18,
  0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0x40, 0xC0, 0x30, 0x60, 0x0C,
  0x18, 0x03, 0x0C, 0x00, 0x83, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x01, 0xFF, 0xE0, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0x8F,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x81, 0x00, 0x70,
  0x38, 0x38, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x0E, 0x01, 0x9F,
  0xE0, 0xD8, 0x30, 0x50, 0x0C, 0x70, 0x06, 0x38, 0x01, 0x18, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x32, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06,
  0x20, 0x02, 0x10, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x81, 0x81, 0x80, 0xE1,
  0x80, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xE0, 0x07, 0x06, 0x01, 0x80, 0x60, 0x30, 0x04,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x40, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x77, 0x00, 0x38, 0x60, 0x0C, 0x06, 0x03,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x04, 0x00, 0x60, 0xC0, 0x0C, 0x1C,
  0x03, 0x01, 0xC1, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x80,
  0x1C, 0x30, 0x0C, 0x06, 0x02, 0x00, 0x81, 0x80, 0x30, 0xC0, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x83, 0x01, 0xE0,
  0xE0, 0xD8, 0x1F, 0xE4, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x03, 0x07, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x07,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x60, 0x00, 0xC0,
  0x70, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x3F, 0xC1, 0xC3, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x08, 0x10, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x07, 0xF0, 0xCC, 0x07, 0x30, 0x66, 0x06,
  0x08, 0x32, 0x06, 0x0C, 0x1B, 0x06, 0x06, 0x0D, 0x83, 0x02, 0x06, 0x83,
  0x01, 0x02, 0xC1, 0x81, 0x81, 0x60, 0x80, 0xC1, 0xB0, 0x40, 0x40, 0xD0,
  0x60, 0x60, 0x48, 0x30, 0x30, 0x24, 0x18, 0x18, 0x32, 0x0C, 0x1C, 0x11,
  0x06, 0x0E, 0x18, 0x83, 0x0B, 0x18, 0x40, 0xFC, 0xF8, 0x20, 0x38, 0x38,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x28,
  0x00, 0x1A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x62, 0x00,
  0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x10,
  0x30, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x3F, 0xFC,
  0x0F, 0xFF, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x58, 0x00,
  0x16, 0x00, 0x07, 0x00, 0x01, 0x03, 0xFF, 0x00, 0x61, 0xF0, 0x0C, 0x03,
  0x01, 0x00, 0x30, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x04, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18,
  0x10, 0x0E, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x60,
  0x40, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x61,
  0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x03, 0x0C,
  0x00, 0xC1, 0x80, 0x30, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0x00, 0x70, 0x20, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC1, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x30,
  0xF8, 0x03, 0x01, 0xC0, 0x20, 0x06, 0x02, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x10,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x02, 0x10, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x0C, 0x20, 0x00, 0xC2, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x30, 0x60, 0x06, 0x04, 0x00, 0xE0, 0xC0, 0x1C, 0x0C, 0x07, 0x00, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0x01, 0xC0, 0x70, 0x01, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x3F, 0xCC, 0x00, 0xFE, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x80,
  0x18, 0x07, 0x81, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x08, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x40,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x08, 0x00,
  0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06,
  0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x40,
  0x60, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03,
  0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18,
  0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x04, 0x0C, 0x00, 0x60,
  0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x04, 0xE0, 0x00,
  0x66, 0x00, 0x03, 0x78, 0x00, 0x1E, 0xC0, 0x00, 0xE2, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x04,
  0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x10,
  0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x05, 0x00,
  0x00, 0xF0, 0x28, 0x00, 0x0D, 0x03, 0x40, 0x00, 0x78, 0x1A, 0x00, 0x06,
  0xC0, 0xD8, 0x00, 0x36, 0x04, 0xC0, 0x03, 0x20, 0x66, 0x00, 0x11, 0x03,
  0x30, 0x01, 0x98, 0x19, 0x80, 0x08, 0xC0, 0xCC, 0x00, 0xC6, 0x04, 0x20,
  0x04, 0x20, 0x61, 0x00, 0x63, 0x03, 0x08, 0x02, 0x18, 0x18, 0x40, 0x30,
  0xC0, 0x82, 0x01, 0x06, 0x04, 0x18, 0x18, 0x20, 0x60, 0xC0, 0x83, 0x03,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x40, 0xC0, 0x81, 0x86, 0x06, 0x04, 0x0C,
  0x20, 0x20, 0x60, 0x63, 0x03, 0x03, 0x01, 0x10, 0x18, 0x18, 0x09, 0x80,
  0xC0, 0x80, 0x48, 0x04, 0x0C, 0x02, 0xC0, 0x20, 0x60, 0x1C, 0x03, 0x03,
  0x00, 0xE0, 0x18, 0x10, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x02, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x18, 0x14, 0x00, 0x30, 0x2C, 0x00, 0x60, 0xD8, 0x00,
  0x81, 0xB0, 0x03, 0x03, 0x20, 0x06, 0x04, 0x60, 0x0C, 0x18, 0xC0, 0x10,
  0x31, 0x80, 0x20, 0x61, 0x00, 0xC0, 0xC3, 0x01, 0x81, 0x06, 0x03, 0x06,
  0x0C, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0x20, 0x30, 0x60, 0x40,
  0x60, 0xC1, 0x80, 0x41, 0x03, 0x00, 0xC6, 0x06, 0x01, 0x8C, 0x08, 0x03,
  0x18, 0x10, 0x02, 0x30, 0x60, 0x06, 0x40, 0xC0, 0x0D, 0x81, 0x80, 0x1B,
  0x02, 0x00, 0x16, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x38, 0x38, 0x03,
  0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33,
  0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x30,
  0x03, 0x87, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xC7, 0xC0, 0x30,
  0x18, 0x08, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01,
  0x04, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x82,
  0x00, 0x61, 0x80, 0x30, 0x60, 0x18, 0x18, 0x1C, 0x07, 0xFE, 0x01, 0xF0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00,
  0x38, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x00, 0xC0, 0x30, 0x03, 0x87, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0xC7, 0xC0, 0x30,
  0x18, 0x08, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01,
  0x04, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x82,
  0x00, 0x61, 0x80, 0x30, 0x60, 0x38, 0x1F, 0xFC, 0x07, 0xF8, 0x01, 0x06,
  0x00, 0xC0, 0x80, 0x30, 0x30, 0x0C, 0x0C, 0x02, 0x03, 0x00, 0x80, 0x40,
  0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00,
  0xE0, 0x70, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x80, 0x1C, 0x0F,
  0x07, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x20, 0x40, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x40, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x03, 0x83, 0x80, 0x07, 0xF8,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03,
  0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x01, 0x83, 0x00, 0x60, 0x40, 0x30, 0x10, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x40, 0x40, 0x10, 0x30, 0x04, 0x08, 0x01, 0x06, 0x00, 0x41, 0x80,
  0x10, 0xC0, 0x04, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x6C, 0x00, 0x70, 0x01,
  0xB0, 0x01, 0xC0, 0x0C, 0xC0, 0x0F, 0x00, 0x33, 0x00, 0x2C, 0x00, 0x8C,
  0x01, 0xB0, 0x06, 0x30, 0x06, 0xC0, 0x10, 0xC0, 0x13, 0x00, 0xC3, 0x00,
  0xCC, 0x03, 0x0C, 0x02, 0x30, 0x18, 0x30, 0x18, 0xC0, 0x60, 0xC0, 0x63,
  0x01, 0x03, 0x01, 0x0C, 0x0C, 0x0C, 0x0C, 0x30, 0x30, 0x30, 0x20, 0xC1,
  0x80, 0xC1, 0x83, 0x06, 0x03, 0x06, 0x0C, 0x10, 0x0C, 0x30, 0x30, 0xC0,
  0x30, 0xC0, 0xC2, 0x00, 0xC2, 0x03, 0x18, 0x03, 0x18, 0x0C, 0x60, 0x0C,
  0x40, 0x31, 0x00, 0x33, 0x00, 0xCC, 0x00, 0xCC, 0x03, 0x20, 0x03, 0x60,
  0x0D, 0x80, 0x0D, 0x80, 0x36, 0x00, 0x34, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x18, 0x00, 0x10, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x98, 0x00,
  0x01, 0x60, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x30, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x08, 0x0C, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x00, 0x80, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x20, 0xC0, 0x20, 0x80, 0x21, 0x80, 0x33,
  0x00, 0x33, 0x00, 0x36, 0x00, 0x34, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x04, 0x03, 0xFC, 0x00, 0x82, 0x0C, 0x30, 0xC3,
  0x04, 0x10, 0x41, 0x86, 0x18, 0x20, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10,
  0x41, 0x86, 0x18, 0x60, 0x82, 0x0C, 0x30, 0xC3, 0x00, 0xFF, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x03, 0x60, 0x01,
  0x88, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x08, 0x10, 0x06, 0x06, 0x01, 0x00,
  0x80, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x03, 0xC0, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0xCC, 0x66, 0x21,
  0x10, 0x01, 0xF0, 0x83, 0xCC, 0xC3, 0x83, 0x41, 0x80, 0xA1, 0x80, 0x71,
  0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x62, 0x00, 0x31, 0x00, 0x18, 0x80,
  0x1C, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x07, 0x0C, 0x07, 0x86, 0x06, 0x81,
  0x86, 0x40, 0x7E, 0x20, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x1F, 0x81, 0x98, 0xE0, 0xD8, 0x30, 0x78, 0x0C, 0x38, 0x06,
  0x38, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x02, 0x20, 0x03, 0x30, 0x01, 0x98,
  0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x63, 0x80, 0x61, 0xE0, 0x70,
  0x98, 0x70, 0x47, 0xE0, 0x00, 0x01, 0xFC, 0x1E, 0x30, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x0C, 0x0F, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x07,
  0xE6, 0x03, 0xCE, 0xC0, 0xE0, 0x58, 0x18, 0x0E, 0x06, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x20, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01,
  0x82, 0x00, 0x70, 0x40, 0x0E, 0x08, 0x03, 0x81, 0x00, 0x50, 0x30, 0x1E,
  0x06, 0x06, 0xC0, 0x61, 0x90, 0x07, 0xE2, 0x00, 0x01, 0xF8, 0x1E, 0x70,
  0xE0, 0xC7, 0x01, 0x18, 0x04, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60, 0x19,
  0x00, 0xCC, 0x0E, 0x3F, 0xE0, 0xF8, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x06,
  0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x40, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x20, 0x3C, 0xEC, 0x0E, 0x05, 0x81, 0x80, 0xE0, 0x60,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x82, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x08, 0x00,
  0xC1, 0x00, 0x18, 0x20, 0x07, 0x04, 0x00, 0xE0, 0x80, 0x38, 0x10, 0x05,
  0x03, 0x01, 0xE0, 0x60, 0x6C, 0x06, 0x19, 0x00, 0x7E, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x80, 0xE0, 0x1F, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x7E, 0x0D,
  0xC7, 0x0D, 0x03, 0x0E, 0x01, 0x0C, 0x01, 0x1C, 0x01, 0x18, 0x01, 0x18,
  0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x20,
  0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40,
  0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x80, 0x18, 0x03, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0xE1, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x20, 0x60, 0x30, 0x60,
  0x18, 0x60, 0x0C, 0x60, 0x06, 0x60, 0x02, 0x30, 0x03, 0x38, 0x01, 0xBC,
  0x00, 0xF6, 0x00, 0x71, 0x00, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C,
  0x08, 0x04, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x30,
  0x40, 0x18, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x04, 0x7C, 0x1F, 0x83, 0x73, 0x8C,
  0x70, 0xF0, 0x24, 0x0C, 0x28, 0x0E, 0x01, 0x0C, 0x03, 0x80, 0x47, 0x00,
  0xC0, 0x11, 0x80, 0x30, 0x0C, 0x60, 0x08, 0x03, 0x18, 0x06, 0x00, 0xC4,
  0x01, 0x80, 0x33, 0x00, 0x60, 0x08, 0xC0, 0x18, 0x06, 0x30, 0x04, 0x01,
  0x88, 0x03, 0x00, 0x62, 0x00, 0xC0, 0x11, 0x80, 0x30, 0x04, 0x60, 0x08,
  0x03, 0x18, 0x02, 0x00, 0xC4, 0x01, 0x80, 0x31, 0x00, 0x60, 0x08, 0xC0,
  0x18, 0x06, 0x30, 0x04, 0x01, 0x8C, 0x03, 0x00, 0x62, 0x00, 0xC0, 0x18,
  0x04, 0x7E, 0x0D, 0xC7, 0x0F, 0x03, 0x0A, 0x01, 0x0E, 0x01, 0x1C, 0x01,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x06,
  0x30, 0x06, 0x20, 0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C,
  0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x80, 0x18,
  0x01, 0xF8, 0x07, 0x9C, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x02, 0x30, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C,
  0x80, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0x70, 0xC0, 0x3F, 0x80,
  0x00, 0x8F, 0xC0, 0x19, 0x8E, 0x01, 0xB0, 0x60, 0x16, 0x03, 0x01, 0xC0,
  0x30, 0x38, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x04,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0xC0, 0x18, 0x1C, 0x03, 0x01, 0xE0, 0x70, 0x1B, 0x0E, 0x01, 0x1F, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xF0, 0x83, 0xCE, 0xC3, 0x81, 0x63, 0x80, 0xE1, 0x80, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x02, 0x30, 0x01, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x22, 0x00, 0x31, 0x00, 0x18, 0x80,
  0x1C, 0x40, 0x0E, 0x20, 0x06, 0x10, 0x05, 0x0C, 0x07, 0x86, 0x06, 0xC1,
  0x86, 0x40, 0x7E, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x04, 0x78, 0x6F, 0x43, 0x40, 0x14, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x0E, 0x3C, 0x30,
  0x10, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x10, 0x0C,
  0x30, 0x70, 0x7F, 0xC0, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x03,
  0xFC, 0xFF, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x00, 0x18, 0x01, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06,
  0x60, 0x04, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0x80, 0x18, 0x80, 0x38, 0x80, 0x30, 0x80, 0x50,
  0xC0, 0xF0, 0xE3, 0xB0, 0x7E, 0x20, 0xC0, 0x06, 0x80, 0x19, 0x00, 0x32,
  0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x60, 0x60, 0xC0,
  0x81, 0x83, 0x03, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80,
  0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x34,
  0x03, 0x80, 0x68, 0x05, 0x01, 0x90, 0x1A, 0x03, 0x20, 0x24, 0x04, 0x40,
  0xC8, 0x18, 0x81, 0x90, 0x21, 0x06, 0x20, 0xC2, 0x0C, 0x41, 0x84, 0x10,
  0x82, 0x08, 0x61, 0x0C, 0x10, 0x82, 0x10, 0x23, 0x06, 0x60, 0x44, 0x0C,
  0xC0, 0x98, 0x1B, 0x01, 0x30, 0x36, 0x02, 0x40, 0x68, 0x05, 0x80, 0xF0,
  0x0A, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00,
  0x02, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x30,
  0x03, 0x0C, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0xD8, 0x00, 0x1A, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00,
  0x19, 0x80, 0x06, 0x30, 0x00, 0xC2, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01,
  0x01, 0x80, 0x60, 0x10, 0x18, 0x03, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x00,
  0x81, 0x80, 0x01, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08,
  0x60, 0x00, 0x10, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xBF, 0xC0, 0x70, 0x3C, 0xF0,
  0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 32, 10, 1, -32 },
  { 37, 10, 11, 13, 4, -32 },
  { 51, 20, 32, 20, 1, -32 },
  { 131, 19, 37, 19, 0, -34 },
  { 219, 22, 34, 27, 3, -33 },
  { 313, 19, 33, 20, 0, -33 },
  { 392, 4, 11, 7, 5, -32 },
  { 398, 13, 39, 11, 1, -32 },
  { 462, 13, 39, 11, -3, -32 },
  { 526, 14, 14, 18, 5, -34 },
  { 551, 17, 21, 20, 2, -26 },
  { 596, 6, 11, 8, -2, -5 },
  { 605, 10, 2, 12, 1, -13 },
  { 608, 3, 3, 8, 1, -3 },
  { 610, 19, 32, 14, -2, -32 },
  { 686, 17, 33, 19, 1, -33 },
  { 757, 9, 32, 19, 6, -32 },
  { 793, 19, 33, 19, -1, -33 },
  { 872, 18, 34, 19, 0, -33 },
  { 949, 18, 32, 19, 0, -32 },
  { 1021, 19, 32, 19, 0, -32 },
  { 1097, 17, 33, 19, 2, -33 },
  { 1168, 17, 32, 19, 3, -32 },
  { 1236, 19, 33, 19, 0, -33 },
  { 1315, 18, 33, 19, 0, -33 },
  { 1390, 8, 24, 8, 0, -24 },
  { 1414, 10, 30, 8, -2, -24 },
  { 1452, 17, 20, 20, 2, -26 },
  { 1495, 17, 11, 20, 2, -21 },
  { 1519, 17, 20, 20, 2, -26 },
  { 1562, 14, 33, 13, 1, -33 },
  { 1620, 25, 36, 28, 2, -32 },
  { 1733, 18, 32, 18, -3, -32 },
  { 1805, 19, 32, 20, 1, -32 },
  { 1881, 20, 33, 19, 2, -33 },
  { 1964, 20, 32, 22, 1, -32 },
  { 2044, 19, 32, 18, 1, -32 },
  { 2120, 19, 32, 17, 1, -32 },
  { 2196, 22, 33, 24, 2, -33 },
  { 2287, 23, 32, 23, 1, -32 },
  { 2379, 15, 32, 10, -2, -32 },
  { 2439, 16, 40, 8, -7, -32 },
  { 2519, 21, 32, 19, 1, -32 },
  { 2603, 12, 32, 16, 1, -32 },
  { 2651, 29, 32, 30, 1, -32 },
  { 2767, 23, 32, 24, 1, -32 },
  { 2859, 21, 33, 24, 2, -33 },
  { 2946, 18, 32, 19, 1, -32 },
  { 3018, 21, 41, 24, 2, -33 },
  { 3126, 18, 32, 19, 1, -32 },
  { 3198, 20, 33, 18, -1, -33 },
  { 3281, 16, 32, 16, 4, -32 },
  { 3345, 22, 32, 23, 2, -32 },
  { 3433, 18, 32, 19, 4, -32 },
  { 3505, 30, 32, 30, 4, -32 },
  { 3625, 23, 32, 17, -3, -32 },
  { 3717, 16, 32, 16, 4, -32 },
  { 3781, 20, 32, 17, -1, -32 },
  { 3861, 17, 39, 13, -1, -32 },
  { 3944, 6, 32, 14, 5, -32 },
  { 3968, 16, 39, 13, -3, -32 },
  { 4046, 18, 17, 20, 1, -32 },
  { 4085, 14, 2, 14, -4, 4 },
  { 4089, 4, 7, 10, 7, -34 },
  { 4093, 17, 24, 20, 2, -24 },
  { 4144, 17, 34, 20, 1, -34 },
  { 4217, 14, 24, 15, 2, -24 },
  { 4259, 19, 34, 20, 2, -34 },
  { 4340, 14, 24, 17, 2, -24 },
  { 4382, 21, 45, 10, -6, -34 },
  { 4501, 19, 35, 20, 0, -24 },
  { 4585, 16, 34, 19, 1, -34 },
  { 4653, 8, 32, 8, 1, -32 },
  { 4685, 15, 43, 8, -6, -32 },
  { 4766, 17, 34, 16, 1, -34 },
  { 4839, 9, 34, 8, 1, -34 },
  { 4878, 26, 24, 29, 1, -24 },
  { 4956, 16, 24, 19, 1, -24 },
  { 5004, 16, 24, 19, 2, -24 },
  { 5052, 20, 34, 20, -2, -24 },
  { 5137, 17, 35, 20, 2, -24 },
  { 5212, 13, 24, 13, 1, -24 },
  { 5251, 15, 24, 15, 0, -24 },
  { 5296, 10, 30, 10, 1, -30 },
  { 5334, 16, 24, 19, 2, -24 },
  { 5382, 15, 24, 15, 2, -24 },
  { 5427, 23, 24, 24, 3, -24 },
  { 5496, 19, 24, 16, -2, -24 },
  { 5553, 23, 35, 15, -5, -24 },
  { 5654, 15, 24, 14, -1, -24 },
  { 5699, 16, 39, 14, 1, -32 },
  { 5777, 1, 45, 18, 9, -34 },
  { 5783, 16, 39, 14, -3, -32 },
  { 5861, 17, 4, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC45PT7B_H_
