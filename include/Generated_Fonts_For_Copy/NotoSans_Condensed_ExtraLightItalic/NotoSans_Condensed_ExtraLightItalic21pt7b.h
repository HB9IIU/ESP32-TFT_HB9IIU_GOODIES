#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x00, 0x23, 0x00, 0x4A,
  0xA5, 0x29, 0x00, 0x04, 0x81, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0x41, 0x20,
  0x48, 0x12, 0x3F, 0xC2, 0x40, 0x90, 0x44, 0x12, 0x04, 0x80, 0x02, 0x01,
  0x07, 0xE4, 0x82, 0x41, 0x20, 0xA0, 0x30, 0x08, 0x06, 0x02, 0x82, 0x41,
  0x20, 0x93, 0xF0, 0x20, 0x20, 0x00, 0x38, 0x49, 0x11, 0x22, 0x24, 0x88,
  0x91, 0x14, 0x22, 0xBC, 0xA9, 0x6A, 0x21, 0x44, 0x48, 0x89, 0x22, 0x24,
  0x44, 0x90, 0xE0, 0x0E, 0x08, 0x84, 0x42, 0x21, 0x20, 0xA0, 0x20, 0x30,
  0x28, 0xA2, 0x61, 0x50, 0xA8, 0x24, 0x31, 0xE4, 0x56, 0x80, 0x08, 0x84,
  0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x86, 0x00, 0x10, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x08, 0x84, 0x44, 0x00, 0x08, 0x23,
  0x41, 0xF2, 0x89, 0x02, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x29, 0x28, 0xF0, 0x70, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x1E,
  0x44, 0x8A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x28, 0x51, 0x1C,
  0x00, 0x35, 0x92, 0x22, 0x24, 0x44, 0x44, 0x88, 0x80, 0x1F, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFC,
  0x1F, 0x10, 0x80, 0x20, 0x10, 0x10, 0x08, 0x18, 0x38, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x23, 0xE0, 0x01, 0x03, 0x03, 0x05, 0x09, 0x12, 0x12,
  0x22, 0x42, 0x42, 0x84, 0x7F, 0x04, 0x04, 0x08, 0x1F, 0x88, 0x04, 0x04,
  0x02, 0x01, 0x00, 0xF0, 0x04, 0x02, 0x00, 0x80, 0x80, 0x40, 0x20, 0x23,
  0xE0, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x40, 0xBC, 0xC2, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x88, 0x78, 0x7F, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x0F, 0x08, 0x48, 0x24, 0x12,
  0x10, 0x88, 0x58, 0x38, 0x22, 0x21, 0x20, 0x90, 0x48, 0x24, 0x11, 0xF0,
  0x0E, 0x11, 0x21, 0x21, 0x41, 0x41, 0x41, 0x23, 0x3D, 0x01, 0x02, 0x02,
  0x04, 0x08, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x10, 0x88, 0x40, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x06, 0x18, 0x60, 0x80, 0x78, 0x10, 0x41, 0x04, 0x21, 0x08, 0x41,
  0x08, 0x00, 0x02, 0x08, 0x00, 0x07, 0xC1, 0x82, 0x20, 0x22, 0x01, 0x43,
  0x14, 0xC9, 0x89, 0x19, 0x12, 0x91, 0x29, 0x22, 0x92, 0x49, 0x64, 0x89,
  0x88, 0x00, 0x80, 0x04, 0x00, 0x3E, 0x00, 0x03, 0x03, 0x05, 0x05, 0x09,
  0x09, 0x11, 0x11, 0x1F, 0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x1F, 0x08,
  0x44, 0x22, 0x12, 0x09, 0x04, 0x8C, 0x7C, 0x21, 0x20, 0x90, 0x48, 0x24,
  0x12, 0x13, 0xF0, 0x0F, 0x88, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0xF0, 0x1F, 0x04, 0x21, 0x04,
  0x41, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x50, 0x24, 0x09, 0x04, 0x41,
  0x11, 0x8F, 0x80, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x7C,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0xF0, 0x1F, 0x88, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x7C, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x00, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x0E, 0x84,
  0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10, 0x43, 0xF0, 0x10, 0x22, 0x04, 0x40,
  0x88, 0x22, 0x04, 0x40, 0x88, 0x11, 0xFE, 0x20, 0x88, 0x11, 0x02, 0x20,
  0x44, 0x08, 0x82, 0x20, 0x40, 0x1E, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x3C, 0x00, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x43, 0x00,
  0x10, 0x44, 0x21, 0x10, 0x48, 0x22, 0x09, 0x02, 0x80, 0xE0, 0x28, 0x11,
  0x04, 0x41, 0x10, 0x42, 0x10, 0x88, 0x20, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x0F, 0xC0, 0x18, 0x04, 0x60, 0x31, 0x80,
  0xC6, 0x06, 0x28, 0x18, 0xA0, 0xA2, 0x84, 0x8A, 0x12, 0x28, 0x91, 0x12,
  0x44, 0x51, 0x11, 0x44, 0x46, 0x11, 0x18, 0x88, 0x42, 0x00, 0x18, 0x23,
  0x04, 0x60, 0x8C, 0x12, 0x42, 0x48, 0x89, 0x11, 0x22, 0x22, 0x48, 0x49,
  0x0A, 0x21, 0x44, 0x18, 0x83, 0x20, 0x40, 0x0F, 0x04, 0x22, 0x05, 0x01,
  0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10,
  0x87, 0xC0, 0x1F, 0x08, 0x44, 0x22, 0x12, 0x09, 0x04, 0x84, 0x44, 0x3C,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01,
  0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10,
  0x87, 0xC0, 0x20, 0x08, 0x01, 0x00, 0x40, 0x1F, 0x08, 0x44, 0x22, 0x12,
  0x09, 0x04, 0x84, 0x44, 0x3C, 0x22, 0x11, 0x08, 0x84, 0x22, 0x12, 0x08,
  0x1F, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x23, 0xE0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x00, 0x20, 0x48, 0x12, 0x04, 0x82,
  0x40, 0x90, 0x24, 0x09, 0x02, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20,
  0x87, 0xC0, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90,
  0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0x82, 0x06, 0x08, 0x28, 0x60, 0xA1, 0x84,
  0x86, 0x12, 0x28, 0x88, 0xA2, 0x24, 0x88, 0x92, 0x42, 0x89, 0x0A, 0x28,
  0x28, 0xA0, 0xC2, 0x83, 0x0C, 0x08, 0x30, 0x00, 0x10, 0x42, 0x20, 0x88,
  0x24, 0x09, 0x02, 0x80, 0x40, 0x10, 0x0C, 0x05, 0x01, 0x20, 0x88, 0x42,
  0x10, 0x88, 0x20, 0x83, 0x06, 0x14, 0x48, 0x8A, 0x14, 0x30, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x00, 0x0F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0F, 0xE0,
  0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0xE0, 0x92, 0x24, 0x92, 0x48, 0x92, 0x48, 0x1E, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x11, 0xE0, 0x08, 0x14, 0x14, 0x24, 0x42, 0x42, 0x82, 0x81, 0xFE, 0x94,
  0x3D, 0x23, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x2F, 0x31, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x42, 0xC2, 0xBC, 0x3D, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x80,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x11, 0xE9, 0x0C, 0x84, 0x82, 0x41, 0x20,
  0x90, 0x48, 0x44, 0x22, 0x31, 0xE8, 0x3C, 0x85, 0x0C, 0x28, 0x9E, 0x20,
  0x40, 0x81, 0x01, 0xE0, 0x01, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x03, 0xC0,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0xE0, 0x00, 0x1E, 0x88, 0xC8, 0x48, 0x24,
  0x12, 0x09, 0x04, 0x84, 0x42, 0x23, 0x1E, 0x80, 0x40, 0x40, 0x20, 0x21,
  0xE0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x2F, 0x31, 0x21, 0x21, 0x21, 0x41,
  0x42, 0x42, 0x42, 0x82, 0x82, 0x11, 0x00, 0x22, 0x22, 0x24, 0x44, 0x48,
  0x80, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x87, 0x00, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x21, 0x22, 0x24, 0x28, 0x30, 0x68, 0x48, 0x48, 0x44, 0x84, 0x84, 0x11,
  0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x88, 0x2E, 0x71, 0x8C, 0x48, 0x42,
  0x42, 0x12, 0x21, 0x21, 0x09, 0x08, 0x48, 0x42, 0x42, 0x14, 0x21, 0x21,
  0x08, 0x2F, 0x31, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x82, 0x82,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x11, 0xE0, 0x17, 0x86,
  0x21, 0x04, 0x41, 0x10, 0x88, 0x22, 0x08, 0x82, 0x21, 0x18, 0x45, 0xE1,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x3D, 0x43, 0x42, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x8C, 0xF4, 0x04, 0x08, 0x08, 0x08, 0x08, 0x2E, 0x60,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x3E, 0x81, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x08, 0x13, 0xC0, 0x22, 0x4F, 0x44, 0x48, 0x88, 0x88,
  0x8C, 0x41, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x84, 0x84, 0x8C, 0xF4,
  0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0xA1, 0x81, 0x00, 0x84, 0x31,
  0x86, 0x31, 0x46, 0x29, 0x49, 0x29, 0x29, 0x45, 0x28, 0xC5, 0x18, 0x42,
  0x08, 0x00, 0x11, 0x88, 0x84, 0x81, 0x80, 0xC0, 0x40, 0x50, 0x48, 0x24,
  0x22, 0x20, 0x80, 0x10, 0x44, 0x21, 0x08, 0x22, 0x09, 0x02, 0x40, 0xA0,
  0x28, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x00, 0x1F,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x06, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x41, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x80, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x04, 0x0C, 0x20, 0x81, 0x02, 0x04, 0x08, 0x21, 0xC0, 0xF9, 0x06,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 15, 4, 0, -15 },
  { 11, 5, 5, 6, 2, -15 },
  { 15, 10, 15, 9, 0, -15 },
  { 34, 9, 17, 9, 0, -16 },
  { 54, 11, 15, 13, 1, -15 },
  { 75, 9, 15, 9, 0, -15 },
  { 92, 2, 5, 3, 2, -15 },
  { 94, 5, 18, 5, 1, -15 },
  { 106, 5, 18, 5, -1, -15 },
  { 118, 7, 7, 8, 2, -16 },
  { 125, 8, 9, 10, 1, -12 },
  { 134, 3, 5, 4, -1, -2 },
  { 136, 4, 1, 6, 1, -6 },
  { 137, 2, 2, 4, 0, -2 },
  { 138, 9, 15, 6, -1, -15 },
  { 155, 7, 15, 9, 1, -15 },
  { 169, 4, 15, 9, 3, -15 },
  { 177, 8, 15, 9, 0, -15 },
  { 192, 9, 15, 9, 0, -15 },
  { 209, 8, 15, 9, 0, -15 },
  { 224, 9, 15, 9, 0, -15 },
  { 241, 8, 15, 9, 1, -15 },
  { 256, 8, 15, 9, 1, -15 },
  { 271, 9, 15, 9, 0, -15 },
  { 288, 8, 15, 9, 0, -15 },
  { 303, 4, 11, 4, 0, -11 },
  { 309, 5, 14, 4, -1, -11 },
  { 318, 8, 9, 10, 1, -12 },
  { 327, 8, 5, 10, 1, -10 },
  { 332, 8, 9, 10, 1, -12 },
  { 341, 6, 15, 6, 1, -15 },
  { 353, 12, 17, 13, 1, -15 },
  { 379, 8, 15, 8, -1, -15 },
  { 394, 9, 15, 9, 0, -15 },
  { 411, 9, 15, 9, 1, -15 },
  { 428, 10, 15, 10, 0, -15 },
  { 447, 9, 15, 8, 0, -15 },
  { 464, 9, 15, 8, 0, -15 },
  { 481, 10, 15, 11, 1, -15 },
  { 500, 11, 15, 11, 0, -15 },
  { 521, 7, 15, 5, -1, -15 },
  { 535, 7, 19, 4, -3, -15 },
  { 552, 10, 15, 9, 0, -15 },
  { 571, 6, 15, 8, 0, -15 },
  { 583, 14, 15, 14, 0, -15 },
  { 610, 11, 15, 11, 0, -15 },
  { 631, 10, 15, 11, 1, -15 },
  { 650, 9, 15, 9, 0, -15 },
  { 667, 10, 19, 11, 1, -15 },
  { 691, 9, 15, 9, 0, -15 },
  { 708, 9, 15, 8, 0, -15 },
  { 725, 7, 15, 8, 2, -15 },
  { 739, 10, 15, 11, 1, -15 },
  { 758, 8, 15, 9, 2, -15 },
  { 773, 14, 15, 14, 2, -15 },
  { 800, 10, 15, 8, -1, -15 },
  { 819, 7, 15, 8, 2, -15 },
  { 833, 10, 15, 8, -1, -15 },
  { 852, 7, 18, 6, 0, -15 },
  { 868, 3, 15, 7, 2, -15 },
  { 874, 7, 18, 6, -1, -15 },
  { 890, 8, 8, 9, 1, -15 },
  { 898, 7, 1, 6, -2, 2 },
  { 899, 2, 3, 5, 3, -16 },
  { 900, 8, 11, 9, 1, -11 },
  { 911, 8, 16, 9, 0, -16 },
  { 927, 6, 11, 7, 1, -11 },
  { 936, 9, 16, 9, 1, -16 },
  { 954, 7, 11, 8, 1, -11 },
  { 964, 10, 21, 5, -3, -16 },
  { 991, 9, 16, 9, 0, -11 },
  { 1009, 8, 16, 9, 0, -16 },
  { 1025, 4, 15, 4, 0, -15 },
  { 1033, 7, 20, 4, -3, -15 },
  { 1051, 8, 16, 7, 0, -16 },
  { 1067, 4, 16, 4, 0, -16 },
  { 1075, 13, 11, 14, 0, -11 },
  { 1093, 8, 11, 9, 0, -11 },
  { 1104, 7, 11, 9, 1, -11 },
  { 1114, 10, 16, 9, -1, -11 },
  { 1134, 8, 16, 9, 1, -11 },
  { 1150, 7, 11, 6, 0, -11 },
  { 1160, 7, 11, 7, 0, -11 },
  { 1170, 4, 14, 5, 1, -14 },
  { 1177, 8, 11, 9, 1, -11 },
  { 1188, 7, 11, 7, 1, -11 },
  { 1198, 11, 11, 11, 1, -11 },
  { 1214, 9, 11, 7, -1, -11 },
  { 1227, 10, 16, 7, -2, -11 },
  { 1247, 8, 11, 6, -1, -11 },
  { 1258, 7, 18, 7, 1, -15 },
  { 1274, 1, 21, 9, 4, -16 },
  { 1277, 7, 18, 7, -1, -15 },
  { 1293, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC21PT7B_H_
