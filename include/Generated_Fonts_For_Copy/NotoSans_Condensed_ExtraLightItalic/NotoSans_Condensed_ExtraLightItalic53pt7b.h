#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x31, 0x87, 0x30, 0x63, 0x06,
  0x30, 0x63, 0x06, 0x30, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0x84, 0x08,
  0x41, 0x8C, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0,
  0x00, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x04, 0x00,
  0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0E, 0x21, 0xC0, 0x60, 0x81, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x06, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x0D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x86, 0x00, 0x02, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x10,
  0x30, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x08, 0x08, 0x70, 0x3C, 0x27, 0x80,
  0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x80,
  0xEE, 0x00, 0x20, 0x30, 0x40, 0x0C, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x18, 0x18, 0x0C, 0x03, 0x06, 0x01, 0x80, 0x41, 0x80, 0x30, 0x18, 0x30,
  0x0C, 0x03, 0x0C, 0x01, 0x80, 0x61, 0x80, 0x30, 0x0C, 0x60, 0x06, 0x03,
  0x0C, 0x7C, 0xC0, 0x63, 0x1F, 0xD8, 0x08, 0xC7, 0x1F, 0x03, 0x18, 0xC1,
  0xE0, 0xC6, 0x30, 0x3C, 0x18, 0xC6, 0x06, 0xEE, 0x31, 0x80, 0xCF, 0x86,
  0x30, 0x18, 0x01, 0x84, 0x03, 0x00, 0x61, 0x80, 0x60, 0x0C, 0x30, 0x0C,
  0x03, 0x06, 0x03, 0x00, 0x60, 0x80, 0x60, 0x18, 0x30, 0x0C, 0x03, 0x06,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x30, 0x0C, 0x0C, 0x0C, 0x01, 0x83, 0x01, 0x80, 0x18,
  0xC0, 0x60, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF7, 0x00, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xEC, 0x00, 0x07, 0x18, 0x00, 0x38, 0x60, 0x31, 0xC1, 0xC0, 0xC6,
  0x03, 0x03, 0x30, 0x0C, 0x18, 0xC0, 0x18, 0x66, 0x00, 0x63, 0x18, 0x01,
  0xCC, 0x60, 0x03, 0x63, 0x00, 0x0D, 0x8C, 0x00, 0x1C, 0x30, 0x00, 0x70,
  0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x06, 0x00, 0x6C, 0x1C, 0x07, 0x18, 0x3C,
  0x78, 0x60, 0x7F, 0x81, 0xC0, 0x20, 0x00, 0x00, 0x18, 0xCE, 0x63, 0x18,
  0xC4, 0x63, 0x18, 0x84, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0xC0, 0xF0, 0x80, 0x38,
  0x80, 0x0E, 0x9F, 0x03, 0xFE, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0x40, 0x18,
  0x60, 0x30, 0x20, 0x60, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC3,
  0x04, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0x03, 0x00,
  0xC0, 0x70, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x38, 0x03, 0x9E, 0x00, 0x3F, 0x80, 0x00, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x0F, 0x07, 0x61, 0xCC, 0x73, 0x38, 0x66, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0E, 0x03, 0x80, 0x20, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xEF, 0x80, 0x3C, 0x03, 0x00,
  0x40, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x20, 0x07, 0x80, 0xF0, 0x78, 0x03, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x48, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x18,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x20, 0x07, 0x00, 0xF0, 0x78, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFB, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x3F, 0x80, 0x33, 0xFE, 0x03, 0x30, 0x18, 0x1B,
  0x00, 0xE0, 0xF0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x03,
  0x1C, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x06, 0x07, 0x00, 0x70, 0x18, 0x03, 0x00, 0xE0, 0x30, 0x03, 0xCF,
  0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF7, 0xC0,
  0x0E, 0x03, 0x80, 0x70, 0x06, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x18, 0x0E, 0x00,
  0x30, 0x70, 0x00, 0x67, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7B,
  0x80, 0x03, 0x86, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x70,
  0x30, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1E, 0x1E, 0x00,
  0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01,
  0xC0, 0xE0, 0x38, 0x06, 0x07, 0x00, 0x70, 0x60, 0x03, 0x0E, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00,
  0x71, 0x80, 0x0E, 0x18, 0x00, 0xE1, 0xC0, 0x1E, 0x0C, 0x07, 0x60, 0x79,
  0xE4, 0x03, 0xF8, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0xC7, 0xC0, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x07, 0x07, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0xE0, 0xC0,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0xFC, 0x08, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x7F,
  0x03, 0x18, 0x07, 0xBC, 0x0C, 0x60, 0x38, 0x30, 0x33, 0x01, 0xC0, 0xC0,
  0xCC, 0x06, 0x06, 0x03, 0x30, 0x30, 0x18, 0x0D, 0x80, 0xC0, 0x60, 0x26,
  0x06, 0x01, 0x81, 0x98, 0x18, 0x0C, 0x06, 0x60, 0xC0, 0x30, 0x1B, 0x03,
  0x00, 0xC0, 0x6C, 0x0C, 0x03, 0x03, 0x30, 0x30, 0x18, 0x0C, 0xC0, 0x80,
  0x60, 0x33, 0x02, 0x01, 0x81, 0x8C, 0x08, 0x0E, 0x06, 0x30, 0x20, 0x38,
  0x30, 0xC0, 0xC1, 0xE0, 0xC3, 0x03, 0x0D, 0x86, 0x0C, 0x0F, 0xE3, 0xF0,
  0x30, 0x0F, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x06, 0x01, 0xE0, 0x0C,
  0x00, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x38,
  0x0C, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x60, 0x1C, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x06, 0x00, 0x78, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xC0,
  0x10, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x01, 0x80, 0xF8, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x0E, 0x03, 0x80, 0x06, 0x03, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x60, 0x03, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x3C, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x04, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0x9F, 0xC0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0x10, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x8C,
  0x00, 0x7F, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x80,
  0x0C, 0x00, 0xF8, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x38,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x03, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x6C, 0x00, 0x01, 0xE6, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x6C, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x03, 0x60, 0x1B, 0x00,
  0x00, 0x6C, 0x03, 0x20, 0x00, 0x19, 0x80, 0x66, 0x00, 0x03, 0x30, 0x0C,
  0xC0, 0x00, 0xCC, 0x03, 0x18, 0x00, 0x19, 0x80, 0x63, 0x00, 0x06, 0x30,
  0x0C, 0x60, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x31, 0x80, 0x06,
  0x30, 0x0C, 0x30, 0x01, 0x86, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x30, 0xC0,
  0x0C, 0x18, 0x06, 0x18, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x30,
  0x30, 0x0C, 0x18, 0x06, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x60,
  0x18, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x00, 0xC0, 0x60, 0xC0,
  0x60, 0x18, 0x0C, 0x18, 0x0C, 0x03, 0x01, 0x86, 0x01, 0x80, 0x60, 0x30,
  0xC0, 0x60, 0x18, 0x06, 0x30, 0x0C, 0x03, 0x00, 0xC6, 0x01, 0x80, 0x60,
  0x09, 0x80, 0x30, 0x0C, 0x01, 0xB0, 0x06, 0x01, 0x80, 0x3C, 0x01, 0x80,
  0x60, 0x07, 0x80, 0x30, 0x0C, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0x60, 0x1E, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x60, 0x1E, 0x00, 0x06, 0x03,
  0x30, 0x00, 0x40, 0x33, 0x00, 0x0C, 0x03, 0x30, 0x00, 0xC0, 0x33, 0x00,
  0x0C, 0x03, 0x18, 0x00, 0xC0, 0x61, 0x80, 0x18, 0x06, 0x18, 0x01, 0x80,
  0x61, 0x80, 0x18, 0x06, 0x0C, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x0C, 0x0C,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x03, 0x06, 0x01, 0x80,
  0x30, 0x60, 0x18, 0x03, 0x06, 0x03, 0x00, 0x30, 0x40, 0x30, 0x01, 0x8C,
  0x03, 0x00, 0x18, 0xC0, 0x30, 0x01, 0x8C, 0x03, 0x00, 0x1C, 0xC0, 0x60,
  0x00, 0xD8, 0x06, 0x00, 0x0D, 0x80, 0x60, 0x00, 0xD8, 0x06, 0x00, 0x0F,
  0x80, 0x60, 0x00, 0x78, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x0C, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x0F, 0x00, 0x60, 0x0E, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x70, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x06,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x18, 0x0F, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x38,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x1C, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x18,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x78, 0x0F, 0x83,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E,
  0x01, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x0E, 0x00, 0x80, 0x60, 0x04, 0x03, 0x00, 0x20, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0x00,
  0x1B, 0x00, 0x07, 0x00, 0x03, 0x60, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x14,
  0x00, 0x19, 0x80, 0x06, 0x80, 0x06, 0x30, 0x00, 0xD0, 0x00, 0xC6, 0x00,
  0x32, 0x00, 0x38, 0xC0, 0x06, 0x40, 0x06, 0x18, 0x00, 0x88, 0x00, 0xC3,
  0x00, 0x31, 0x00, 0x30, 0x60, 0x06, 0x20, 0x06, 0x0C, 0x01, 0x84, 0x01,
  0xC1, 0x80, 0x30, 0x80, 0x30, 0x30, 0x0C, 0x10, 0x06, 0x06, 0x01, 0x82,
  0x01, 0x80, 0xC0, 0x30, 0x40, 0x30, 0x18, 0x0C, 0x08, 0x0C, 0x03, 0x01,
  0x81, 0x01, 0x80, 0x60, 0x60, 0x60, 0x30, 0x0C, 0x0C, 0x0C, 0x0C, 0x01,
  0x81, 0x01, 0x81, 0x80, 0x30, 0x60, 0x30, 0x60, 0x06, 0x0C, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x18, 0x60, 0x03, 0x18, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x0C, 0x60, 0x01, 0x98,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x06, 0x60, 0x00,
  0xD8, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B,
  0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x0E, 0x18, 0x01, 0x83,
  0x00, 0x60, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x02,
  0x07, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06,
  0x70, 0x00, 0xCC, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x02, 0x03, 0x03, 0x03, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x01, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0x18, 0x43, 0x08, 0x61, 0x00, 0x10, 0x00, 0x0F, 0xE1, 0x01,
  0xE7, 0x30, 0x30, 0x1B, 0x06, 0x00, 0xB0, 0xC0, 0x0A, 0x1C, 0x00, 0xE1,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x70, 0xC0, 0x07, 0x0C, 0x00, 0xF0, 0xC0, 0x0A, 0x0E, 0x01, 0x60, 0x60,
  0x36, 0x03, 0x9E, 0x60, 0x1F, 0x86, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x20, 0x06, 0x1F, 0xC0, 0x67, 0x1E, 0x06, 0xE0, 0x60, 0x78,
  0x03, 0x07, 0x80, 0x30, 0xF0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x18, 0x70, 0x01,
  0x85, 0x00, 0x30, 0xD8, 0x07, 0x0D, 0x80, 0xE0, 0xCE, 0x3C, 0x08, 0x7F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x78, 0xC0, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x8E, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x0F, 0xE3, 0x00, 0x3C, 0xE6,
  0x00, 0xC0, 0x6C, 0x03, 0x00, 0x58, 0x0C, 0x00, 0xF0, 0x38, 0x01, 0xC0,
  0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xE0, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x3C,
  0x06, 0x00, 0xD8, 0x0E, 0x01, 0xA0, 0x0C, 0x06, 0xC0, 0x0E, 0x39, 0x80,
  0x0F, 0xC3, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x71,
  0xC0, 0x60, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x30,
  0x01, 0x98, 0x01, 0x8C, 0x01, 0xCC, 0x01, 0xC6, 0x01, 0xC3, 0x07, 0xC3,
  0xFF, 0x81, 0xFC, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x02, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x20, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x11, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0x0C, 0x01, 0xE7, 0x10, 0x06, 0x03, 0x60, 0x18,
  0x02, 0xC0, 0x60, 0x07, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x0C, 0x0E, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x01, 0xE0, 0x30, 0x06, 0xC0, 0x70,
  0x0F, 0x00, 0x60, 0x76, 0x00, 0xF1, 0xCC, 0x00, 0xFF, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x20, 0x06, 0x00, 0x70, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x20, 0x06, 0x3F, 0xC0, 0x67, 0x9E, 0x06,
  0xC0, 0x60, 0x78, 0x06, 0x05, 0x00, 0x30, 0xF0, 0x02, 0x0E, 0x00, 0x60,
  0xE0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x8E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x60, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1,
  0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x19,
  0xC0, 0x01, 0xB6, 0x00, 0x16, 0x60, 0x03, 0xC6, 0x00, 0x38, 0x60, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x04, 0x00, 0x40, 0x0C, 0x7F, 0x07,
  0xF0, 0x19, 0xC7, 0x1C, 0x70, 0x36, 0x06, 0x60, 0x70, 0x78, 0x07, 0x80,
  0x60, 0xA0, 0x0E, 0x00, 0xC3, 0x80, 0x1C, 0x01, 0x87, 0x00, 0x30, 0x03,
  0x0C, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x0C, 0x30, 0x03, 0x00, 0x38,
  0xC0, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x01, 0x86,
  0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x30, 0x01, 0x80, 0x18, 0x60,
  0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x00, 0xC6, 0x00,
  0x30, 0x03, 0x0C, 0x00, 0x60, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x03,
  0x00, 0x18, 0x60, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0xC3, 0x00, 0x18,
  0x01, 0x86, 0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x63, 0xFC, 0x06, 0x79, 0xE0, 0x6C, 0x06, 0x07, 0x80, 0x60, 0x50,
  0x07, 0x0F, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3,
  0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18,
  0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xE0, 0x07, 0x1E, 0x01, 0x80, 0xE0, 0x60, 0x0C, 0x18,
  0x01, 0x87, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x0C, 0x01,
  0x81, 0xC0, 0xE0, 0x1E, 0x78, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x01, 0x87, 0xF0, 0x03, 0x38, 0xF0, 0x06, 0xE0, 0x60, 0x0D,
  0x80, 0x60, 0x16, 0x00, 0xC0, 0x78, 0x01, 0x80, 0xF0, 0x03, 0x01, 0xC0,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0x81,
  0xC0, 0x03, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x60, 0x34,
  0x01, 0xC0, 0x6C, 0x07, 0x00, 0xCE, 0x3C, 0x01, 0x8F, 0xE0, 0x03, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xF0, 0xC0, 0x79, 0xC4, 0x06, 0x03, 0x60, 0x60, 0x0B, 0x06, 0x00,
  0x78, 0x70, 0x03, 0x83, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xE0,
  0xC0, 0x1B, 0x07, 0x00, 0xF0, 0x18, 0x0D, 0x80, 0xF1, 0xCC, 0x03, 0xFC,
  0x60, 0x03, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x06,
  0x3F, 0x06, 0x79, 0x06, 0xC0, 0x07, 0x80, 0x05, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x81,
  0xE1, 0xE0, 0xC0, 0x10, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x20, 0x0C, 0x1C, 0x1E, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x03, 0xFF, 0x3F,
  0xF0, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x20, 0x7E, 0x00, 0x80, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0xE0,
  0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xC0, 0x34, 0x0E, 0x06, 0x40, 0x71, 0xCC,
  0x03, 0xF8, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x06, 0x01,
  0x83, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0xE0,
  0x06, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x03, 0x60, 0x0F, 0x00, 0x6C, 0x01, 0xE0, 0x0D, 0x80,
  0x2C, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x01, 0xB0, 0x18, 0xC0, 0x66, 0x03,
  0x18, 0x0C, 0xC0, 0x63, 0x03, 0x18, 0x18, 0x60, 0x63, 0x03, 0x0C, 0x18,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x86, 0x06, 0x18, 0x10, 0xC0,
  0xC3, 0x02, 0x18, 0x18, 0xC0, 0x46, 0x03, 0x18, 0x08, 0xC0, 0x66, 0x01,
  0x30, 0x0C, 0xC0, 0x26, 0x01, 0x90, 0x04, 0xC0, 0x36, 0x00, 0xB0, 0x06,
  0xC0, 0x16, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xE0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00,
  0x1B, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0xF8, 0x1E, 0x1D, 0x00, 0x3F,
  0xC8, 0x00, 0x38, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 38, 11, 1, -38 },
  { 54, 12, 14, 15, 5, -38 },
  { 75, 24, 38, 24, 1, -38 },
  { 189, 22, 43, 22, 0, -40 },
  { 308, 27, 39, 32, 3, -38 },
  { 440, 22, 39, 24, 0, -38 },
  { 548, 5, 14, 9, 5, -38 },
  { 557, 15, 46, 13, 1, -38 },
  { 644, 15, 46, 13, -4, -38 },
  { 731, 16, 17, 21, 6, -40 },
  { 765, 21, 25, 24, 2, -31 },
  { 831, 7, 12, 9, -2, -5 },
  { 842, 12, 2, 15, 1, -15 },
  { 845, 3, 4, 10, 1, -4 },
  { 847, 22, 38, 16, -2, -38 },
  { 952, 19, 39, 22, 2, -38 },
  { 1045, 11, 38, 22, 7, -38 },
  { 1098, 22, 38, 22, -1, -38 },
  { 1203, 22, 39, 22, 0, -38 },
  { 1311, 22, 38, 22, -1, -38 },
  { 1416, 22, 39, 22, 0, -38 },
  { 1524, 21, 39, 22, 2, -38 },
  { 1627, 20, 38, 22, 3, -38 },
  { 1722, 22, 39, 22, 0, -38 },
  { 1830, 20, 39, 22, 1, -38 },
  { 1928, 8, 28, 10, 1, -28 },
  { 1956, 11, 35, 10, -2, -28 },
  { 2005, 21, 23, 24, 2, -30 },
  { 2066, 20, 13, 24, 2, -25 },
  { 2099, 21, 23, 24, 2, -30 },
  { 2160, 16, 38, 16, 2, -38 },
  { 2236, 30, 43, 33, 2, -38 },
  { 2398, 21, 38, 21, -3, -38 },
  { 2498, 23, 38, 24, 1, -38 },
  { 2608, 23, 39, 22, 3, -38 },
  { 2721, 24, 38, 26, 1, -38 },
  { 2835, 22, 38, 21, 1, -38 },
  { 2940, 22, 38, 20, 1, -38 },
  { 3045, 25, 39, 28, 3, -38 },
  { 3167, 27, 38, 27, 1, -38 },
  { 3296, 17, 38, 11, -2, -38 },
  { 3377, 19, 47, 10, -8, -38 },
  { 3489, 25, 38, 22, 1, -38 },
  { 3608, 14, 38, 19, 1, -38 },
  { 3675, 35, 38, 35, 1, -38 },
  { 3842, 28, 38, 28, 1, -38 },
  { 3975, 24, 39, 28, 3, -38 },
  { 4092, 22, 38, 22, 1, -38 },
  { 4197, 24, 47, 28, 3, -38 },
  { 4338, 22, 38, 23, 1, -38 },
  { 4443, 23, 39, 21, -1, -38 },
  { 4556, 18, 38, 19, 5, -38 },
  { 4642, 25, 39, 27, 3, -38 },
  { 4764, 21, 38, 22, 5, -38 },
  { 4864, 35, 38, 36, 5, -38 },
  { 5031, 26, 38, 20, -3, -38 },
  { 5155, 19, 38, 19, 5, -38 },
  { 5246, 25, 38, 20, -2, -38 },
  { 5365, 19, 46, 15, -1, -38 },
  { 5475, 8, 38, 17, 5, -38 },
  { 5513, 19, 46, 15, -3, -38 },
  { 5623, 20, 20, 23, 2, -38 },
  { 5673, 16, 2, 16, -4, 5 },
  { 5677, 5, 8, 12, 8, -40 },
  { 5682, 20, 30, 23, 2, -29 },
  { 5757, 20, 41, 23, 1, -40 },
  { 5860, 17, 30, 18, 2, -29 },
  { 5924, 23, 41, 23, 2, -40 },
  { 6042, 17, 30, 20, 2, -29 },
  { 6106, 25, 54, 12, -7, -41 },
  { 6275, 23, 42, 23, 0, -29 },
  { 6396, 20, 40, 23, 1, -40 },
  { 6496, 10, 38, 9, 1, -38 },
  { 6544, 18, 51, 10, -7, -38 },
  { 6659, 20, 40, 19, 1, -40 },
  { 6759, 10, 40, 9, 1, -40 },
  { 6809, 31, 29, 34, 1, -29 },
  { 6922, 20, 29, 23, 1, -29 },
  { 6995, 19, 30, 23, 2, -29 },
  { 7067, 23, 41, 23, -2, -29 },
  { 7185, 21, 41, 23, 2, -29 },
  { 7293, 16, 29, 15, 1, -29 },
  { 7351, 17, 30, 17, 0, -29 },
  { 7415, 12, 36, 12, 1, -35 },
  { 7469, 20, 29, 23, 2, -28 },
  { 7542, 17, 28, 17, 3, -28 },
  { 7602, 27, 28, 28, 3, -28 },
  { 7697, 22, 28, 18, -2, -28 },
  { 7774, 27, 41, 18, -6, -28 },
  { 7913, 18, 28, 16, -1, -28 },
  { 7976, 18, 46, 17, 2, -38 },
  { 8080, 2, 53, 21, 10, -40 },
  { 8094, 18, 46, 17, -3, -38 },
  { 8198, 21, 5, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC53PT7B_H_
