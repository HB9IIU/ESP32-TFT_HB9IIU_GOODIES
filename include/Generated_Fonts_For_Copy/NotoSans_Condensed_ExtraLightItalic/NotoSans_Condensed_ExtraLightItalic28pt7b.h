#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x00, 0x00,
  0x21, 0x00, 0x45, 0x34, 0xA2, 0x8A, 0x29, 0x00, 0x01, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x40, 0x22, 0x02, 0x10, 0xFF, 0xE0, 0x88, 0x08, 0x40, 0x42,
  0x02, 0x20, 0x21, 0x01, 0x08, 0x7F, 0xF0, 0x44, 0x04, 0x20, 0x22, 0x01,
  0x10, 0x10, 0x80, 0x88, 0x00, 0x00, 0x80, 0x08, 0x07, 0xE0, 0xD3, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x05,
  0x80, 0x48, 0x04, 0xC0, 0x44, 0x08, 0x80, 0x88, 0xCB, 0x03, 0xC0, 0x08,
  0x01, 0x00, 0x10, 0x00, 0x3C, 0x08, 0x90, 0x44, 0x43, 0x11, 0x08, 0x84,
  0x42, 0x11, 0x08, 0x48, 0x21, 0x20, 0x89, 0x3A, 0x2D, 0x19, 0x2C, 0x7D,
  0x21, 0x04, 0x84, 0x24, 0x10, 0x90, 0x84, 0x42, 0x31, 0x08, 0x84, 0x44,
  0x11, 0x10, 0x38, 0x03, 0xC0, 0x44, 0x08, 0x40, 0x84, 0x08, 0x40, 0x8C,
  0x08, 0x80, 0x90, 0x06, 0x00, 0xC0, 0x1E, 0x02, 0x21, 0x62, 0x24, 0x12,
  0x81, 0x48, 0x1C, 0x80, 0x88, 0x18, 0x43, 0x47, 0xC4, 0x56, 0xA8, 0x03,
  0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x04,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0xC0, 0x04,
  0x04, 0x32, 0x07, 0x30, 0xE0, 0xC0, 0x90, 0x88, 0x02, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x32, 0x24, 0x48, 0x80, 0xFC, 0xC0, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x07, 0x82, 0x11, 0x04, 0x41, 0x20, 0x48, 0x14,
  0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x1A, 0x04,
  0x81, 0x20, 0x84, 0x41, 0xE0, 0x09, 0xDB, 0x31, 0x08, 0x42, 0x31, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x21, 0x00, 0x07, 0xE0, 0xC3, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xF8,
  0x0F, 0xC3, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x81, 0xE0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x32, 0x0C, 0x7F, 0x00, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x90, 0x14, 0x04,
  0x81, 0x10, 0x22, 0x08, 0x82, 0x10, 0x42, 0x10, 0x44, 0x09, 0x82, 0x3F,
  0xF8, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x07, 0xF0, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x3F, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x83,
  0x0F, 0xC0, 0x03, 0xE0, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x5F, 0x0C, 0x13, 0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x81, 0x10, 0x21, 0x08, 0x3E, 0x00, 0x7F, 0xC0, 0x10, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x07, 0xC0, 0x82, 0x18, 0x21,
  0x01, 0x10, 0x31, 0x02, 0x10, 0x20, 0x84, 0x0D, 0x80, 0x60, 0x19, 0x02,
  0x18, 0x40, 0x84, 0x04, 0x80, 0x48, 0x04, 0x80, 0x4C, 0x08, 0x41, 0x83,
  0xE0, 0x07, 0xC1, 0x0C, 0x40, 0x88, 0x13, 0x02, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x64, 0x0C, 0xC3, 0x0F, 0xA0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x18, 0x7C, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x40, 0x00, 0x3E, 0x21, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x01, 0xF8,
  0x02, 0x04, 0x0C, 0x02, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x21, 0xF1,
  0x42, 0x11, 0x42, 0x21, 0x44, 0x21, 0x84, 0x22, 0x88, 0x42, 0x88, 0x42,
  0x88, 0x44, 0x88, 0xC4, 0x89, 0x48, 0x87, 0x30, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x0A,
  0x01, 0x20, 0x12, 0x03, 0x20, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0xFE,
  0x08, 0x21, 0x02, 0x10, 0x22, 0x02, 0x20, 0x26, 0x02, 0x40, 0x3C, 0x03,
  0x07, 0xE0, 0x41, 0x82, 0x04, 0x10, 0x30, 0x81, 0x84, 0x08, 0x40, 0x42,
  0x04, 0x10, 0x60, 0xFC, 0x0C, 0x30, 0x40, 0xC2, 0x02, 0x10, 0x10, 0x80,
  0x88, 0x04, 0x40, 0x42, 0x06, 0x10, 0x61, 0xFC, 0x00, 0x03, 0xF8, 0x30,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x41, 0x82, 0x04, 0x10,
  0x10, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x02,
  0x40, 0x32, 0x01, 0x10, 0x08, 0x80, 0xC8, 0x04, 0x40, 0x42, 0x04, 0x10,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0xFC, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0F, 0xF0, 0x07, 0xF0, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x3F, 0xC2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x01, 0xF8, 0x18, 0x10, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x0F, 0x30, 0x04,
  0xC0, 0x12, 0x00, 0x4C, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x82, 0x02,
  0x07, 0xF0, 0x04, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41,
  0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x08, 0x3F, 0xF0, 0xC0, 0x21, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x20, 0x18, 0x40, 0x20, 0x80, 0x41,
  0x00, 0x86, 0x03, 0x00, 0x0F, 0x81, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x1F, 0x00, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x00, 0x04,
  0x0C, 0x20, 0x60, 0x83, 0x02, 0x08, 0x08, 0x40, 0x22, 0x01, 0x10, 0x04,
  0x80, 0x16, 0x00, 0x78, 0x03, 0xA0, 0x0C, 0x80, 0x23, 0x00, 0x84, 0x02,
  0x10, 0x10, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x10, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x04, 0x00, 0x61, 0x80, 0x1C, 0x30,
  0x03, 0x06, 0x00, 0xE0, 0xA0, 0x14, 0x14, 0x06, 0x84, 0x80, 0xA0, 0x90,
  0x24, 0x12, 0x04, 0x82, 0x41, 0x10, 0x88, 0x22, 0x11, 0x08, 0x82, 0x21,
  0x10, 0x44, 0x42, 0x08, 0x88, 0x42, 0x0A, 0x18, 0x41, 0x42, 0x08, 0x30,
  0x41, 0x06, 0x08, 0x60, 0x81, 0x00, 0x04, 0x02, 0x18, 0x04, 0x30, 0x08,
  0x50, 0x30, 0xA0, 0x41, 0x40, 0x84, 0xC1, 0x08, 0x82, 0x11, 0x08, 0x22,
  0x10, 0xC6, 0x21, 0x04, 0x42, 0x08, 0x84, 0x12, 0x08, 0x34, 0x20, 0x28,
  0x40, 0x50, 0x80, 0xE1, 0x01, 0x86, 0x01, 0x00, 0x03, 0xE0, 0x20, 0x82,
  0x02, 0x20, 0x13, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x03, 0x80, 0x3C, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x04, 0x40, 0x62,
  0x02, 0x18, 0x20, 0x7E, 0x00, 0x07, 0xC0, 0x82, 0x08, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x10, 0x11, 0x03, 0x10, 0x21, 0x04, 0x33, 0x83, 0xC0, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x03,
  0xE0, 0x20, 0x82, 0x02, 0x20, 0x13, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x2C, 0x01, 0x40, 0x0A, 0x00, 0xD8,
  0x04, 0x40, 0x62, 0x02, 0x18, 0x20, 0x7E, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x07, 0xC0, 0x82, 0x08, 0x10, 0x81, 0x08, 0x10,
  0x81, 0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x3F, 0x82, 0x30, 0x21, 0x02,
  0x10, 0x21, 0x04, 0x10, 0x40, 0x84, 0x08, 0x40, 0x8C, 0x0C, 0x07, 0xE0,
  0x81, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x83, 0x0F, 0xE0, 0xFF, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x18, 0x04, 0x40, 0x21, 0x00, 0x84, 0x02,
  0x10, 0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80, 0x44, 0x02,
  0x10, 0x08, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x20, 0x10, 0x80, 0x41, 0x02,
  0x04, 0x18, 0x0F, 0xC0, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x48, 0x09, 0x02,
  0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x10, 0x44, 0x08, 0x81, 0x30, 0x24,
  0x04, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x00, 0x80, 0x80, 0x60, 0x20,
  0x28, 0x18, 0x0A, 0x06, 0x04, 0x82, 0x81, 0x20, 0xA0, 0x48, 0x28, 0x22,
  0x12, 0x08, 0x84, 0x84, 0x22, 0x21, 0x08, 0x88, 0xC2, 0x22, 0x20, 0x90,
  0x88, 0x24, 0x24, 0x0A, 0x09, 0x02, 0x82, 0x80, 0xC0, 0xA0, 0x30, 0x28,
  0x0C, 0x0C, 0x02, 0x03, 0x00, 0x04, 0x04, 0x08, 0x20, 0x20, 0x80, 0x84,
  0x02, 0x30, 0x08, 0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x04, 0x00, 0x38,
  0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x81,
  0x06, 0x04, 0x30, 0x10, 0xC0, 0x50, 0x34, 0x09, 0x04, 0x41, 0x10, 0x84,
  0x20, 0x90, 0x2C, 0x0A, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0xFF, 0x00, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE0, 0x88, 0x88, 0x44, 0x44,
  0x44, 0x42, 0x22, 0x22, 0x23, 0x11, 0x07, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xE0,
  0x02, 0x00, 0xC0, 0x34, 0x04, 0x81, 0x18, 0x21, 0x08, 0x21, 0x02, 0x40,
  0x58, 0x0A, 0x00, 0x80, 0xFF, 0xC9, 0x10, 0x0F, 0x23, 0x14, 0xC3, 0x10,
  0x24, 0x04, 0x80, 0x90, 0x24, 0x04, 0x80, 0x90, 0x12, 0x06, 0x40, 0x88,
  0x31, 0x8A, 0x1E, 0x40, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0xF0, 0xA3, 0x18, 0x22, 0x04, 0x40, 0x98, 0x12, 0x02, 0x40, 0x48,
  0x09, 0x02, 0x40, 0x48, 0x09, 0x82, 0x30, 0x89, 0xE0, 0x0F, 0x8C, 0x08,
  0x04, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x0F,
  0x21, 0x8A, 0x30, 0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0x48, 0x08, 0x80,
  0x88, 0x08, 0x81, 0x88, 0x18, 0x83, 0x0C, 0x50, 0x79, 0x00, 0x0F, 0x0C,
  0x48, 0x24, 0x14, 0x0A, 0x0B, 0x19, 0xF0, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x3E, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x30, 0x00, 0x07, 0x90, 0xC5, 0x18, 0x61, 0x02, 0x20, 0x22,
  0x02, 0x20, 0x64, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC4, 0x0C, 0x41, 0x86,
  0x28, 0x3C, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x84, 0x07,
  0x80, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0xF0, 0xA3,
  0x18, 0x22, 0x04, 0x40, 0x98, 0x22, 0x04, 0x40, 0x88, 0x11, 0x02, 0x40,
  0x88, 0x11, 0x02, 0x20, 0x4C, 0x18, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x0C, 0x0E, 0x00, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x18, 0x82, 0x10, 0x82, 0x20, 0x48, 0x12, 0x02,
  0xC0, 0x78, 0x0D, 0x01, 0x10, 0x42, 0x08, 0x41, 0x08, 0x20, 0x8C, 0x10,
  0x04, 0x30, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x80, 0x13, 0xCF, 0x0A, 0x28, 0x46, 0x18, 0x22, 0x0C,
  0x11, 0x04, 0x09, 0x02, 0x04, 0x81, 0x04, 0x40, 0x82, 0x20, 0x81, 0x10,
  0x40, 0x90, 0x20, 0xC8, 0x10, 0x44, 0x18, 0x22, 0x08, 0x13, 0x04, 0x08,
  0x13, 0xC2, 0x8C, 0x60, 0x88, 0x11, 0x02, 0x40, 0x88, 0x11, 0x02, 0x20,
  0x4C, 0x09, 0x02, 0x20, 0x44, 0x08, 0x81, 0x30, 0x60, 0x0F, 0x06, 0x23,
  0x04, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0xE0, 0x28, 0x0A, 0x04,
  0x81, 0x10, 0x87, 0xC0, 0x09, 0xE0, 0xA3, 0x0C, 0x10, 0xC1, 0x08, 0x11,
  0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x03, 0x30, 0x22, 0x02, 0x30, 0x43,
  0x08, 0x4F, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00,
  0x0F, 0x23, 0x14, 0xC1, 0x10, 0x24, 0x04, 0x80, 0x90, 0x14, 0x04, 0x80,
  0x90, 0x12, 0x06, 0x40, 0xC8, 0x31, 0x8A, 0x1E, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x13, 0x8A, 0x06, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x03, 0x00,
  0x0F, 0x98, 0x48, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x24, 0x33, 0xF0, 0x10, 0x41, 0x1F, 0x20, 0x82, 0x18, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x83, 0x80, 0x20, 0x48, 0x12, 0x04, 0x81,
  0x60, 0xD0, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x48, 0x12, 0x04, 0x83, 0x21,
  0x47, 0xA0, 0x81, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x98,
  0x48, 0x2C, 0x14, 0x0A, 0x06, 0x03, 0x00, 0x83, 0x06, 0x0C, 0x38, 0x50,
  0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x22, 0x85,
  0x0A, 0x14, 0x28, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x00, 0x10, 0x21,
  0x0C, 0x21, 0x04, 0x40, 0x90, 0x0A, 0x01, 0x80, 0x20, 0x0A, 0x01, 0x40,
  0x48, 0x10, 0x82, 0x10, 0x82, 0x20, 0x60, 0x04, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x12,
  0x00, 0x28, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0F, 0xC0,
  0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00,
  0x80, 0x60, 0x10, 0x0F, 0xE0, 0x01, 0xC1, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0xC0, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x83, 0xC0, 0x7C, 0x30, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 6, 7, 8, 3, -20 },
  { 20, 13, 20, 13, 0, -20 },
  { 53, 12, 23, 12, 0, -21 },
  { 88, 14, 20, 17, 2, -20 },
  { 123, 12, 20, 12, 0, -20 },
  { 153, 2, 7, 5, 3, -20 },
  { 155, 8, 24, 7, 1, -20 },
  { 179, 8, 24, 7, -2, -20 },
  { 203, 9, 9, 11, 3, -21 },
  { 214, 11, 13, 13, 1, -16 },
  { 232, 4, 7, 5, -1, -3 },
  { 236, 6, 1, 8, 1, -8 },
  { 237, 1, 2, 5, 1, -2 },
  { 238, 12, 20, 9, -1, -20 },
  { 268, 10, 20, 12, 1, -20 },
  { 293, 5, 20, 12, 4, -20 },
  { 306, 12, 20, 12, -1, -20 },
  { 336, 11, 20, 12, 0, -20 },
  { 364, 11, 20, 12, 0, -20 },
  { 392, 12, 20, 12, 0, -20 },
  { 422, 11, 20, 12, 1, -20 },
  { 450, 10, 20, 12, 2, -20 },
  { 475, 12, 20, 12, 0, -20 },
  { 505, 11, 20, 12, 0, -20 },
  { 533, 5, 15, 5, 0, -15 },
  { 543, 6, 19, 5, -1, -15 },
  { 558, 11, 12, 13, 1, -16 },
  { 575, 11, 7, 13, 1, -13 },
  { 585, 11, 12, 13, 1, -16 },
  { 602, 8, 20, 8, 1, -20 },
  { 622, 16, 22, 17, 1, -20 },
  { 666, 12, 20, 11, -2, -20 },
  { 696, 13, 20, 13, 0, -20 },
  { 729, 13, 20, 12, 1, -20 },
  { 762, 13, 20, 14, 0, -20 },
  { 795, 12, 20, 11, 0, -20 },
  { 825, 12, 20, 10, 0, -20 },
  { 855, 14, 20, 15, 1, -20 },
  { 890, 15, 20, 15, 0, -20 },
  { 928, 9, 20, 6, -1, -20 },
  { 951, 10, 25, 5, -4, -20 },
  { 983, 14, 20, 12, 0, -20 },
  { 1018, 8, 20, 10, 0, -20 },
  { 1038, 19, 20, 19, 0, -20 },
  { 1086, 15, 20, 15, 0, -20 },
  { 1124, 13, 20, 15, 1, -20 },
  { 1157, 12, 20, 12, 0, -20 },
  { 1187, 13, 25, 15, 1, -20 },
  { 1228, 12, 20, 12, 0, -20 },
  { 1258, 12, 20, 11, 0, -20 },
  { 1288, 10, 20, 10, 2, -20 },
  { 1313, 14, 20, 14, 1, -20 },
  { 1348, 11, 20, 12, 3, -20 },
  { 1376, 18, 20, 19, 3, -20 },
  { 1421, 14, 20, 10, -2, -20 },
  { 1456, 10, 20, 10, 2, -20 },
  { 1481, 13, 20, 11, -1, -20 },
  { 1514, 10, 24, 8, 0, -20 },
  { 1544, 4, 20, 9, 3, -20 },
  { 1554, 10, 24, 8, -2, -20 },
  { 1584, 11, 11, 12, 1, -20 },
  { 1600, 8, 1, 8, -2, 3 },
  { 1601, 3, 4, 6, 4, -21 },
  { 1603, 11, 15, 12, 1, -15 },
  { 1624, 11, 21, 12, 0, -21 },
  { 1653, 9, 15, 9, 1, -15 },
  { 1670, 12, 21, 12, 1, -21 },
  { 1702, 9, 15, 11, 1, -15 },
  { 1719, 14, 28, 6, -4, -21 },
  { 1768, 12, 22, 12, 0, -15 },
  { 1801, 11, 21, 12, 0, -21 },
  { 1830, 6, 20, 5, 0, -20 },
  { 1845, 10, 27, 5, -4, -20 },
  { 1879, 11, 21, 10, 0, -21 },
  { 1908, 6, 21, 5, 0, -21 },
  { 1924, 17, 15, 18, 0, -15 },
  { 1956, 11, 15, 12, 0, -15 },
  { 1977, 10, 15, 12, 1, -15 },
  { 1996, 12, 21, 12, -1, -15 },
  { 2028, 11, 22, 12, 1, -15 },
  { 2059, 9, 15, 8, 0, -15 },
  { 2076, 9, 15, 9, 0, -15 },
  { 2093, 6, 18, 6, 1, -18 },
  { 2107, 10, 15, 12, 1, -15 },
  { 2126, 9, 15, 9, 2, -15 },
  { 2143, 14, 15, 15, 2, -15 },
  { 2170, 11, 15, 10, -1, -15 },
  { 2191, 14, 22, 9, -3, -15 },
  { 2230, 10, 15, 8, -1, -15 },
  { 2249, 10, 24, 9, 1, -20 },
  { 2279, 1, 28, 11, 5, -21 },
  { 2283, 10, 24, 9, -2, -20 },
  { 2313, 11, 2, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC28PT7B_H_
