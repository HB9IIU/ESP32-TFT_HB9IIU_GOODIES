#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x38, 0x0E, 0x03, 0x00, 0x30, 0x66,
  0x0C, 0xC3, 0x18, 0x62, 0x0C, 0xC1, 0x98, 0x23, 0x0C, 0x41, 0x88, 0x33,
  0x04, 0x60, 0x8C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00,
  0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x01, 0x00, 0x0C, 0x0C, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x80, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x30, 0x20, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x40, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x20, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x07,
  0x10, 0xC0, 0x70, 0x80, 0x03, 0x04, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xE3,
  0x00, 0x03, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x80, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0x86, 0x07, 0x0C, 0xE0,
  0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x07, 0xF0,
  0x03, 0x03, 0x0C, 0x01, 0x03, 0x06, 0x01, 0x83, 0x03, 0x01, 0x81, 0x81,
  0x80, 0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x60, 0x30,
  0x18, 0x20, 0x10, 0x08, 0x30, 0x18, 0x0C, 0x30, 0x0C, 0x06, 0x18, 0x06,
  0x03, 0x18, 0x03, 0x01, 0x0C, 0x39, 0x81, 0x8C, 0x7E, 0xC0, 0xC4, 0x61,
  0xE0, 0x46, 0x60, 0xF0, 0x66, 0x30, 0x78, 0x63, 0x30, 0x17, 0xE3, 0x18,
  0x19, 0xE1, 0x88, 0x0C, 0x01, 0x8C, 0x06, 0x00, 0x86, 0x03, 0x00, 0xC3,
  0x01, 0x80, 0xC1, 0x00, 0xC0, 0x60, 0x80, 0x40, 0x60, 0xC0, 0x60, 0x30,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x10, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x18,
  0x06, 0x0C, 0x0C, 0x03, 0x06, 0x0C, 0x00, 0xC6, 0x06, 0x00, 0x7E, 0x04,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xDC, 0x00, 0x18, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x18,
  0x70, 0x00, 0x67, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xEC, 0x00, 0x0E, 0x60, 0x00, 0xC3, 0x01, 0x8C, 0x0C,
  0x0C, 0xE0, 0x60, 0xC6, 0x01, 0x86, 0x60, 0x0C, 0x23, 0x00, 0x63, 0x18,
  0x01, 0x91, 0x80, 0x0D, 0x8C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0xF0, 0x60, 0x0D, 0x83, 0x80, 0xC6, 0x0E, 0x1C, 0x30, 0x3F,
  0xC1, 0xC0, 0x20, 0x00, 0x00, 0x39, 0x8C, 0x62, 0x31, 0x8C, 0x62, 0x11,
  0x8C, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x0C, 0x18, 0x1C, 0x30, 0x0E,
  0x40, 0x87, 0xBF, 0x03, 0xE0, 0x0E, 0x00, 0x32, 0x00, 0xC6, 0x03, 0x0C,
  0x1C, 0x0C, 0x10, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF,
  0xE0, 0x5F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1C, 0x18, 0x0C, 0x07, 0x07,
  0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83,
  0x00, 0xE0, 0xC0, 0x30, 0x18, 0x18, 0x07, 0x9C, 0x00, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0x61, 0xCC, 0x71, 0xB8, 0x62,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x70, 0x1C,
  0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0x80, 0x60, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x02, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x08, 0x01, 0xC0, 0xE0, 0x78, 0x0F, 0xFE, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xA0, 0x00,
  0x0B, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x20,
  0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x30,
  0x20, 0x01, 0x83, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0xC0, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x04,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFD, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x04, 0x00, 0xE0, 0x38, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x7E,
  0x01, 0x1F, 0xE0, 0x6E, 0x0E, 0x0F, 0x00, 0xE1, 0xC0, 0x0C, 0x38, 0x01,
  0x8E, 0x00, 0x31, 0xC0, 0x02, 0x30, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x03, 0x86, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x07, 0x00, 0xE3, 0xC0,
  0x0F, 0xE0, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0x80, 0x0C,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x0E, 0x00, 0x18,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x77, 0x00, 0x0E, 0x1C, 0x00,
  0xE0, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x04, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x01, 0x80, 0x30,
  0x07, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF0, 0x06, 0x07, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x1C, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30,
  0x01, 0xC3, 0x00, 0x38, 0x60, 0x0F, 0x0E, 0x03, 0x60, 0xFF, 0xC8, 0x07,
  0xE3, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x02, 0x0F, 0x00, 0x7F, 0x80, 0x01, 0x00,
  0x00, 0x01, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x70, 0xE0, 0x60, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x40,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0xC0, 0x31, 0x80, 0x7F, 0x83, 0x18, 0x0C, 0x18,
  0x33, 0x01, 0x81, 0x03, 0x30, 0x30, 0x30, 0x32, 0x02, 0x03, 0x03, 0x60,
  0x60, 0x30, 0x36, 0x04, 0x02, 0x02, 0x60, 0xC0, 0x60, 0x24, 0x0C, 0x06,
  0x06, 0xC0, 0x80, 0x60, 0x6C, 0x18, 0x0C, 0x04, 0xC1, 0x80, 0xC0, 0xCC,
  0x18, 0x0C, 0x0C, 0xC1, 0x81, 0xC0, 0x88, 0x18, 0x1C, 0x18, 0x81, 0x83,
  0xC1, 0x08, 0x18, 0x2C, 0x30, 0x80, 0xCE, 0xC6, 0x08, 0x0F, 0x87, 0xC0,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x20, 0x18,
  0x02, 0x01, 0x80, 0x20, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x30, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x3C, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x60,
  0x3C, 0x03, 0x00, 0x70, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x60, 0x03, 0x02, 0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x38, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x02, 0x01, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1,
  0x80, 0x06, 0x0C, 0x00, 0x70, 0x40, 0x07, 0x06, 0x00, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0x80,
  0x40, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x06, 0x07, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x40, 0x0E, 0x01, 0x80, 0x78, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1E,
  0x00, 0xE0, 0x1C, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0x0C, 0x00, 0xFF, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x0E,
  0x00, 0x30, 0x03, 0xE1, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x80, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x08, 0x30, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x07, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03,
  0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x04, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x0C,
  0xE0, 0x00, 0x0D, 0xE0, 0x00, 0x1B, 0x60, 0x00, 0x1E, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x28,
  0x00, 0x01, 0xE0, 0x34, 0x00, 0x00, 0xF0, 0x1A, 0x00, 0x00, 0xD8, 0x0D,
  0x80, 0x00, 0x78, 0x06, 0xC0, 0x00, 0x6C, 0x02, 0x60, 0x00, 0x36, 0x03,
  0x30, 0x00, 0x33, 0x01, 0x98, 0x00, 0x11, 0x80, 0xCC, 0x00, 0x19, 0x80,
  0x66, 0x00, 0x18, 0xC0, 0x23, 0x00, 0x0C, 0x60, 0x31, 0x80, 0x0C, 0x30,
  0x18, 0x40, 0x06, 0x10, 0x0C, 0x20, 0x06, 0x18, 0x06, 0x18, 0x03, 0x0C,
  0x06, 0x0C, 0x03, 0x06, 0x03, 0x06, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0xC1, 0x80, 0x40, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x60, 0x30, 0x18, 0x18, 0x30, 0x30, 0x0C, 0x0C, 0x30,
  0x18, 0x04, 0x02, 0x18, 0x0C, 0x06, 0x01, 0x18, 0x06, 0x03, 0x00, 0xCC,
  0x02, 0x01, 0x80, 0x6C, 0x03, 0x00, 0xC0, 0x36, 0x01, 0x80, 0x40, 0x1E,
  0x00, 0xC0, 0x60, 0x0F, 0x00, 0x60, 0x30, 0x07, 0x00, 0x20, 0x18, 0x03,
  0x80, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x03, 0x60, 0x01, 0x80, 0xD8, 0x00, 0x60, 0x36,
  0x00, 0x18, 0x0D, 0x80, 0x06, 0x03, 0x30, 0x01, 0x01, 0x8C, 0x00, 0xC0,
  0x63, 0x00, 0x30, 0x18, 0xC0, 0x0C, 0x06, 0x18, 0x03, 0x01, 0x06, 0x00,
  0x80, 0xC1, 0x80, 0x60, 0x30, 0x60, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x06,
  0x01, 0x83, 0x01, 0x80, 0x60, 0xC0, 0xC0, 0x18, 0x60, 0x30, 0x03, 0x18,
  0x0C, 0x00, 0xC6, 0x03, 0x00, 0x31, 0x80, 0x80, 0x0C, 0x40, 0x60, 0x01,
  0xB0, 0x18, 0x00, 0x6C, 0x06, 0x00, 0x1B, 0x01, 0x80, 0x06, 0xC0, 0x40,
  0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60,
  0x18, 0x00, 0xE0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x78, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x78, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x18,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x01,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60, 0x18, 0x00,
  0xE0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x66,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x78, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x60, 0x78, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x38, 0x30, 0x01, 0x81,
  0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x60, 0x1C, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xF0, 0x0E, 0x00, 0x80, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x02, 0x00, 0x38, 0x0F, 0x87, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x80, 0x60, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x3A, 0x00, 0x01, 0x90, 0x00, 0x1C, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00,
  0x46, 0x00, 0x02, 0x30, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x05, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0xC0, 0x03, 0x80, 0x06, 0xC0, 0x07, 0x80, 0x06, 0xC0, 0x07, 0x80, 0x0C,
  0xC0, 0x05, 0x80, 0x0C, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x0D, 0x80, 0x18,
  0xC0, 0x19, 0x80, 0x18, 0xC0, 0x19, 0x80, 0x30, 0xC0, 0x11, 0x80, 0x30,
  0xC0, 0x31, 0x80, 0x60, 0xC0, 0x31, 0x80, 0x60, 0xC0, 0x61, 0x80, 0x40,
  0xC0, 0x61, 0x80, 0xC0, 0xC0, 0xC1, 0x80, 0xC0, 0xC0, 0xC1, 0x81, 0x80,
  0xC0, 0x81, 0x81, 0x80, 0xC1, 0x81, 0x83, 0x00, 0xC1, 0x81, 0x83, 0x00,
  0xC3, 0x01, 0x83, 0x00, 0xC3, 0x01, 0x86, 0x00, 0xC2, 0x01, 0x86, 0x00,
  0xC6, 0x01, 0x8C, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0xCC, 0x01, 0x88, 0x00,
  0xCC, 0x01, 0x98, 0x00, 0xD8, 0x01, 0x98, 0x00, 0xD8, 0x01, 0xB0, 0x00,
  0xD0, 0x01, 0xB0, 0x00, 0xF0, 0x01, 0xA0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x08, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x88, 0x00,
  0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x76, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0x20,
  0x1C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18,
  0x01, 0x0C, 0x00, 0x47, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x83,
  0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18,
  0x30, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x30, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x30, 0x00, 0x66, 0x00,
  0x03, 0xE0, 0x00, 0x30, 0xFF, 0xFE, 0xE1, 0x86, 0x0C, 0x10, 0x60, 0x83,
  0x00, 0x78, 0x00, 0x3F, 0xCC, 0x0E, 0x19, 0x83, 0x01, 0xA0, 0xC0, 0x14,
  0x30, 0x03, 0x86, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xE1, 0x80, 0x1C, 0x30, 0x05, 0x06, 0x01, 0xA0, 0x60, 0x6C, 0x0E,
  0x39, 0x80, 0xFE, 0x30, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x0F, 0x80,
  0x67, 0xF8, 0x0D, 0xC3, 0x81, 0x60, 0x30, 0x68, 0x03, 0x0F, 0x00, 0x61,
  0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60,
  0x03, 0x0E, 0x00, 0xC3, 0x40, 0x38, 0x6C, 0x0E, 0x0C, 0xC3, 0x81, 0x0F,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0x82, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x60, 0x1F, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1E, 0x18, 0x01, 0xFE, 0x60,
  0x0E, 0x0D, 0x80, 0x60, 0x16, 0x03, 0x00, 0x50, 0x18, 0x01, 0xC0, 0x60,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x60, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x78, 0x0C, 0x03, 0x40,
  0x18, 0x19, 0x00, 0x71, 0xCC, 0x00, 0xFE, 0x30, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0xFE, 0x03, 0x07, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x38,
  0xC1, 0xF0, 0xFF, 0x80, 0xF0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x08, 0x38, 0x70, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xEC, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x40, 0x38, 0x36, 0x03, 0x00, 0xB0, 0x30, 0x05, 0x03, 0x00, 0x38,
  0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x03, 0x00, 0x38, 0x18, 0x03, 0xC0, 0xC0, 0x1E, 0x06, 0x01, 0xA0, 0x18,
  0x1B, 0x00, 0xE3, 0x98, 0x03, 0xF8, 0xC0, 0x02, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x08, 0x07, 0x00, 0x7F, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x7C, 0x06, 0x7F, 0x81, 0xB0, 0x70, 0x58,
  0x0C, 0x3C, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x10, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x08, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x0C, 0x30, 0x03, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x01, 0xC1, 0x80, 0x60,
  0x40, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x20,
  0xC0, 0x18, 0x60, 0x06, 0x30, 0x01, 0x98, 0x00, 0x6F, 0x00, 0x36, 0xC0,
  0x0F, 0x30, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x18, 0x18, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x0C, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x18, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x33, 0xF8,
  0x7F, 0x81, 0x30, 0x66, 0x0E, 0x0B, 0x03, 0x60, 0x30, 0xF0, 0x0A, 0x01,
  0x87, 0x00, 0x70, 0x0C, 0x38, 0x03, 0x00, 0x61, 0x80, 0x18, 0x03, 0x0C,
  0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x30, 0x03,
  0x00, 0x61, 0x80, 0x30, 0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00,
  0xC6, 0x00, 0x60, 0x04, 0x30, 0x03, 0x00, 0x61, 0x80, 0x30, 0x03, 0x18,
  0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x04, 0x30, 0x02,
  0x00, 0x61, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00,
  0xC6, 0x00, 0x60, 0x0C, 0x30, 0x06, 0x00, 0x60, 0x00, 0x1F, 0x01, 0x9F,
  0xE0, 0x4C, 0x1C, 0x16, 0x03, 0x0F, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x84, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x08, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06,
  0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00,
  0xC3, 0x80, 0x60, 0x60, 0x30, 0x0E, 0x38, 0x01, 0xFC, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0x3F, 0xC0, 0x09, 0xC3, 0x80, 0x2C, 0x06, 0x01,
  0xA0, 0x0C, 0x07, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01,
  0x80, 0xE0, 0x0C, 0x06, 0x80, 0x70, 0x1B, 0x03, 0x80, 0x66, 0x1C, 0x01,
  0x8F, 0xE0, 0x04, 0x08, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xC4, 0x0C, 0x0D, 0x83, 0x00, 0xB0, 0xC0, 0x14,
  0x30, 0x03, 0x86, 0x00, 0x71, 0x80, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x0C,
  0x00, 0xE1, 0x80, 0x1C, 0x30, 0x07, 0x86, 0x01, 0xA0, 0x60, 0x6C, 0x0E,
  0x39, 0x80, 0xFE, 0x30, 0x02, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x0C,
  0xFC, 0x13, 0x00, 0x2C, 0x00, 0xD0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0x06, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x80, 0x70, 0xE0, 0xE0, 0xFF, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x13, 0xFE, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x20, 0x7E, 0x00, 0x80, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x86, 0x00, 0x61, 0x80, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x07,
  0x0C, 0x02, 0xC3, 0x01, 0xA0, 0xE1, 0xC8, 0x1F, 0xC6, 0x00, 0x80, 0x00,
  0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0x43, 0x00, 0x43, 0x00, 0x46, 0x00,
  0x46, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x01, 0xF0, 0x07, 0x00, 0x6C, 0x01,
  0xC0, 0x1B, 0x00, 0xF0, 0x0C, 0xC0, 0x3C, 0x03, 0x30, 0x1B, 0x01, 0x8C,
  0x06, 0xC0, 0x63, 0x01, 0x10, 0x10, 0xC0, 0xC4, 0x0C, 0x30, 0x21, 0x03,
  0x0C, 0x18, 0x41, 0x83, 0x06, 0x10, 0x60, 0xC3, 0x04, 0x10, 0x30, 0xC1,
  0x0C, 0x0C, 0x20, 0x43, 0x03, 0x18, 0x11, 0x80, 0xC4, 0x04, 0x60, 0x33,
  0x01, 0x30, 0x0C, 0xC0, 0x4C, 0x03, 0x60, 0x12, 0x00, 0xD8, 0x05, 0x80,
  0x34, 0x01, 0x60, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x08, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00,
  0x18, 0xC0, 0x00, 0xCE, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x18, 0xC0, 0x01, 0x82, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0,
  0x0C, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x07, 0x03, 0xC3,
  0xC0, 0x1F, 0xE0, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 11, 13, 14, 5, -36 },
  { 64, 22, 36, 23, 1, -36 },
  { 163, 21, 41, 21, 0, -38 },
  { 271, 25, 37, 30, 3, -36 },
  { 387, 21, 37, 22, 0, -36 },
  { 485, 5, 13, 8, 5, -36 },
  { 494, 14, 44, 12, 1, -36 },
  { 571, 14, 44, 12, -3, -36 },
  { 648, 15, 16, 19, 6, -38 },
  { 678, 19, 23, 23, 2, -29 },
  { 733, 7, 11, 9, -2, -5 },
  { 743, 11, 1, 14, 1, -14 },
  { 745, 3, 4, 9, 1, -4 },
  { 747, 21, 36, 15, -2, -36 },
  { 842, 18, 37, 21, 2, -36 },
  { 926, 11, 36, 21, 6, -36 },
  { 976, 21, 36, 21, -1, -36 },
  { 1071, 20, 37, 21, 0, -36 },
  { 1164, 21, 36, 21, -1, -36 },
  { 1259, 21, 37, 21, 0, -36 },
  { 1357, 19, 37, 21, 2, -36 },
  { 1445, 19, 36, 21, 3, -36 },
  { 1531, 21, 37, 21, 0, -36 },
  { 1629, 19, 37, 21, 1, -36 },
  { 1717, 8, 27, 9, 0, -27 },
  { 1744, 11, 33, 9, -2, -27 },
  { 1790, 19, 22, 23, 2, -29 },
  { 1843, 19, 13, 23, 2, -24 },
  { 1874, 19, 22, 23, 2, -29 },
  { 1927, 15, 36, 15, 2, -36 },
  { 1995, 28, 40, 31, 2, -36 },
  { 2135, 20, 36, 20, -3, -36 },
  { 2225, 21, 36, 22, 1, -36 },
  { 2320, 22, 37, 21, 2, -36 },
  { 2422, 23, 36, 25, 1, -36 },
  { 2526, 21, 36, 20, 1, -36 },
  { 2621, 21, 36, 18, 1, -36 },
  { 2716, 25, 37, 26, 2, -36 },
  { 2832, 25, 36, 26, 1, -36 },
  { 2945, 16, 36, 11, -2, -36 },
  { 3017, 18, 45, 9, -8, -36 },
  { 3119, 24, 36, 21, 1, -36 },
  { 3227, 13, 36, 18, 1, -36 },
  { 3286, 33, 36, 33, 1, -36 },
  { 3435, 26, 36, 27, 1, -36 },
  { 3552, 23, 37, 27, 2, -36 },
  { 3659, 21, 36, 21, 1, -36 },
  { 3754, 23, 45, 27, 2, -36 },
  { 3884, 21, 36, 21, 1, -36 },
  { 3979, 22, 37, 20, -1, -36 },
  { 4081, 18, 36, 18, 4, -36 },
  { 4162, 24, 37, 26, 2, -36 },
  { 4273, 21, 36, 21, 4, -36 },
  { 4368, 32, 36, 34, 5, -36 },
  { 4512, 25, 36, 19, -3, -36 },
  { 4625, 18, 36, 18, 4, -36 },
  { 4706, 24, 36, 19, -2, -36 },
  { 4814, 18, 44, 14, -1, -36 },
  { 4913, 7, 36, 16, 5, -36 },
  { 4945, 18, 44, 14, -3, -36 },
  { 5044, 20, 19, 22, 1, -36 },
  { 5092, 15, 1, 15, -4, 5 },
  { 5094, 6, 8, 11, 7, -38 },
  { 5100, 19, 28, 22, 2, -27 },
  { 5167, 19, 39, 22, 1, -38 },
  { 5260, 16, 28, 17, 2, -27 },
  { 5316, 22, 39, 22, 2, -38 },
  { 5424, 16, 28, 19, 2, -27 },
  { 5480, 23, 50, 11, -6, -38 },
  { 5624, 21, 39, 22, 0, -27 },
  { 5727, 18, 38, 21, 1, -38 },
  { 5813, 9, 36, 9, 1, -36 },
  { 5854, 17, 48, 9, -7, -36 },
  { 5956, 18, 38, 18, 1, -38 },
  { 6042, 10, 38, 9, 1, -38 },
  { 6090, 29, 27, 32, 1, -27 },
  { 6188, 18, 27, 21, 1, -27 },
  { 6249, 18, 28, 21, 2, -27 },
  { 6312, 22, 39, 22, -2, -27 },
  { 6420, 19, 39, 22, 2, -27 },
  { 6513, 15, 27, 14, 1, -27 },
  { 6564, 16, 28, 16, 0, -27 },
  { 6620, 12, 34, 11, 1, -33 },
  { 6671, 18, 27, 21, 2, -26 },
  { 6732, 16, 26, 16, 3, -26 },
  { 6784, 26, 26, 27, 3, -26 },
  { 6869, 21, 26, 17, -2, -26 },
  { 6938, 25, 38, 17, -6, -26 },
  { 7057, 17, 26, 15, -1, -26 },
  { 7113, 18, 44, 16, 1, -36 },
  { 7212, 1, 50, 20, 10, -38 },
  { 7219, 17, 44, 16, -3, -36 },
  { 7313, 19, 5, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC50PT7B_H_
