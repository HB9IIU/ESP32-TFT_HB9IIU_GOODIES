#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x44, 0x00, 0x80, 0xB6, 0xE0, 0x1A, 0x24, 0x53,
  0xF2, 0x45, 0x0A, 0x6E, 0x48, 0xA2, 0x40, 0x08, 0x3C, 0xA2, 0x45, 0x06,
  0x04, 0x0C, 0x14, 0x4B, 0xE1, 0x02, 0x00, 0x21, 0x52, 0x92, 0x94, 0x94,
  0xAB, 0xB5, 0x59, 0x29, 0x29, 0x4A, 0xCE, 0x08, 0x28, 0x91, 0x22, 0x82,
  0x0C, 0x29, 0x8D, 0x1A, 0x23, 0xA0, 0xF0, 0x18, 0x88, 0x84, 0x22, 0x10,
  0x84, 0x21, 0x04, 0x20, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x25,
  0x1E, 0xC9, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x29, 0x40, 0xF0,
  0x80, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00, 0x11,
  0x53, 0x18, 0xC6, 0x31, 0x8C, 0xA5, 0xC0, 0x74, 0x94, 0x92, 0x52, 0x00,
  0x18, 0x90, 0x41, 0x04, 0x10, 0x84, 0x21, 0x08, 0x3E, 0x18, 0x48, 0x08,
  0x10, 0x41, 0x0E, 0x02, 0x04, 0x08, 0x27, 0x80, 0x04, 0x10, 0xC5, 0x14,
  0x94, 0x92, 0xFC, 0x20, 0x84, 0x3E, 0x40, 0x82, 0x07, 0x80, 0x81, 0x02,
  0x04, 0x13, 0xC0, 0x1C, 0x84, 0x10, 0x83, 0xC8, 0xA2, 0x8A, 0x29, 0x38,
  0x7C, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0x00, 0x1C, 0x44, 0x89,
  0x12, 0x47, 0x0A, 0x24, 0x85, 0x0A, 0x23, 0xC0, 0x18, 0x94, 0x51, 0x45,
  0x14, 0xCD, 0x04, 0x21, 0x38, 0x24, 0x00, 0x00, 0x80, 0x11, 0x00, 0x00,
  0x02, 0x44, 0x80, 0x0C, 0xC4, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F,
  0x81, 0x81, 0x83, 0x31, 0x08, 0x00, 0x61, 0x11, 0x12, 0x48, 0x80, 0x08,
  0x1F, 0x10, 0x50, 0x33, 0x9A, 0x4D, 0x26, 0x95, 0x52, 0xBE, 0x40, 0x20,
  0x1F, 0x00, 0x04, 0x30, 0xC5, 0x14, 0x93, 0xD1, 0x45, 0x18, 0x40, 0x3E,
  0x44, 0x89, 0x14, 0x4F, 0x91, 0x22, 0x45, 0x0B, 0xE0, 0x0C, 0x65, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0x80, 0x3E, 0x22, 0x21, 0x21,
  0x41, 0x41, 0x42, 0x42, 0x44, 0x8C, 0xF0, 0x3E, 0x40, 0x81, 0x07, 0xC8,
  0x10, 0x20, 0x41, 0x03, 0xE0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x90, 0x20,
  0x41, 0x02, 0x00, 0x0E, 0x31, 0x40, 0x40, 0x80, 0x80, 0x8E, 0x82, 0x84,
  0x84, 0x84, 0x7C, 0x21, 0x21, 0x21, 0x21, 0x41, 0x7E, 0x42, 0x42, 0x42,
  0x82, 0x84, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21, 0x38, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x60, 0x23, 0x24, 0x24, 0x28, 0x50, 0x70,
  0x50, 0x48, 0x48, 0x88, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x3E,
  0x30, 0x66, 0x08, 0xC3, 0x18, 0x65, 0x14, 0xA2, 0x94, 0xA2, 0x94, 0x4C,
  0x91, 0x12, 0x22, 0x00, 0x30, 0x98, 0x8C, 0x45, 0x24, 0x92, 0x49, 0x28,
  0x8C, 0x46, 0x43, 0x21, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0x0A, 0x23, 0x80, 0x3E, 0x44, 0x89, 0x14, 0x4F, 0x10, 0x20, 0x41,
  0x02, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x23,
  0x81, 0x02, 0x04, 0x00, 0x3E, 0x44, 0x89, 0x14, 0x4F, 0x12, 0x24, 0x49,
  0x12, 0x10, 0x1C, 0x45, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x10, 0x27,
  0x80, 0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x00, 0x42, 0x85,
  0x0A, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x13, 0xC0, 0x83, 0x0A, 0x14, 0x48,
  0x92, 0x24, 0x30, 0x60, 0x81, 0x00, 0x88, 0x66, 0x29, 0x8A, 0x62, 0xA9,
  0x2A, 0x4C, 0xA3, 0x28, 0x8C, 0x23, 0x08, 0x80, 0x11, 0x12, 0x14, 0x14,
  0x08, 0x08, 0x18, 0x28, 0x48, 0x44, 0x84, 0x86, 0x24, 0x94, 0x61, 0x84,
  0x10, 0x41, 0x08, 0x00, 0x1F, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0xFC, 0x3C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x83, 0x80, 0xAA, 0xA9, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x08, 0x23, 0x80, 0x18, 0x30, 0x91, 0x24, 0x30, 0x40, 0xF8, 0x90,
  0x31, 0x38, 0xA2, 0x8A, 0x28, 0xA4, 0xF0, 0x20, 0x82, 0x0A, 0x34, 0x94,
  0x51, 0x45, 0x18, 0xBC, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x02, 0x08,
  0x11, 0xA4, 0xD1, 0x22, 0x44, 0x89, 0x12, 0x47, 0x80, 0x32, 0x63, 0x2E,
  0x42, 0x10, 0xF0, 0x06, 0x10, 0x20, 0xE0, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x60, 0x18, 0x4D, 0x12, 0x24, 0x50, 0xA1, 0x44,
  0x78, 0x10, 0x20, 0x8E, 0x00, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x51, 0x45,
  0x18, 0xA2, 0x24, 0x02, 0x92, 0x4A, 0x40, 0x08, 0x40, 0x00, 0x88, 0x42,
  0x10, 0x88, 0x42, 0x11, 0x18, 0x20, 0x82, 0x08, 0x25, 0x25, 0x18, 0x51,
  0x49, 0x22, 0x24, 0x92, 0x92, 0x4A, 0x40, 0x19, 0x89, 0x94, 0x45, 0x11,
  0x44, 0x91, 0x24, 0x8A, 0x22, 0x88, 0x80, 0x18, 0x94, 0x51, 0x45, 0x14,
  0x62, 0x88, 0x32, 0x63, 0x18, 0xC6, 0x32, 0xE0, 0x04, 0x34, 0x49, 0x12,
  0x24, 0x48, 0xA2, 0x78, 0x81, 0x04, 0x08, 0x00, 0x31, 0x38, 0xA2, 0x8A,
  0x28, 0xA4, 0xF0, 0x41, 0x04, 0x20, 0x19, 0x08, 0x84, 0x21, 0x10, 0x80,
  0x3A, 0x10, 0x82, 0x08, 0x42, 0xF0, 0x22, 0x72, 0x44, 0x44, 0x88, 0xE0,
  0x46, 0x28, 0xA2, 0x8A, 0x49, 0x3C, 0x8C, 0xA5, 0x4A, 0x63, 0x10, 0x91,
  0x91, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x88, 0x26, 0x28, 0x60, 0x81, 0x05,
  0x12, 0x64, 0x11, 0x12, 0x12, 0x12, 0x14, 0x14, 0x08, 0x10, 0x10, 0x10,
  0x20, 0xC0, 0x78, 0x84, 0x44, 0x22, 0x1E, 0x0C, 0x41, 0x04, 0x20, 0x8C,
  0x08, 0x21, 0x04, 0x10, 0x40, 0x80, 0xFF, 0xFF, 0x18, 0x20, 0x82, 0x08,
  0x40, 0xC4, 0x10, 0x42, 0x08, 0x23, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 3, 0, -11 },
  { 7, 3, 4, 5, 2, -11 },
  { 9, 7, 11, 7, 0, -11 },
  { 19, 7, 13, 7, 0, -12 },
  { 31, 8, 12, 10, 1, -12 },
  { 43, 7, 12, 7, 0, -12 },
  { 54, 1, 4, 3, 2, -11 },
  { 55, 5, 14, 4, 0, -11 },
  { 64, 4, 14, 4, -1, -11 },
  { 71, 5, 5, 6, 2, -12 },
  { 75, 6, 7, 7, 1, -9 },
  { 81, 3, 4, 3, -1, -2 },
  { 83, 4, 1, 4, 0, -5 },
  { 84, 1, 1, 3, 0, -1 },
  { 85, 7, 11, 5, -1, -11 },
  { 95, 5, 12, 7, 1, -12 },
  { 103, 3, 11, 7, 2, -11 },
  { 108, 6, 12, 7, 0, -12 },
  { 117, 7, 12, 7, 0, -12 },
  { 128, 6, 12, 7, 0, -12 },
  { 137, 7, 11, 7, 0, -11 },
  { 147, 6, 12, 7, 1, -12 },
  { 156, 6, 11, 7, 1, -11 },
  { 165, 7, 12, 7, 0, -12 },
  { 176, 6, 12, 7, 0, -12 },
  { 185, 3, 9, 3, 0, -9 },
  { 189, 4, 11, 3, -1, -9 },
  { 195, 6, 7, 7, 1, -9 },
  { 201, 6, 4, 7, 1, -8 },
  { 204, 6, 7, 7, 1, -9 },
  { 210, 4, 12, 5, 1, -12 },
  { 216, 9, 12, 10, 1, -11 },
  { 230, 6, 11, 6, -1, -11 },
  { 239, 7, 11, 7, 0, -11 },
  { 249, 7, 12, 7, 1, -12 },
  { 260, 8, 11, 8, 0, -11 },
  { 271, 7, 11, 6, 0, -11 },
  { 281, 7, 11, 6, 0, -11 },
  { 291, 8, 12, 8, 1, -12 },
  { 303, 8, 11, 8, 0, -11 },
  { 314, 5, 11, 3, -1, -11 },
  { 321, 5, 14, 3, -2, -11 },
  { 330, 8, 11, 7, 0, -11 },
  { 341, 5, 11, 6, 0, -11 },
  { 348, 11, 11, 11, 0, -11 },
  { 364, 9, 11, 9, 0, -11 },
  { 377, 7, 12, 9, 1, -12 },
  { 388, 7, 11, 7, 0, -11 },
  { 398, 7, 15, 9, 1, -12 },
  { 412, 7, 11, 7, 0, -11 },
  { 422, 7, 12, 6, 0, -12 },
  { 433, 6, 11, 6, 1, -11 },
  { 442, 7, 11, 8, 1, -11 },
  { 452, 7, 11, 7, 1, -11 },
  { 462, 10, 11, 11, 2, -11 },
  { 476, 8, 11, 6, -1, -11 },
  { 487, 6, 11, 6, 1, -11 },
  { 496, 8, 11, 6, -1, -11 },
  { 507, 6, 14, 5, 0, -11 },
  { 518, 2, 11, 5, 2, -11 },
  { 521, 6, 14, 5, -1, -11 },
  { 532, 7, 6, 7, 0, -11 },
  { 538, 5, 1, 5, -1, 1 },
  { 539, 2, 2, 4, 2, -12 },
  { 540, 6, 9, 7, 1, -9 },
  { 547, 6, 12, 7, 0, -12 },
  { 556, 5, 9, 5, 1, -9 },
  { 562, 7, 12, 7, 1, -12 },
  { 573, 5, 9, 6, 1, -9 },
  { 579, 7, 16, 3, -2, -12 },
  { 593, 7, 13, 7, 0, -9 },
  { 605, 6, 12, 7, 0, -12 },
  { 614, 3, 12, 3, 0, -12 },
  { 619, 5, 16, 3, -2, -12 },
  { 629, 6, 12, 6, 0, -12 },
  { 638, 3, 12, 3, 0, -12 },
  { 643, 10, 9, 10, 0, -9 },
  { 655, 6, 9, 7, 0, -9 },
  { 662, 5, 9, 7, 1, -9 },
  { 668, 7, 13, 7, -1, -9 },
  { 680, 6, 13, 7, 1, -9 },
  { 690, 5, 9, 5, 0, -9 },
  { 696, 5, 9, 5, 0, -9 },
  { 702, 4, 11, 4, 0, -11 },
  { 708, 6, 8, 7, 1, -8 },
  { 714, 5, 8, 5, 1, -8 },
  { 719, 8, 8, 9, 1, -8 },
  { 727, 7, 8, 6, -1, -8 },
  { 734, 8, 12, 5, -2, -8 },
  { 746, 5, 8, 5, 0, -8 },
  { 751, 6, 14, 5, 0, -11 },
  { 762, 1, 16, 6, 3, -12 },
  { 764, 6, 14, 5, -1, -11 },
  { 775, 6, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC16PT7B_H_
