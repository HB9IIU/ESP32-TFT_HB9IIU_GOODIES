#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0x30, 0xE6, 0x18,
  0xC3, 0x10, 0x66, 0x0C, 0xC1, 0x18, 0x62, 0x0C, 0x41, 0x98, 0x23, 0x04,
  0x61, 0x88, 0x30, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x10, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04,
  0x00, 0x10, 0x30, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x08, 0x08, 0x00,
  0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0,
  0xC0, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x04, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0x84, 0x30, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0x60, 0x80, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x31, 0x00, 0x03, 0x90, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x02, 0xE0, 0x00,
  0x66, 0x00, 0x06, 0x30, 0x00, 0x41, 0x00, 0x04, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x18, 0x60,
  0xC1, 0x9C, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x06, 0x06,
  0x30, 0x02, 0x06, 0x08, 0x03, 0x03, 0x06, 0x03, 0x03, 0x03, 0x01, 0x81,
  0x81, 0x81, 0x81, 0x80, 0xC0, 0x80, 0xC0, 0x60, 0xC0, 0x60, 0x20, 0x40,
  0x20, 0x30, 0x60, 0x30, 0x18, 0x60, 0x18, 0x0C, 0x30, 0x0C, 0x06, 0x30,
  0x06, 0x02, 0x10, 0x03, 0x03, 0x18, 0xF9, 0x81, 0x88, 0xE6, 0xC1, 0x8C,
  0xC1, 0x60, 0xCC, 0x60, 0xF0, 0xC6, 0x60, 0x7C, 0xC6, 0x30, 0x37, 0xC2,
  0x30, 0x18, 0x03, 0x18, 0x0C, 0x01, 0x0C, 0x04, 0x01, 0x84, 0x02, 0x01,
  0x86, 0x03, 0x00, 0xC3, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0x40, 0xC0, 0x40,
  0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x18, 0x30, 0x30, 0x0C, 0x18,
  0x18, 0x06, 0x18, 0x18, 0x03, 0x98, 0x1C, 0x00, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0x8C, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00,
  0x66, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xCC, 0x00, 0x1C, 0x60, 0x11, 0xC3, 0x03, 0x0C, 0x0C, 0x18, 0xC0,
  0x60, 0xCC, 0x01, 0x8C, 0x60, 0x0C, 0x63, 0x00, 0x66, 0x30, 0x01, 0xB1,
  0x80, 0x0F, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x0C, 0x01,
  0xB0, 0x60, 0x19, 0x81, 0xC3, 0x86, 0x07, 0xF0, 0x30, 0x33, 0x32, 0x66,
  0x64, 0x44, 0xCC, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x0C, 0x10, 0x0E, 0x20, 0x06, 0x43, 0x83, 0xFF, 0x03, 0x00, 0x0A,
  0x00, 0x62, 0x01, 0x84, 0x06, 0x0C, 0x18, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x83,
  0x0C, 0x18, 0x60, 0x83, 0x00, 0xFF, 0xFF, 0xFC, 0x5F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x79, 0xC0, 0x18,
  0x18, 0x0C, 0x06, 0x06, 0x00, 0x81, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8,
  0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x88, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30,
  0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x60, 0x1C, 0x70, 0x03, 0xF8,
  0x00, 0x00, 0xC0, 0xF0, 0x7C, 0x3B, 0x19, 0x9C, 0x6E, 0x19, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0x8F, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x1E, 0x1C, 0x03, 0x00,
  0x60, 0x20, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x80, 0x1C, 0x0F, 0x0F, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x1E, 0x00, 0x03, 0x60,
  0x00, 0x66, 0x00, 0x04, 0x40, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x0C,
  0x00, 0x30, 0xC0, 0x06, 0x08, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x10, 0x03, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x02, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0,
  0x06, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x08, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x80,
  0x1C, 0x0E, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x08,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0xC0, 0x08, 0xFE, 0x03, 0x30, 0xE0, 0x6C, 0x06, 0x0E,
  0x00, 0xE1, 0xC0, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x07, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x1E,
  0x01, 0xC0, 0x60, 0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x02, 0x00, 0x60, 0x30,
  0x06, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC7, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x03, 0x8C, 0x00, 0xE0, 0x60, 0x1C, 0x07, 0x03,
  0x00, 0x30, 0x30, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x03,
  0x06, 0x00, 0x70, 0x30, 0x0E, 0x01, 0xC3, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x38, 0x70, 0x0E, 0x06, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x10, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40,
  0x01, 0x98, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x0E, 0x10, 0x01, 0xC3, 0x00, 0x78, 0x70, 0x1A, 0x07, 0x0E, 0xC0, 0x7F,
  0x18, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x70, 0xE0,
  0x60, 0x00, 0xC0, 0x30, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xF0, 0x70, 0xE1, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x04, 0x60, 0x0F, 0xC0, 0x8C, 0x07, 0x98, 0x13, 0x01, 0x83, 0x02,
  0x60, 0x60, 0x60, 0x48, 0x0C, 0x0C, 0x0B, 0x03, 0x01, 0x03, 0x60, 0x40,
  0x60, 0x6C, 0x18, 0x0C, 0x0D, 0x02, 0x01, 0x01, 0xE0, 0xC0, 0x60, 0x2C,
  0x18, 0x0C, 0x0D, 0x83, 0x01, 0x81, 0xB0, 0x60, 0x20, 0x24, 0x0C, 0x0C,
  0x0C, 0x81, 0x01, 0x81, 0x10, 0x30, 0x50, 0x62, 0x06, 0x1A, 0x18, 0x40,
  0xC6, 0x67, 0x08, 0x0F, 0x87, 0xC1, 0x80, 0x40, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x46,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x21,
  0x80, 0x02, 0x18, 0x00, 0x23, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x07, 0x06, 0x00, 0x70, 0x30, 0x07, 0x01,
  0x80, 0xF0, 0x0F, 0xFC, 0x00, 0xC1, 0xF0, 0x06, 0x00, 0xE0, 0x30, 0x03,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0xC0, 0x1E, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xC1,
  0xC0, 0x1C, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x18, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x70, 0x10, 0x03, 0x80, 0xC0,
  0x38, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03,
  0xF8, 0x60, 0x07, 0xF8, 0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x38, 0x00, 0x40, 0x1C, 0x00, 0xC0, 0x0F, 0x07,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x10, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x43, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x01,
  0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x43, 0x80, 0x01, 0x8E, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00,
  0x0D, 0xE0, 0x00, 0x36, 0xC0, 0x00, 0x79, 0x80, 0x00, 0xE1, 0x00, 0x01,
  0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x30, 0x00, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0x40, 0x00, 0x36, 0x03, 0x40, 0x00, 0x36, 0x02, 0x40, 0x00, 0x64,
  0x06, 0x60, 0x00, 0x6C, 0x06, 0x60, 0x00, 0xCC, 0x06, 0x60, 0x00, 0xCC,
  0x06, 0x60, 0x01, 0x8C, 0x04, 0x60, 0x01, 0x98, 0x0C, 0x60, 0x03, 0x18,
  0x0C, 0x60, 0x03, 0x18, 0x0C, 0x60, 0x06, 0x18, 0x08, 0x60, 0x06, 0x18,
  0x18, 0x20, 0x0C, 0x30, 0x18, 0x20, 0x0C, 0x30, 0x18, 0x20, 0x18, 0x30,
  0x18, 0x30, 0x18, 0x30, 0x10, 0x30, 0x30, 0x20, 0x30, 0x30, 0x30, 0x60,
  0x30, 0x30, 0x60, 0x60, 0x30, 0x30, 0x60, 0x60, 0x30, 0x30, 0xC0, 0x60,
  0x20, 0x30, 0xC0, 0x40, 0x60, 0x31, 0x80, 0xC0, 0x60, 0x31, 0x00, 0xC0,
  0x60, 0x13, 0x00, 0xC0, 0x60, 0x12, 0x00, 0xC0, 0x40, 0x1E, 0x01, 0x80,
  0xC0, 0x1C, 0x01, 0x80, 0xC0, 0x1C, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x20, 0x1C, 0x00, 0x18, 0x0F, 0x00,
  0x06, 0x03, 0x40, 0x01, 0x80, 0xD8, 0x00, 0x60, 0x36, 0x00, 0x30, 0x09,
  0x80, 0x0C, 0x06, 0x20, 0x03, 0x01, 0x8C, 0x00, 0xC0, 0x63, 0x00, 0x20,
  0x18, 0xC0, 0x18, 0x04, 0x10, 0x06, 0x03, 0x06, 0x01, 0x80, 0xC1, 0x80,
  0x60, 0x30, 0x60, 0x10, 0x0C, 0x08, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x04, 0x18, 0x04, 0x01, 0x86, 0x03,
  0x00, 0x61, 0x80, 0xC0, 0x18, 0x60, 0x30, 0x02, 0x10, 0x0C, 0x00, 0xCC,
  0x02, 0x00, 0x33, 0x01, 0x80, 0x0C, 0xC0, 0x60, 0x01, 0x30, 0x18, 0x00,
  0x68, 0x06, 0x00, 0x1E, 0x01, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xE0,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81,
  0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC3,
  0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x18,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x18, 0x7E, 0x01, 0xFF,
  0x80, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x01, 0x86,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x18, 0x01, 0x80, 0x38,
  0x07, 0x00, 0x3C, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0x80, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C,
  0x03, 0x81, 0x80, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x18, 0x30, 0x01,
  0x81, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0x80,
  0x20, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06,
  0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xC3, 0xC0, 0x70, 0x02, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x80,
  0x0E, 0x07, 0xC3, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x03, 0x02, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x20, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x40, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x64, 0x00, 0x0C, 0x40, 0x00, 0xC4,
  0x00, 0x1C, 0x40, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02,
  0x40, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0x80, 0x03, 0x80, 0x06, 0x80,
  0x03, 0x80, 0x06, 0x80, 0x07, 0x80, 0x0C, 0x80, 0x07, 0x80, 0x0C, 0x80,
  0x05, 0x80, 0x18, 0x80, 0x0D, 0x80, 0x18, 0x80, 0x0D, 0x80, 0x18, 0x80,
  0x19, 0x80, 0x30, 0x80, 0x19, 0x80, 0x30, 0x80, 0x31, 0x80, 0x60, 0x80,
  0x31, 0x80, 0x60, 0x80, 0x21, 0x80, 0x40, 0x80, 0x61, 0x80, 0xC0, 0x80,
  0x61, 0x80, 0xC0, 0x80, 0xC1, 0x81, 0x80, 0x80, 0xC1, 0x81, 0x80, 0x80,
  0x81, 0x83, 0x00, 0xC1, 0x81, 0x83, 0x00, 0xC1, 0x81, 0x83, 0x00, 0xC3,
  0x01, 0x86, 0x00, 0xC3, 0x01, 0x86, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0xC6,
  0x01, 0x8C, 0x00, 0xC4, 0x01, 0x88, 0x00, 0xCC, 0x01, 0x98, 0x00, 0xCC,
  0x01, 0x98, 0x00, 0xD8, 0x01, 0x30, 0x00, 0xD8, 0x01, 0x30, 0x00, 0x90,
  0x01, 0x20, 0x00, 0xB0, 0x01, 0x60, 0x00, 0xA0, 0x01, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x02, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x08, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x84, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0xF0, 0x00, 0x64, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x70, 0x20, 0x18, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x46,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x08,
  0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C,
  0x60, 0x01, 0x86, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0x81, 0x80, 0x0C, 0x18, 0x00, 0xC3,
  0x00, 0x06, 0x30, 0x00, 0x6E, 0x00, 0x07, 0xFF, 0xFE, 0xC3, 0x18, 0x61,
  0x0C, 0x20, 0x01, 0xFC, 0x60, 0x79, 0xC8, 0x1C, 0x09, 0x06, 0x01, 0xE1,
  0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x04, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60,
  0x07, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x0F, 0x03, 0x03, 0x60, 0x71,
  0xCC, 0x07, 0xF1, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x1F, 0x80, 0x6E, 0x38, 0x09,
  0x81, 0x83, 0x60, 0x30, 0x78, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x0C, 0x30,
  0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x11, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x70, 0x06, 0x1A, 0x01,
  0x83, 0x60, 0x70, 0x4E, 0x1C, 0x08, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0x8C,
  0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x38, 0x60, 0x3F, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x03, 0xF8, 0xC0, 0x3C, 0xE6, 0x03, 0x81, 0xA0, 0x30, 0x07,
  0x03, 0x80, 0x38, 0x18, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x40,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x60, 0x07, 0x03, 0x00, 0x38, 0x18, 0x03, 0xC0, 0xC0, 0x14, 0x06,
  0x01, 0xE0, 0x18, 0x1B, 0x00, 0xE3, 0x98, 0x03, 0xF8, 0xC0, 0x00, 0x01,
  0xFC, 0x03, 0x8E, 0x06, 0x06, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x30,
  0x03, 0x30, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x38, 0x40, 0xF0, 0xFF,
  0xC0, 0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x10, 0x38,
  0x70, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x88, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x18, 0x07, 0x9C, 0xC0, 0x70, 0x34, 0x06, 0x00, 0xA0, 0x70,
  0x07, 0x03, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x08, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x78, 0x18, 0x02, 0x80, 0xC0, 0x3C,
  0x03, 0x03, 0x60, 0x1C, 0x73, 0x00, 0x7F, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0xC0, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0xFC, 0x06, 0xE3, 0x81, 0x60, 0x30,
  0xD0, 0x0C, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60,
  0x02, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x40, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x06, 0x01, 0x81, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30,
  0x0C, 0x18, 0x03, 0x0E, 0x00, 0x83, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06,
  0x60, 0x01, 0x38, 0x00, 0xDB, 0x00, 0x34, 0xC0, 0x0F, 0x30, 0x03, 0x84,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x06, 0x7F, 0x07, 0xE0, 0x27, 0x38,
  0xE3, 0x81, 0x60, 0x6C, 0x0C, 0x1E, 0x03, 0x40, 0x30, 0xE0, 0x1C, 0x01,
  0x87, 0x00, 0xE0, 0x0C, 0x30, 0x06, 0x00, 0x61, 0x80, 0x30, 0x02, 0x18,
  0x01, 0x80, 0x30, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0xC0, 0x0C, 0x30, 0x06,
  0x00, 0x63, 0x00, 0x30, 0x02, 0x18, 0x01, 0x80, 0x30, 0xC0, 0x08, 0x01,
  0x86, 0x00, 0xC0, 0x0C, 0x20, 0x06, 0x00, 0x63, 0x00, 0x30, 0x06, 0x18,
  0x01, 0x80, 0x30, 0xC0, 0x08, 0x01, 0x86, 0x00, 0xC0, 0x0C, 0x20, 0x06,
  0x00, 0x43, 0x00, 0x30, 0x06, 0x18, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x01,
  0x86, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x3F, 0x01, 0x3C, 0xE0, 0x58, 0x1C,
  0x3C, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18,
  0x00, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x43, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x00, 0x01, 0xFC, 0x01, 0xE7, 0x01, 0x80, 0xC1, 0x80,
  0x71, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x60, 0x78, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0xC7, 0xE0, 0x02, 0x31, 0xC0, 0x09, 0x81, 0x80, 0x6C, 0x06, 0x01,
  0xE0, 0x0C, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x80,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x38, 0x03,
  0x01, 0xA0, 0x1C, 0x06, 0xC0, 0xE0, 0x1B, 0x8F, 0x00, 0x67, 0xF0, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x60, 0x79, 0xCC, 0x18,
  0x0D, 0x06, 0x01, 0xA1, 0xC0, 0x1C, 0x30, 0x03, 0x8C, 0x00, 0x71, 0x80,
  0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C, 0x01, 0xE1, 0x80, 0x28, 0x30, 0x0F,
  0x03, 0x03, 0x60, 0x71, 0xCC, 0x07, 0xF1, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x3E, 0x09, 0xE8, 0x16, 0x00, 0x68, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x03, 0xFE, 0x07, 0x8F, 0x0C, 0x01, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x80, 0x70, 0xE0, 0xE0, 0xFF, 0x80, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x0F, 0xF9, 0xFF, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x83, 0xF0, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x08, 0x60, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x00,
  0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x1C, 0x30, 0x0F, 0x0C, 0x02, 0x83, 0x01, 0x20, 0xE1, 0x98, 0x1F, 0xC6,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03,
  0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x06, 0x06, 0x0C,
  0x08, 0x18, 0x30, 0x30, 0x40, 0x61, 0x80, 0xC3, 0x00, 0x8C, 0x01, 0x18,
  0x02, 0x60, 0x04, 0xC0, 0x0B, 0x00, 0x16, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xD8,
  0x07, 0x80, 0x6C, 0x03, 0xC0, 0x66, 0x03, 0x60, 0x33, 0x01, 0xB0, 0x19,
  0x80, 0x98, 0x18, 0xC0, 0xCC, 0x0C, 0x60, 0x46, 0x0C, 0x30, 0x63, 0x06,
  0x18, 0x31, 0x82, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x61, 0x83, 0x18, 0x31,
  0x81, 0x8C, 0x18, 0xC0, 0xC4, 0x0C, 0x40, 0x66, 0x06, 0x60, 0x32, 0x03,
  0x30, 0x1B, 0x01, 0xB0, 0x0D, 0x80, 0xD8, 0x07, 0x80, 0x68, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x30, 0x06, 0x01, 0x00, 0x60, 0x18, 0x0C, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x04,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00,
  0xE0, 0x80, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x60, 0x06, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x08, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x61, 0x80, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x09, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x7E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x07, 0x87, 0x81,
  0xC0, 0x3F, 0xE8, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 35, 10, 1, -35 },
  { 45, 11, 13, 14, 5, -35 },
  { 63, 22, 35, 22, 1, -35 },
  { 160, 20, 40, 20, 0, -37 },
  { 260, 25, 36, 30, 3, -35 },
  { 373, 21, 35, 22, 0, -35 },
  { 465, 4, 13, 8, 5, -35 },
  { 472, 14, 43, 12, 1, -35 },
  { 548, 13, 43, 12, -3, -35 },
  { 618, 15, 16, 19, 6, -37 },
  { 648, 19, 23, 22, 2, -29 },
  { 703, 7, 11, 9, -2, -5 },
  { 713, 11, 2, 14, 1, -14 },
  { 716, 3, 4, 9, 1, -4 },
  { 718, 21, 35, 15, -2, -35 },
  { 810, 18, 35, 20, 2, -35 },
  { 889, 10, 35, 20, 6, -35 },
  { 933, 21, 35, 20, -1, -35 },
  { 1025, 20, 36, 20, 0, -35 },
  { 1115, 20, 35, 20, 0, -35 },
  { 1203, 20, 35, 20, 0, -35 },
  { 1291, 19, 35, 20, 2, -35 },
  { 1375, 19, 35, 20, 3, -35 },
  { 1459, 20, 35, 20, 0, -35 },
  { 1547, 19, 35, 20, 1, -35 },
  { 1631, 8, 26, 9, 0, -26 },
  { 1657, 10, 32, 9, -2, -26 },
  { 1697, 19, 21, 22, 2, -28 },
  { 1747, 19, 12, 22, 2, -23 },
  { 1776, 19, 21, 22, 2, -28 },
  { 1826, 14, 35, 15, 2, -35 },
  { 1888, 27, 39, 30, 2, -35 },
  { 2020, 20, 35, 20, -3, -35 },
  { 2108, 21, 35, 22, 1, -35 },
  { 2200, 22, 36, 21, 2, -36 },
  { 2299, 22, 35, 24, 1, -35 },
  { 2396, 20, 35, 20, 1, -35 },
  { 2484, 20, 35, 18, 1, -35 },
  { 2572, 24, 36, 26, 2, -36 },
  { 2680, 25, 35, 25, 1, -35 },
  { 2790, 16, 35, 11, -2, -35 },
  { 2860, 17, 44, 9, -7, -35 },
  { 2954, 23, 35, 20, 1, -35 },
  { 3055, 13, 35, 18, 1, -35 },
  { 3112, 32, 35, 32, 1, -35 },
  { 3252, 26, 35, 26, 1, -35 },
  { 3366, 23, 35, 26, 2, -35 },
  { 3467, 20, 35, 21, 1, -35 },
  { 3555, 23, 43, 26, 2, -35 },
  { 3679, 20, 35, 21, 1, -35 },
  { 3767, 21, 35, 19, -1, -35 },
  { 3859, 18, 35, 18, 4, -35 },
  { 3938, 24, 35, 25, 2, -35 },
  { 4043, 20, 35, 20, 4, -35 },
  { 4131, 32, 35, 33, 5, -35 },
  { 4271, 25, 35, 18, -3, -35 },
  { 4381, 18, 35, 18, 4, -35 },
  { 4460, 23, 35, 19, -2, -35 },
  { 4561, 18, 43, 14, -1, -35 },
  { 4658, 7, 35, 16, 5, -35 },
  { 4689, 18, 43, 14, -3, -35 },
  { 4786, 20, 18, 22, 1, -35 },
  { 4831, 15, 1, 15, -4, 5 },
  { 4833, 5, 7, 11, 7, -37 },
  { 4838, 19, 26, 21, 2, -26 },
  { 4900, 19, 37, 21, 1, -37 },
  { 4988, 15, 26, 16, 2, -26 },
  { 5037, 21, 37, 22, 2, -37 },
  { 5135, 16, 26, 19, 2, -26 },
  { 5187, 23, 49, 11, -6, -37 },
  { 5328, 21, 38, 22, 0, -26 },
  { 5428, 18, 37, 21, 1, -37 },
  { 5512, 9, 35, 9, 1, -35 },
  { 5552, 17, 47, 9, -7, -35 },
  { 5652, 18, 37, 17, 1, -37 },
  { 5736, 9, 37, 9, 1, -37 },
  { 5778, 29, 26, 32, 1, -26 },
  { 5873, 18, 26, 21, 1, -26 },
  { 5932, 17, 26, 21, 2, -26 },
  { 5988, 22, 37, 21, -2, -26 },
  { 6090, 19, 38, 22, 2, -26 },
  { 6181, 15, 26, 14, 1, -26 },
  { 6230, 16, 26, 16, 0, -26 },
  { 6282, 11, 32, 11, 1, -32 },
  { 6326, 18, 26, 21, 2, -26 },
  { 6385, 15, 26, 16, 3, -26 },
  { 6434, 25, 26, 26, 3, -26 },
  { 6516, 20, 26, 17, -2, -26 },
  { 6581, 24, 38, 17, -5, -26 },
  { 6695, 17, 26, 15, -1, -26 },
  { 6751, 18, 43, 16, 1, -35 },
  { 6848, 2, 49, 20, 9, -37 },
  { 6861, 17, 43, 16, -3, -35 },
  { 6953, 19, 5, 22, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC49PT7B_H_
