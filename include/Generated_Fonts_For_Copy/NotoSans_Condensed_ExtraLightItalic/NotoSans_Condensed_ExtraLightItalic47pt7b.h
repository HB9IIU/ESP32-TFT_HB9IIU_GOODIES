#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
  0xC0, 0xE0, 0x60, 0x00, 0x30, 0xCC, 0x32, 0x09, 0x86, 0x61, 0x98, 0x64,
  0x19, 0x04, 0xC1, 0x30, 0xC8, 0x32, 0x08, 0x82, 0x00, 0x00, 0x10, 0x30,
  0x01, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x20, 0x01, 0x03, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x18, 0x10, 0x00, 0x81, 0x80, 0x0C, 0x08,
  0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0xC0, 0x06, 0x04, 0x03, 0xFF, 0xFF, 0x01, 0x03, 0x00,
  0x18, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02,
  0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x01, 0xCC, 0x60, 0x30, 0x80, 0x06,
  0x08, 0x00, 0x60, 0x80, 0x04, 0x18, 0x00, 0x41, 0x80, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x06, 0x10, 0x00, 0x73, 0x00, 0x03, 0x20, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x04, 0xC0, 0x00, 0x46,
  0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x08,
  0x30, 0x00, 0x83, 0x00, 0x18, 0x60, 0x01, 0x86, 0x0C, 0x11, 0xC0, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x0C, 0x0F, 0xC0, 0x08, 0x18,
  0x60, 0x18, 0x10, 0x60, 0x10, 0x30, 0x60, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0x40, 0x60, 0x80, 0xC0, 0x61, 0x80, 0xC0,
  0x41, 0x00, 0xC0, 0x43, 0x00, 0xC0, 0xC6, 0x00, 0x80, 0xC6, 0x00, 0x80,
  0x8C, 0x7C, 0x81, 0x8C, 0xC6, 0x81, 0x99, 0x82, 0x83, 0x11, 0x83, 0xC2,
  0x33, 0x03, 0x6E, 0x63, 0x03, 0x38, 0x62, 0x02, 0x00, 0xC6, 0x02, 0x00,
  0xC6, 0x02, 0x01, 0x84, 0x06, 0x01, 0x04, 0x06, 0x03, 0x0C, 0x06, 0x06,
  0x0C, 0x04, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18,
  0x0C, 0x18, 0x10, 0x0C, 0x30, 0x30, 0x06, 0x30, 0x60, 0x07, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0xC1, 0x80, 0x0C, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x10, 0x18, 0x01, 0x01,
  0x80, 0x10, 0x30, 0x01, 0x03, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x19,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x06,
  0x60, 0x00, 0xC3, 0x03, 0x18, 0x30, 0x23, 0x01, 0x06, 0x30, 0x18, 0x66,
  0x01, 0x8C, 0x60, 0x0C, 0xC4, 0x00, 0xD8, 0xC0, 0x05, 0x8C, 0x00, 0x70,
  0xC0, 0x06, 0x0C, 0x00, 0xF0, 0x60, 0x0B, 0x06, 0x03, 0x98, 0x38, 0xE1,
  0x81, 0xFC, 0x1C, 0x33, 0x26, 0x66, 0x44, 0xCC, 0x88, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x83, 0x03, 0x8C, 0x03, 0xA0, 0x43, 0xBF, 0x07, 0x00,
  0x3C, 0x01, 0x90, 0x0C, 0x60, 0x60, 0x83, 0x03, 0x00, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x30, 0xC6, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xFC,
  0x5F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xE0, 0xC0, 0x60, 0x60,
  0x60, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x04, 0xC0,
  0x02, 0x40, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x19, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x06,
  0x10, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x80, 0x71,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x78, 0x36, 0x19, 0x9C, 0x6C,
  0x12, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0xE0, 0x10, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1E, 0x03, 0x01, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x04, 0x01, 0xC0, 0xE0, 0xF0, 0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x2C,
  0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x44, 0x00, 0x18, 0x80, 0x06, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x18, 0x18, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01,
  0x00, 0x60, 0x60, 0x08, 0x18, 0x03, 0x02, 0x00, 0x60, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x04, 0x01,
  0xC0, 0xE0, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x30, 0x06, 0x7F, 0x81, 0xB8, 0x70, 0x78, 0x0E, 0x14, 0x01, 0x8E, 0x00,
  0x63, 0x80, 0x18, 0xC0, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x06, 0x0C, 0x03, 0x81, 0x81, 0xC0, 0x78, 0xE0, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0x03, 0x01,
  0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x08, 0x30, 0x01, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x00, 0x60, 0x30, 0x18, 0x03,
  0x06, 0x00, 0x73, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1C,
  0x70, 0x06, 0x07, 0x01, 0x80, 0x60, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x08, 0x40, 0x01, 0x18, 0x00, 0x33, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00,
  0x30, 0x80, 0x06, 0x18, 0x01, 0x83, 0x80, 0x60, 0x3C, 0x38, 0x01, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x38, 0x30, 0x18, 0x06, 0x06, 0x01,
  0x83, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x86, 0x01, 0xE1, 0xC0, 0xD0, 0x3F, 0xEC, 0x07, 0xE3,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x83, 0x80, 0x3F, 0x80, 0x00, 0x03, 0x07, 0x07, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x60, 0xE0, 0x60, 0x00, 0xC0, 0x70, 0x1C, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xC1, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x20, 0x00, 0x08, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x31, 0x80, 0x7F, 0x04, 0x40, 0x39, 0x81, 0x30, 0x38, 0x60, 0x4C,
  0x0C, 0x18, 0x36, 0x06, 0x06, 0x0D, 0x83, 0x01, 0x03, 0x60, 0xC0, 0xC0,
  0xD0, 0x20, 0x30, 0x3C, 0x18, 0x0C, 0x0B, 0x06, 0x02, 0x06, 0xC1, 0x01,
  0x81, 0xA0, 0x40, 0x60, 0x48, 0x30, 0x18, 0x32, 0x0C, 0x0C, 0x0C, 0x83,
  0x03, 0x06, 0x20, 0x41, 0x41, 0x88, 0x18, 0xD8, 0xC2, 0x07, 0xE3, 0xE0,
  0x80, 0x70, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0D, 0x80,
  0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x80, 0x18, 0x10, 0x02, 0x02, 0x00,
  0xC0, 0x40, 0x18, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x3F, 0xFE, 0x06,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0x01, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x03, 0x80, 0x83, 0xF0, 0x1F, 0xF8,
  0x01, 0x80, 0xE0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x00, 0x83, 0x00, 0x08, 0x30, 0x01, 0x82, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x70, 0x40, 0x0E, 0x0C,
  0x01, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xC0, 0x1C, 0x04, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xC0, 0xF0, 0x06, 0x01, 0xC0,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x60,
  0xC0, 0x07, 0x06, 0x00, 0x30, 0x20, 0x03, 0x03, 0x00, 0x70, 0x18, 0x0F,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x1F,
  0xFE, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0F,
  0xF1, 0x00, 0x1F, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC1,
  0x00, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x40, 0x0F, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x01,
  0x80, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x04, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x1F,
  0xFF, 0xF0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xCE, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x30, 0x03, 0x00,
  0xC0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x20, 0x18, 0x01, 0x80,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x70, 0x00, 0x1B,
  0xC0, 0x00, 0x69, 0x00, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x20,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x58, 0x00, 0x0D, 0x80, 0xB0, 0x00, 0x1A, 0x03, 0x60, 0x00, 0x6C, 0x06,
  0xC0, 0x00, 0xD8, 0x0C, 0x80, 0x03, 0x30, 0x11, 0x00, 0x06, 0x60, 0x62,
  0x00, 0x18, 0x80, 0xC4, 0x00, 0x33, 0x01, 0x88, 0x00, 0xC6, 0x03, 0x18,
  0x01, 0x8C, 0x04, 0x30, 0x06, 0x10, 0x18, 0x60, 0x0C, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x61, 0x80, 0x61, 0x80, 0xC3, 0x01, 0x83, 0x01, 0x06, 0x02,
  0x04, 0x06, 0x04, 0x0C, 0x18, 0x0C, 0x08, 0x10, 0x30, 0x18, 0x10, 0x60,
  0x60, 0x20, 0x20, 0x80, 0xC0, 0x40, 0x63, 0x01, 0x01, 0x80, 0xC4, 0x06,
  0x03, 0x01, 0x98, 0x0C, 0x06, 0x03, 0x20, 0x18, 0x08, 0x06, 0xC0, 0x20,
  0x30, 0x0D, 0x00, 0xC0, 0x60, 0x1E, 0x01, 0x80, 0xC0, 0x38, 0x03, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xE0,
  0x00, 0xC0, 0x78, 0x00, 0x60, 0x3C, 0x00, 0x30, 0x16, 0x00, 0x18, 0x09,
  0x00, 0x08, 0x0C, 0xC0, 0x0C, 0x06, 0x60, 0x06, 0x03, 0x30, 0x03, 0x01,
  0x08, 0x01, 0x01, 0x86, 0x01, 0x80, 0xC3, 0x00, 0xC0, 0x61, 0x80, 0x60,
  0x30, 0x40, 0x30, 0x10, 0x30, 0x10, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x06, 0x02, 0x06, 0x03, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x01, 0x80, 0x61,
  0x80, 0xC0, 0x10, 0xC0, 0x60, 0x0C, 0x60, 0x30, 0x06, 0x20, 0x10, 0x03,
  0x30, 0x18, 0x00, 0x98, 0x0C, 0x00, 0x6C, 0x06, 0x00, 0x36, 0x02, 0x00,
  0x1A, 0x03, 0x00, 0x05, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00,
  0x60, 0x0E, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x90, 0x00, 0x06, 0xC0, 0x00,
  0x13, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80,
  0x0E, 0x07, 0x00, 0x30, 0x0C, 0x03, 0x80, 0x1C, 0x3C, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x0C, 0x0E, 0x01, 0x80, 0x60, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00,
  0x30, 0x40, 0x0C, 0x18, 0x03, 0x03, 0x01, 0xC0, 0x7F, 0xF0, 0x0F, 0xF0,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x60, 0x0E, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C,
  0x10, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x30, 0x0C,
  0x03, 0x80, 0x1C, 0x3C, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x0C,
  0x0E, 0x01, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x04, 0x18, 0x01, 0x83, 0x00, 0x70, 0x40, 0x0C, 0x18, 0x07, 0x03, 0x07,
  0xC0, 0x7F, 0xE0, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x06,
  0x18, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x38, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x10, 0x01, 0x80, 0xF0, 0x78, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x38, 0x06, 0x00, 0x38, 0x38, 0x00, 0x3F, 0xE0, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x06, 0x08, 0x00, 0xC1,
  0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x10, 0x06, 0x02,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06,
  0x0C, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x63, 0x00, 0x0C,
  0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xA0, 0x01, 0xC0, 0x06,
  0x80, 0x0F, 0x00, 0x12, 0x00, 0x3C, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x20,
  0x06, 0xC0, 0x18, 0x80, 0x13, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x08, 0x03,
  0x30, 0x0C, 0x20, 0x18, 0xC0, 0x30, 0x80, 0x63, 0x01, 0x82, 0x01, 0x0C,
  0x06, 0x08, 0x0C, 0x30, 0x30, 0x20, 0x20, 0xC0, 0xC0, 0x81, 0x83, 0x02,
  0x02, 0x06, 0x0C, 0x18, 0x08, 0x30, 0x30, 0x60, 0x20, 0xC0, 0xC3, 0x00,
  0x82, 0x03, 0x0C, 0x02, 0x18, 0x0C, 0x20, 0x08, 0x60, 0x31, 0x80, 0x23,
  0x00, 0xC6, 0x00, 0x8C, 0x03, 0x30, 0x02, 0x20, 0x0C, 0xC0, 0x09, 0x80,
  0x32, 0x00, 0x24, 0x00, 0xD8, 0x00, 0xB0, 0x03, 0x40, 0x02, 0xC0, 0x0F,
  0x00, 0x0A, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xA0, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x20, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x03, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0,
  0x01, 0xE0, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x61,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x18, 0x08, 0x18, 0x06, 0x0C,
  0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0B,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x83,
  0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x81, 0x03, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x61, 0x00, 0x08, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xF0, 0xC6,
  0x18, 0xC3, 0x08, 0x61, 0x01, 0xF8, 0xC0, 0xE7, 0x30, 0x60, 0x68, 0x30,
  0x0A, 0x18, 0x03, 0x86, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01, 0xC3, 0x00,
  0x70, 0xC0, 0x3C, 0x30, 0x0A, 0x0E, 0x04, 0x81, 0xC6, 0x60, 0x3F, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0xF8, 0x04, 0xE7, 0x03, 0x60, 0x60, 0xF0, 0x08, 0x38,
  0x03, 0x0E, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xC4, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x62,
  0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80,
  0x18, 0xF0, 0x0C, 0x34, 0x06, 0x09, 0xC7, 0x02, 0x3F, 0x80, 0x01, 0xFE,
  0x07, 0x98, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x20, 0x3F, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x1F, 0x8C, 0x03, 0x9C, 0xC0, 0x60, 0x6C, 0x0C, 0x02, 0x81, 0x80,
  0x38, 0x18, 0x03, 0x83, 0x00, 0x38, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0C, 0x08, 0x01, 0xC0,
  0xC0, 0x1C, 0x0C, 0x03, 0xC0, 0xC0, 0x2C, 0x0E, 0x06, 0x80, 0x71, 0xC8,
  0x03, 0xF1, 0x80, 0x01, 0xF8, 0x07, 0x18, 0x18, 0x18, 0x60, 0x31, 0x80,
  0x62, 0x00, 0xCC, 0x01, 0x90, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x01, 0xC6,
  0x1F, 0x0F, 0xF0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C, 0x30,
  0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x02, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x30, 0x0E, 0x73, 0x01, 0x81, 0xB0, 0x30, 0x0A, 0x06, 0x00,
  0xE0, 0x60, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x20, 0x03, 0x82, 0x00, 0x30, 0x20, 0x07, 0x03,
  0x00, 0x70, 0x30, 0x0F, 0x03, 0x01, 0xA0, 0x38, 0x1A, 0x01, 0xC7, 0x60,
  0x0F, 0xC6, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x08, 0x07,
  0x00, 0xE1, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xCF, 0xC0, 0x4E, 0x70, 0x6C, 0x0C,
  0x3C, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x10, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x01, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x10, 0x03, 0x00, 0x01,
  0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x9C, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x40, 0x30,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x18, 0x06, 0x18,
  0x03, 0x18, 0x01, 0x98, 0x00, 0x9C, 0x00, 0xCE, 0x00, 0x6D, 0x00, 0x3C,
  0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x01, 0x80, 0x80, 0x40, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x10, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x04, 0x7E, 0x0F, 0xC0, 0x4C, 0x73,
  0x8E, 0x0D, 0x03, 0x60, 0x60, 0xE0, 0x14, 0x02, 0x0E, 0x01, 0xC0, 0x30,
  0xC0, 0x18, 0x02, 0x1C, 0x01, 0x80, 0x21, 0x80, 0x30, 0x06, 0x18, 0x03,
  0x00, 0x61, 0x80, 0x30, 0x06, 0x10, 0x03, 0x00, 0x63, 0x00, 0x20, 0x04,
  0x30, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x0C, 0x30, 0x06, 0x00, 0xC2, 0x00,
  0x40, 0x08, 0x60, 0x0C, 0x01, 0x86, 0x00, 0xC0, 0x18, 0x60, 0x0C, 0x01,
  0x86, 0x00, 0xC0, 0x18, 0x40, 0x08, 0x01, 0x0C, 0x01, 0x80, 0x30, 0xC0,
  0x18, 0x03, 0x0C, 0x01, 0x80, 0x30, 0x80, 0x18, 0x03, 0x00, 0x04, 0x7F,
  0x02, 0x73, 0x83, 0x60, 0x61, 0xE0, 0x30, 0xE0, 0x18, 0x60, 0x0C, 0x70,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x18, 0x01, 0x0C, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x10, 0x80, 0x18, 0x00, 0x01, 0xFC, 0x03, 0x8E, 0x06, 0x06, 0x0C, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x30, 0x01, 0x30, 0x01, 0x60, 0x01, 0x60, 0x01,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38,
  0x60, 0x70, 0x70, 0xE0, 0x3F, 0x80, 0x00, 0x87, 0xC0, 0x04, 0xE7, 0x00,
  0x6C, 0x0C, 0x03, 0xC0, 0x30, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x06, 0x00,
  0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0,
  0x0C, 0x0F, 0x00, 0xC0, 0x68, 0x0C, 0x03, 0x61, 0xC0, 0x11, 0xFC, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0xC0, 0xE7, 0x30, 0x60, 0x6C,
  0x30, 0x0A, 0x18, 0x03, 0x86, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0x80, 0x0E, 0x20, 0x03, 0x08, 0x01, 0xC3,
  0x00, 0x70, 0xC0, 0x3C, 0x30, 0x0B, 0x0C, 0x06, 0x81, 0xC7, 0x60, 0x3F,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x04, 0x7C, 0x13, 0x90, 0xD8, 0x03, 0xC0, 0x0A, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x03, 0xFC,
  0x0E, 0x3C, 0x30, 0x08, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x20, 0x18, 0x70, 0xE0, 0xFF, 0x80, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0xF9, 0xFF, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC4, 0x1F, 0x00, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x21, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x10,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x21, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x10, 0x03, 0x08, 0x03,
  0x84, 0x03, 0xC3, 0x03, 0x41, 0xC3, 0x20, 0x7F, 0x10, 0x00, 0x80, 0x07,
  0x00, 0x1A, 0x00, 0x34, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60,
  0x30, 0xC0, 0x61, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x60,
  0x30, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x02, 0x40, 0x05,
  0x80, 0x0A, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x02, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x06, 0xC0, 0x68, 0x0C,
  0xC0, 0x48, 0x0C, 0xC0, 0xC8, 0x08, 0xC0, 0xC8, 0x18, 0xC0, 0x88, 0x18,
  0xC1, 0x88, 0x30, 0xC1, 0x08, 0x30, 0xC3, 0x08, 0x20, 0xC2, 0x08, 0x60,
  0xC6, 0x08, 0x40, 0xC6, 0x08, 0xC0, 0xCC, 0x08, 0xC0, 0xCC, 0x08, 0x80,
  0xC8, 0x09, 0x80, 0xD8, 0x09, 0x00, 0xD0, 0x0B, 0x00, 0xF0, 0x0B, 0x00,
  0xF0, 0x0A, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x10, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x30, 0x00, 0x86, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x0D,
  0x80, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xB0, 0x00, 0x1B, 0x00, 0x03, 0x10, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0xC1, 0x80, 0x18, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0,
  0xC0, 0x04, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x04, 0x01, 0x80, 0x08, 0x03, 0x00, 0x10, 0x0C, 0x00,
  0x20, 0x18, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x31,
  0x80, 0x00, 0x62, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x02, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x1C, 0x0E, 0x1E, 0x00, 0xFE, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 10, 13, 14, 5, -34 },
  { 57, 21, 34, 21, 1, -34 },
  { 147, 20, 39, 19, 0, -36 },
  { 245, 24, 35, 29, 3, -34 },
  { 350, 20, 34, 21, 0, -34 },
  { 435, 4, 13, 8, 5, -34 },
  { 442, 13, 40, 12, 1, -33 },
  { 507, 13, 40, 12, -3, -33 },
  { 572, 14, 16, 18, 6, -36 },
  { 600, 18, 21, 21, 2, -27 },
  { 648, 6, 11, 8, -2, -5 },
  { 657, 11, 2, 13, 1, -14 },
  { 660, 3, 4, 8, 1, -4 },
  { 662, 20, 34, 14, -2, -34 },
  { 747, 17, 34, 19, 2, -34 },
  { 820, 10, 34, 19, 6, -34 },
  { 863, 20, 34, 19, -1, -34 },
  { 948, 19, 35, 19, 0, -34 },
  { 1032, 19, 34, 19, 0, -34 },
  { 1113, 19, 34, 19, 0, -34 },
  { 1194, 18, 34, 19, 2, -34 },
  { 1271, 18, 34, 19, 3, -34 },
  { 1348, 19, 34, 19, 0, -34 },
  { 1429, 18, 34, 19, 1, -34 },
  { 1506, 8, 25, 8, 0, -25 },
  { 1531, 10, 31, 9, -2, -25 },
  { 1570, 18, 20, 21, 2, -27 },
  { 1615, 18, 11, 21, 2, -22 },
  { 1640, 18, 20, 21, 2, -27 },
  { 1685, 14, 34, 14, 2, -34 },
  { 1745, 26, 38, 29, 2, -34 },
  { 1869, 19, 34, 19, -3, -34 },
  { 1950, 20, 34, 21, 1, -34 },
  { 2035, 21, 34, 20, 2, -34 },
  { 2125, 21, 34, 23, 1, -34 },
  { 2215, 20, 34, 19, 1, -34 },
  { 2300, 20, 34, 17, 1, -34 },
  { 2385, 23, 34, 25, 2, -34 },
  { 2483, 24, 34, 24, 1, -34 },
  { 2585, 15, 34, 10, -2, -34 },
  { 2649, 17, 42, 9, -7, -34 },
  { 2739, 22, 34, 20, 1, -34 },
  { 2833, 12, 34, 17, 1, -34 },
  { 2884, 31, 34, 31, 1, -34 },
  { 3016, 25, 34, 25, 1, -34 },
  { 3123, 22, 34, 25, 2, -34 },
  { 3217, 19, 34, 20, 1, -34 },
  { 3298, 22, 42, 25, 2, -34 },
  { 3414, 19, 34, 20, 1, -34 },
  { 3495, 21, 34, 19, -1, -34 },
  { 3585, 17, 34, 17, 4, -34 },
  { 3658, 23, 34, 24, 2, -34 },
  { 3756, 19, 34, 19, 4, -34 },
  { 3837, 30, 34, 32, 5, -34 },
  { 3965, 24, 34, 17, -3, -34 },
  { 4067, 17, 34, 17, 4, -34 },
  { 4140, 22, 34, 18, -2, -34 },
  { 4234, 17, 41, 13, -1, -34 },
  { 4322, 7, 34, 15, 5, -34 },
  { 4352, 17, 41, 13, -3, -34 },
  { 4440, 19, 18, 21, 1, -34 },
  { 4483, 14, 2, 14, -4, 4 },
  { 4487, 5, 8, 10, 7, -36 },
  { 4492, 18, 25, 21, 2, -25 },
  { 4549, 18, 36, 21, 1, -36 },
  { 4630, 15, 25, 16, 2, -25 },
  { 4677, 20, 36, 21, 2, -36 },
  { 4767, 15, 25, 18, 2, -25 },
  { 4814, 22, 47, 10, -6, -36 },
  { 4944, 20, 36, 21, 0, -25 },
  { 5034, 17, 36, 20, 1, -36 },
  { 5111, 9, 34, 8, 1, -34 },
  { 5150, 16, 45, 9, -6, -34 },
  { 5240, 17, 36, 17, 1, -36 },
  { 5317, 9, 36, 8, 1, -36 },
  { 5358, 28, 25, 30, 1, -25 },
  { 5446, 17, 25, 20, 1, -25 },
  { 5500, 16, 25, 20, 2, -25 },
  { 5550, 21, 36, 21, -2, -25 },
  { 5645, 18, 36, 21, 2, -25 },
  { 5726, 14, 25, 13, 1, -25 },
  { 5770, 15, 25, 15, 0, -25 },
  { 5817, 11, 31, 11, 1, -31 },
  { 5860, 17, 25, 20, 2, -25 },
  { 5914, 15, 25, 15, 3, -25 },
  { 5961, 24, 25, 25, 3, -25 },
  { 6036, 20, 25, 16, -2, -25 },
  { 6099, 23, 36, 16, -5, -25 },
  { 6203, 16, 25, 14, -1, -25 },
  { 6253, 17, 41, 15, 1, -34 },
  { 6341, 2, 47, 19, 9, -36 },
  { 6353, 17, 41, 15, -3, -34 },
  { 6441, 18, 5, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC47PT7B_H_
