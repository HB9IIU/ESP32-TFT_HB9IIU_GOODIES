#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC62PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x00, 0x1C, 0x1C, 0x60, 0x61, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x30, 0x31, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61,
  0x01, 0x0C, 0x0C, 0x30, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x01,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFC, 0x01, 0xF3, 0x1F, 0x01, 0xE1, 0x81, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0x40, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x78, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x87,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0xC0, 0x80, 0xC1, 0xC0, 0x70,
  0x63, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x70, 0x1C, 0x70, 0x00, 0xC0, 0x70, 0x60, 0x03, 0x00, 0xC0,
  0xC0, 0x06, 0x03, 0x01, 0x80, 0x18, 0x06, 0x03, 0x80, 0x30, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x1C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x01, 0x81,
  0x80, 0x30, 0x07, 0x06, 0x00, 0x60, 0x0C, 0x1C, 0x00, 0xC0, 0x18, 0x30,
  0x01, 0x80, 0x30, 0xE0, 0x03, 0x00, 0xE1, 0x83, 0xE6, 0x01, 0x86, 0x1F,
  0xEC, 0x03, 0x0C, 0x70, 0xD8, 0x0E, 0x30, 0xC1, 0xF0, 0x18, 0xE3, 0x01,
  0xE0, 0x71, 0x8E, 0x03, 0xC1, 0xC7, 0x18, 0x07, 0xC7, 0x0C, 0x70, 0x0D,
  0xFC, 0x30, 0xC0, 0x19, 0xF0, 0x61, 0x80, 0x30, 0x01, 0x87, 0x00, 0x60,
  0x07, 0x0C, 0x01, 0xC0, 0x0C, 0x18, 0x03, 0x00, 0x38, 0x30, 0x06, 0x00,
  0x60, 0x60, 0x0C, 0x01, 0x81, 0xC0, 0x18, 0x03, 0x03, 0x00, 0x70, 0x0C,
  0x06, 0x00, 0xC0, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x01,
  0xC1, 0xC0, 0x60, 0x01, 0x83, 0x01, 0xC0, 0x03, 0x9C, 0x03, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x0C,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x0E, 0x00,
  0x18, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x1C,
  0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xB0, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x70, 0x1C, 0x30, 0x0C,
  0x06, 0x18, 0x03, 0x01, 0x8E, 0x00, 0xE0, 0xE3, 0x00, 0x18, 0x31, 0xC0,
  0x07, 0x1C, 0x60, 0x00, 0xC6, 0x18, 0x00, 0x33, 0x86, 0x00, 0x0E, 0xC3,
  0x80, 0x01, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07,
  0x81, 0x80, 0x03, 0xE0, 0x60, 0x01, 0xD8, 0x1C, 0x00, 0xE7, 0x03, 0x80,
  0xF0, 0xC0, 0x7D, 0xF8, 0x38, 0x0F, 0xF8, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0xC0, 0xC0, 0x3C, 0x18, 0x01, 0xE3, 0x00, 0x0F, 0x60, 0xE0,
  0x7B, 0xFC, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x32, 0x00, 0x0C, 0x60, 0x03,
  0x04, 0x01, 0xC0, 0xC0, 0x70, 0x1C, 0x04, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x27, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0xF9, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80,
  0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x63, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00,
  0xE0, 0x30, 0x03, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x70,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x7C, 0x0F, 0x60, 0xE7, 0x0E, 0x31, 0xE1, 0x9C, 0x0C, 0x40,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF3, 0xF0, 0x01, 0xC0, 0x1C, 0x00,
  0x20, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xE1, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x20, 0x00, 0x78, 0x0E, 0x00, 0x7C, 0x03, 0xFD, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x18, 0x00,
  0x0C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x38,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC8, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x80, 0x03, 0x80, 0x30,
  0x03, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0x83, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x7F, 0x80, 0x39, 0xFF,
  0xC0, 0x33, 0xC1, 0xE0, 0x37, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x7C, 0x00,
  0x30, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x30, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE1, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0,
  0x1C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xC1, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x38,
  0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x18, 0x38, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0E, 0x01,
  0x80, 0x0E, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x1E, 0x0C, 0x00, 0x3E, 0x0E, 0x00, 0x6C, 0x07, 0x00, 0xEC, 0x07,
  0x83, 0xCC, 0x03, 0xFF, 0x1C, 0x00, 0xFC, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3E,
  0x3E, 0x06, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60, 0x01,
  0xF0, 0x06, 0x1C, 0x00, 0xFF, 0x80, 0xC3, 0x00, 0x38, 0x30, 0x18, 0x60,
  0x0C, 0x06, 0x03, 0x18, 0x03, 0x01, 0xC0, 0x63, 0x00, 0xC0, 0x30, 0x0C,
  0x60, 0x38, 0x06, 0x01, 0x98, 0x06, 0x00, 0xC0, 0x33, 0x01, 0xC0, 0x38,
  0x0E, 0x60, 0x30, 0x06, 0x01, 0x9C, 0x06, 0x00, 0xC0, 0x33, 0x01, 0x80,
  0x18, 0x06, 0x60, 0x30, 0x07, 0x00, 0xCC, 0x06, 0x00, 0xC0, 0x31, 0x80,
  0xC0, 0x18, 0x06, 0x70, 0x38, 0x07, 0x00, 0xCC, 0x06, 0x00, 0xE0, 0x31,
  0x80, 0xC0, 0x18, 0x06, 0x30, 0x18, 0x07, 0x01, 0xC6, 0x03, 0x00, 0xE0,
  0x30, 0xC0, 0x60, 0x3C, 0x0E, 0x18, 0x0E, 0x0C, 0x83, 0x83, 0x00, 0xE3,
  0x98, 0xE0, 0x60, 0x1F, 0xE3, 0xF8, 0x0C, 0x00, 0xF0, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01,
  0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x18, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0x80, 0x1E,
  0x00, 0x30, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00,
  0x60, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x03, 0x80, 0x60, 0x01, 0xE0, 0x0C, 0x01, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x00, 0x20, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x01, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x60, 0x1F, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x06,
  0x00, 0x1E, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x03, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x08, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0xFF,
  0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0xC7, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x3C, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x30, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x0C, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x06, 0x7C, 0x00, 0x00, 0x1B, 0xB0, 0x00, 0x00, 0x6C, 0xC0, 0x00, 0x03,
  0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x06, 0xC0, 0x00, 0x01, 0xF8, 0x03,
  0x60, 0x00, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x01, 0xD8, 0x00,
  0x00, 0x66, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x67, 0x00, 0x00, 0x33,
  0x00, 0x31, 0x80, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x1C,
  0x60, 0x00, 0x1C, 0xE0, 0x0E, 0x30, 0x00, 0x0C, 0x70, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x01, 0x86, 0x00, 0x06, 0x0C,
  0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0xC1, 0x80, 0x03, 0x07, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x30, 0x70, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01,
  0xC0, 0xC0, 0x1C, 0x0C, 0x00, 0xC0, 0xE0, 0x0C, 0x06, 0x00, 0xE0, 0x70,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x70, 0x18, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x1C, 0x03, 0x00, 0x30, 0x0C, 0x0C, 0x01, 0x80,
  0x38, 0x06, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x86, 0x00, 0xE0, 0x0C, 0x01,
  0xC7, 0x00, 0x60, 0x06, 0x00, 0x63, 0x00, 0x30, 0x03, 0x00, 0x33, 0x80,
  0x18, 0x03, 0x80, 0x19, 0x80, 0x1C, 0x01, 0x80, 0x0D, 0xC0, 0x0E, 0x00,
  0xC0, 0x06, 0xC0, 0x06, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0x30, 0x01,
  0xE0, 0x01, 0x80, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80, 0x1E,
  0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x70, 0x06,
  0xC0, 0x00, 0x38, 0x03, 0x70, 0x00, 0x18, 0x01, 0x98, 0x00, 0x0C, 0x01,
  0xCC, 0x00, 0x06, 0x00, 0xE6, 0x00, 0x07, 0x00, 0x63, 0x80, 0x03, 0x00,
  0x30, 0xC0, 0x01, 0x80, 0x18, 0x60, 0x00, 0xC0, 0x1C, 0x30, 0x00, 0xE0,
  0x0E, 0x1C, 0x00, 0x70, 0x06, 0x06, 0x00, 0x30, 0x03, 0x03, 0x00, 0x18,
  0x01, 0x81, 0x80, 0x0C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x07, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0xC0, 0x70, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x38, 0x18, 0x03, 0x80, 0x0C, 0x0C, 0x01, 0xC0, 0x06,
  0x0E, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x01, 0xC3, 0x00, 0x30, 0x00,
  0x61, 0x80, 0x38, 0x00, 0x31, 0xC0, 0x1C, 0x00, 0x18, 0xE0, 0x0C, 0x00,
  0x0E, 0x60, 0x06, 0x00, 0x03, 0x30, 0x03, 0x00, 0x01, 0x98, 0x03, 0x80,
  0x00, 0xFC, 0x01, 0x80, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x30, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x70, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x01,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x18, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01,
  0x80, 0x0E, 0x00, 0x60, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x01, 0xE0, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x38,
  0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x1E,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x06,
  0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x38, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x10, 0x00, 0x3C, 0x03, 0x80, 0x0F,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x61,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x80, 0x00, 0x63, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0xC0, 0x00, 0xD8, 0x00,
  0x1C, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x01, 0xD8, 0x00, 0x38, 0xC0,
  0x01, 0x98, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x70, 0xC0, 0x03, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x18, 0x00, 0xE0,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x18, 0x01, 0xC0, 0xC0, 0x0C,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x18, 0x03,
  0x80, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x18, 0x1C, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x18, 0x70,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0E,
  0xC0, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0E,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x60,
  0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01,
  0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0x70, 0x03, 0x00, 0x30, 0x07, 0x00, 0x38, 0x06, 0x00, 0x18,
  0x0E, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x06,
  0x06, 0x00, 0x3F, 0xC3, 0x00, 0x7F, 0xE3, 0x00, 0xE0, 0x73, 0x01, 0xC0,
  0x36, 0x03, 0x80, 0x16, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x03,
  0xC0, 0x60, 0x06, 0xC0, 0x70, 0x0C, 0xC0, 0x38, 0x1C, 0xC0, 0x3E, 0xF8,
  0xC0, 0x1F, 0xE1, 0x80, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x87, 0xF0, 0x03, 0x8F, 0xFC, 0x03, 0x38, 0x1C, 0x03, 0x30,
  0x0E, 0x03, 0x60, 0x06, 0x03, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x07, 0x80,
  0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x30, 0x78, 0x00, 0x70, 0x78, 0x00,
  0x60, 0x78, 0x00, 0xE0, 0x6C, 0x01, 0xC0, 0xCE, 0x03, 0x80, 0xC7, 0xFF,
  0x00, 0xC3, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xE0, 0x20, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x04,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0xC0, 0x03,
  0xFF, 0x18, 0x00, 0xE0, 0x73, 0x00, 0x38, 0x06, 0xE0, 0x0E, 0x00, 0x7C,
  0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0xE0,
  0x01, 0xE0, 0x0C, 0x00, 0x7C, 0x01, 0x80, 0x1B, 0x00, 0x38, 0x07, 0x60,
  0x03, 0x81, 0xCC, 0x00, 0x7F, 0xF1, 0x80, 0x07, 0xF8, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xE0, 0x70, 0x1C, 0x03,
  0x03, 0x80, 0x30, 0x70, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00,
  0x31, 0x80, 0x07, 0x38, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x01, 0xC7, 0x00,
  0x78, 0x70, 0x1F, 0x06, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x03, 0x01, 0xFB, 0xF0, 0x0F, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0xC0, 0x07, 0xFE, 0x30, 0x03, 0x81, 0xCC, 0x01, 0xC0,
  0x33, 0x00, 0xE0, 0x07, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1E,
  0x03, 0x80, 0x0F, 0x80, 0x60, 0x03, 0xE0, 0x18, 0x01, 0xB0, 0x07, 0x00,
  0xEC, 0x00, 0xE0, 0x73, 0x00, 0x3F, 0xF8, 0xC0, 0x07, 0xF8, 0x70, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x80,
  0x0E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xFC, 0x01, 0xCF, 0xFE, 0x03, 0xB8,
  0x1C, 0x06, 0xE0, 0x1C, 0x0D, 0x80, 0x38, 0x1E, 0x00, 0x30, 0x78, 0x00,
  0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x70, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x04, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x0E,
  0x03, 0x80, 0x38, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x07, 0x00,
  0x70, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x63, 0x80, 0x00, 0xCF,
  0x00, 0x03, 0xBE, 0x00, 0x06, 0x6E, 0x00, 0x0D, 0x8C, 0x00, 0x1E, 0x18,
  0x00, 0x38, 0x30, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0E, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x87, 0xF0, 0x1F, 0xC0, 0x18, 0xFF,
  0xC3, 0xFF, 0x00, 0xCE, 0x0E, 0x38, 0x1C, 0x06, 0xC0, 0x3B, 0x80, 0x60,
  0x3C, 0x00, 0xD8, 0x03, 0x81, 0xE0, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x38,
  0x00, 0xE0, 0x01, 0x81, 0x80, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0xE0, 0x01, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xE0, 0x01, 0x83, 0x80, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0xC0, 0x01, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xE0,
  0x01, 0x83, 0x80, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0xC0,
  0x01, 0x80, 0x06, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x01,
  0x83, 0x80, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x00, 0xE0, 0xC0, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x01, 0x83,
  0x80, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x01, 0x87, 0xF0, 0x06, 0x3F, 0xF8, 0x0C, 0xE0, 0x70, 0x1B,
  0x80, 0x70, 0x36, 0x00, 0xE0, 0x78, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0xC0,
  0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x70, 0x00,
  0x60, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00,
  0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x0E,
  0x03, 0x80, 0x18, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x1C,
  0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03,
  0x8E, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x03,
  0x80, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0xFE, 0x00, 0x0C, 0x3F, 0xF0, 0x01, 0x8E, 0x0E, 0x00, 0x33, 0x00,
  0xE0, 0x06, 0xC0, 0x0C, 0x00, 0xF0, 0x01, 0xC0, 0x3E, 0x00, 0x38, 0x07,
  0x80, 0x03, 0x00, 0xF0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x06, 0x00, 0xF0, 0x01,
  0xC0, 0x1B, 0x00, 0x70, 0x07, 0x70, 0x3C, 0x00, 0xC7, 0xFF, 0x00, 0x18,
  0x7F, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0x7F, 0xE3, 0x01, 0xE0, 0x73, 0x01,
  0xC0, 0x33, 0x03, 0x80, 0x1F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x03, 0xE0, 0x60, 0x06, 0xC0, 0x70, 0x0E, 0xC0, 0x38, 0x1C, 0xC0, 0x3F,
  0xF8, 0xC0, 0x1F, 0xE1, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0x87, 0xE0, 0x63, 0xFC, 0x0C, 0xE0, 0x01, 0xB8, 0x00,
  0x36, 0x00, 0x07, 0x80, 0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0x03, 0x80, 0x70, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x08, 0x00, 0xE0,
  0xC0, 0x1C, 0x0F, 0xDF, 0x80, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x1F, 0xFC, 0xFF, 0xE4, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70,
  0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x00, 0x0F, 0x06, 0x00, 0x36, 0x0E, 0x00, 0x78, 0x1C,
  0x01, 0xB0, 0x1C, 0x0E, 0x60, 0x3F, 0xF8, 0xC0, 0x3F, 0xE1, 0x80, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x0E,
  0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03,
  0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x70,
  0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x03,
  0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80,
  0x0E, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x0D, 0x80,
  0x18, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x0D, 0x80, 0x38, 0xC0, 0x19, 0x80,
  0x30, 0xC0, 0x19, 0x80, 0x70, 0xC0, 0x31, 0x80, 0x60, 0xC0, 0x31, 0x80,
  0x60, 0xC0, 0x71, 0x80, 0xE0, 0xC0, 0x61, 0x80, 0xC0, 0xC0, 0xE1, 0x81,
  0xC0, 0xC0, 0xC1, 0x81, 0x80, 0xC0, 0xC1, 0x81, 0x80, 0xC1, 0x81, 0x83,
  0x00, 0xC1, 0x81, 0x83, 0x00, 0xC3, 0x01, 0x87, 0x00, 0xC3, 0x01, 0x86,
  0x00, 0xC7, 0x01, 0x86, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0xC6, 0x01, 0x8C,
  0x00, 0xCC, 0x01, 0x9C, 0x00, 0xCC, 0x01, 0x98, 0x00, 0xD8, 0x01, 0x98,
  0x00, 0xD8, 0x01, 0xB0, 0x00, 0xF8, 0x01, 0xB0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x06, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x07,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xC0, 0x07, 0xE3, 0xE0, 0x1E, 0x01, 0xF0, 0xF8, 0x00, 0xFF, 0xD0,
  0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 44, 13, 1, -44 },
  { 73, 14, 16, 18, 6, -44 },
  { 101, 28, 44, 28, 1, -44 },
  { 255, 25, 51, 25, 1, -47 },
  { 415, 31, 46, 38, 4, -45 },
  { 594, 26, 46, 28, 0, -45 },
  { 744, 6, 16, 10, 6, -44 },
  { 756, 17, 54, 15, 2, -44 },
  { 871, 17, 54, 15, -4, -44 },
  { 986, 19, 20, 24, 7, -47 },
  { 1034, 23, 28, 28, 3, -36 },
  { 1115, 9, 14, 11, -3, -6 },
  { 1131, 13, 2, 17, 2, -18 },
  { 1135, 4, 5, 11, 1, -5 },
  { 1138, 26, 44, 19, -3, -44 },
  { 1281, 23, 46, 26, 2, -45 },
  { 1414, 13, 44, 26, 8, -44 },
  { 1486, 26, 45, 26, -1, -45 },
  { 1633, 26, 46, 26, -1, -45 },
  { 1783, 26, 45, 26, -1, -45 },
  { 1930, 26, 45, 26, 0, -44 },
  { 2077, 24, 46, 26, 2, -45 },
  { 2215, 23, 44, 26, 4, -44 },
  { 2342, 26, 46, 26, 0, -45 },
  { 2492, 24, 46, 26, 1, -45 },
  { 2630, 9, 33, 11, 1, -33 },
  { 2668, 14, 41, 11, -3, -33 },
  { 2740, 23, 26, 28, 3, -35 },
  { 2815, 23, 15, 28, 3, -29 },
  { 2859, 23, 26, 28, 3, -35 },
  { 2934, 19, 45, 18, 2, -45 },
  { 3041, 35, 50, 38, 2, -44 },
  { 3260, 25, 44, 25, -4, -44 },
  { 3398, 27, 44, 28, 1, -44 },
  { 3547, 27, 46, 26, 3, -45 },
  { 3703, 28, 44, 31, 1, -44 },
  { 3857, 26, 44, 25, 1, -44 },
  { 4000, 26, 44, 23, 1, -44 },
  { 4143, 30, 46, 33, 3, -45 },
  { 4316, 32, 44, 32, 1, -44 },
  { 4492, 19, 44, 13, -2, -44 },
  { 4597, 22, 55, 12, -9, -44 },
  { 4749, 30, 44, 26, 1, -44 },
  { 4914, 17, 44, 23, 1, -44 },
  { 5008, 41, 44, 41, 1, -44 },
  { 5234, 33, 44, 33, 1, -44 },
  { 5416, 29, 46, 33, 3, -45 },
  { 5583, 26, 44, 26, 1, -44 },
  { 5726, 29, 56, 33, 3, -45 },
  { 5929, 26, 44, 27, 1, -44 },
  { 6072, 27, 46, 24, -1, -45 },
  { 6228, 22, 44, 22, 5, -44 },
  { 6349, 30, 45, 32, 3, -44 },
  { 6518, 24, 44, 25, 6, -44 },
  { 6650, 40, 44, 42, 6, -44 },
  { 6870, 31, 44, 23, -4, -44 },
  { 7041, 23, 44, 22, 5, -44 },
  { 7168, 29, 44, 24, -2, -44 },
  { 7328, 23, 54, 18, -1, -44 },
  { 7484, 9, 44, 20, 6, -44 },
  { 7534, 22, 54, 18, -4, -44 },
  { 7683, 24, 23, 27, 2, -44 },
  { 7752, 19, 2, 19, -5, 6 },
  { 7757, 7, 9, 14, 9, -47 },
  { 7765, 24, 34, 27, 2, -33 },
  { 7867, 24, 48, 27, 1, -47 },
  { 8011, 20, 34, 21, 2, -33 },
  { 8096, 27, 48, 27, 2, -47 },
  { 8258, 20, 34, 24, 2, -33 },
  { 8343, 29, 62, 14, -8, -47 },
  { 8568, 26, 48, 27, 0, -33 },
  { 8724, 23, 47, 26, 1, -47 },
  { 8860, 12, 45, 11, 1, -45 },
  { 8928, 21, 60, 11, -8, -45 },
  { 9086, 23, 47, 22, 1, -47 },
  { 9222, 12, 47, 11, 1, -47 },
  { 9293, 37, 33, 40, 1, -33 },
  { 9446, 23, 33, 26, 1, -33 },
  { 9541, 22, 34, 27, 2, -33 },
  { 9635, 27, 47, 27, -2, -33 },
  { 9794, 24, 48, 27, 2, -33 },
  { 9938, 19, 33, 17, 1, -33 },
  { 10017, 20, 34, 20, 0, -33 },
  { 10102, 14, 42, 14, 2, -41 },
  { 10176, 23, 34, 26, 2, -33 },
  { 10274, 20, 33, 20, 3, -33 },
  { 10357, 32, 33, 33, 4, -33 },
  { 10489, 26, 33, 21, -3, -33 },
  { 10597, 31, 48, 21, -7, -33 },
  { 10783, 22, 33, 19, -2, -33 },
  { 10874, 21, 54, 20, 2, -44 },
  { 11016, 2, 62, 25, 12, -47 },
  { 11032, 22, 54, 20, -4, -44 },
  { 11181, 23, 6, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC62PT7B_H_
