#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x31, 0x90, 0x88, 0x4C, 0x66, 0x32,
  0x19, 0x08, 0x84, 0xC2, 0x43, 0x21, 0x00, 0x00, 0x20, 0xC0, 0x04, 0x10,
  0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x30, 0xC0,
  0x04, 0x18, 0x00, 0x82, 0x03, 0xFF, 0xFC, 0x04, 0x18, 0x00, 0x82, 0x00,
  0x30, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x30, 0x40, 0x04, 0x18, 0x00,
  0x83, 0x00, 0x30, 0x40, 0x7F, 0xFF, 0x80, 0x83, 0x00, 0x10, 0x40, 0x06,
  0x08, 0x00, 0x83, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x83, 0x00, 0x10,
  0x40, 0x06, 0x08, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x1F,
  0xC0, 0x3B, 0x78, 0x31, 0x08, 0x10, 0x80, 0x18, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x02, 0x10, 0x01, 0x88, 0x00, 0x44, 0x00, 0x32, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x58, 0x00, 0x26, 0x00, 0x21, 0x00, 0x10,
  0xC0, 0x08, 0x60, 0x04, 0x30, 0x06, 0x10, 0x02, 0x18, 0x01, 0x08, 0x38,
  0x9C, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x07, 0x80, 0x20, 0x64, 0x03, 0x06, 0x30, 0x10, 0x20, 0x81, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x83, 0x0C, 0x0C, 0x18, 0x40, 0x40, 0xC6, 0x02,
  0x04, 0x20, 0x10, 0x23, 0x01, 0x83, 0x10, 0x0C, 0x19, 0x1F, 0x60, 0x99,
  0x8B, 0x0C, 0x98, 0x48, 0x4C, 0x83, 0x6C, 0x4C, 0x19, 0xC6, 0x60, 0xC0,
  0x22, 0x04, 0x02, 0x10, 0x20, 0x31, 0x81, 0x01, 0x0C, 0x18, 0x18, 0x40,
  0xC0, 0x82, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x04, 0x10, 0x60,
  0x31, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x66, 0x00, 0x61, 0x00,
  0x60, 0xC0, 0x30, 0x60, 0x10, 0x30, 0x08, 0x10, 0x04, 0x18, 0x02, 0x0C,
  0x01, 0x0C, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x19, 0x00, 0x18, 0xC1, 0x98, 0x20, 0x88, 0x18, 0x4C, 0x0C, 0x64,
  0x02, 0x26, 0x01, 0xB3, 0x00, 0x51, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x1E,
  0x10, 0x1B, 0x0C, 0x18, 0x83, 0xF8, 0x60, 0x32, 0x26, 0x64, 0x44, 0xC8,
  0x80, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x18, 0x00, 0x03,
  0x00, 0x20, 0x02, 0x0C, 0x20, 0x64, 0x01, 0xCF, 0x07, 0x00, 0xA0, 0x32,
  0x06, 0x10, 0xC1, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x21, 0x84, 0x30, 0xC2, 0x10, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xB8, 0x0C, 0x10,
  0x30, 0x30, 0x40, 0x61, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x60,
  0x0C, 0xC0, 0x19, 0x00, 0x32, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x20, 0x02,
  0x40, 0x0C, 0x80, 0x19, 0x00, 0x26, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x20, 0x80, 0xC1, 0x83, 0x01, 0x8C, 0x03, 0xF0,
  0x00, 0x01, 0x07, 0x0F, 0x1B, 0x72, 0xC2, 0x86, 0x06, 0x06, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x00, 0x7C, 0x00, 0xF7, 0x80, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xDE,
  0x06, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0xC0, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0A, 0x00, 0x1A, 0x00, 0x32, 0x00, 0x26, 0x00, 0x66, 0x00, 0xC4,
  0x00, 0x84, 0x01, 0x84, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x08, 0x0C, 0x08,
  0x08, 0x18, 0x10, 0x18, 0x30, 0x10, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x30,
  0xFF, 0xFE, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0xFE, 0x00, 0xE3, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x18, 0x18, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF3, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x80, 0x27, 0xF0, 0x2C, 0x18, 0x70, 0x08,
  0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08,
  0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x60,
  0x30, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xE7, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40,
  0x10, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x02, 0x0C, 0x03, 0x02, 0x01, 0x01,
  0x81, 0x80, 0x41, 0x80, 0x33, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0xC0,
  0x18, 0x30, 0x18, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x84, 0x00, 0xC6, 0x00,
  0x23, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x20, 0x0C, 0x18, 0x06, 0x06,
  0x0E, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xDC, 0x03, 0x06, 0x06, 0x02,
  0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x10, 0x06, 0x18, 0x0E, 0x18, 0x1E,
  0x0E, 0x76, 0x07, 0xC4, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x83, 0x80,
  0xFE, 0x00, 0x06, 0x1C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0x0E, 0x00, 0x01, 0x81, 0xC0,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x80, 0x00, 0x07, 0xC1, 0xEE, 0x10, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0x40, 0x30, 0x00,
  0xC0, 0x40, 0x00, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x02, 0x02,
  0x30, 0x3F, 0x04, 0x40, 0xC2, 0x09, 0x83, 0x0C, 0x12, 0x0C, 0x18, 0x64,
  0x10, 0x20, 0xD8, 0x60, 0x41, 0xA0, 0x81, 0x82, 0x41, 0x02, 0x04, 0x86,
  0x04, 0x19, 0x0C, 0x18, 0x26, 0x18, 0x30, 0x4C, 0x30, 0x61, 0x98, 0x61,
  0x42, 0x30, 0xC6, 0x88, 0x60, 0xF9, 0xE0, 0xC0, 0x40, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x4C,
  0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x20, 0x0C,
  0x10, 0x04, 0x08, 0x06, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01, 0xFF, 0x81,
  0x80, 0x40, 0xC0, 0x20, 0xC0, 0x10, 0x60, 0x08, 0x60, 0x04, 0x30, 0x02,
  0x10, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x18, 0x03,
  0xE0, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x20, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00, 0xC3, 0x00,
  0xC1, 0x80, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x20, 0x30, 0x30, 0x0C, 0x18,
  0x02, 0x08, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10,
  0x80, 0x18, 0x40, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x7C, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x79, 0xC0, 0x60, 0x20, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x04,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x60, 0x70, 0x18, 0x0C,
  0x04, 0x01, 0x81, 0x00, 0x20, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2,
  0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00,
  0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x10, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x30, 0x40, 0x18, 0x30,
  0x0C, 0x0C, 0x06, 0x02, 0x1F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x07,
  0xFF, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0x7C, 0x06, 0x00, 0x81, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0xFC, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0x40, 0x02, 0x0C, 0x00, 0xC0, 0xC0,
  0x18, 0x0C, 0x06, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x10, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41, 0x80, 0x0C,
  0x18, 0x00, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x08, 0x00, 0x40, 0x80, 0x04, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x08, 0xC0, 0x3E, 0x00, 0x02, 0x00,
  0x60, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0x40, 0x60, 0x08, 0x08,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x23, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x26, 0x00, 0x05, 0xE0, 0x01, 0xEC, 0x00,
  0x38, 0x80, 0x06, 0x18, 0x00, 0x83, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x02, 0x01, 0x00, 0x40, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x40, 0x40, 0x0C, 0x08, 0x01, 0x80, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x14, 0x00, 0x0E, 0x05, 0x00, 0x06,
  0x81, 0x40, 0x01, 0xE0, 0xD0, 0x00, 0xD8, 0x34, 0x00, 0x34, 0x09, 0x80,
  0x19, 0x02, 0x60, 0x06, 0x40, 0x98, 0x03, 0x30, 0x66, 0x00, 0xCC, 0x19,
  0x80, 0x62, 0x04, 0x20, 0x18, 0x81, 0x08, 0x0C, 0x60, 0xC2, 0x02, 0x18,
  0x30, 0x81, 0x86, 0x0C, 0x20, 0x41, 0x02, 0x08, 0x30, 0x40, 0x82, 0x08,
  0x30, 0x60, 0xC6, 0x0C, 0x18, 0x31, 0x02, 0x04, 0x0C, 0xC0, 0x81, 0x03,
  0x20, 0x20, 0x40, 0xD8, 0x18, 0x30, 0x14, 0x06, 0x0C, 0x07, 0x01, 0x02,
  0x01, 0x80, 0x40, 0x80, 0x60, 0x30, 0x00, 0x02, 0x00, 0x18, 0x38, 0x00,
  0xC1, 0xC0, 0x04, 0x0A, 0x00, 0x20, 0x50, 0x03, 0x02, 0xC0, 0x18, 0x36,
  0x00, 0x81, 0x90, 0x04, 0x08, 0x80, 0x20, 0x46, 0x03, 0x02, 0x30, 0x18,
  0x30, 0x80, 0x81, 0x84, 0x04, 0x08, 0x30, 0x20, 0x41, 0x83, 0x06, 0x04,
  0x18, 0x30, 0x20, 0x81, 0x81, 0x84, 0x08, 0x0C, 0x60, 0x40, 0x23, 0x06,
  0x01, 0x18, 0x30, 0x0C, 0x81, 0x80, 0x64, 0x08, 0x01, 0x60, 0x40, 0x0B,
  0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x00,
  0x00, 0x7C, 0x00, 0x7B, 0xC0, 0x30, 0x18, 0x18, 0x02, 0x0C, 0x00, 0xC2,
  0x00, 0x31, 0x80, 0x04, 0x40, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x16, 0x00,
  0x05, 0x80, 0x01, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x30,
  0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x10, 0x03, 0x06, 0x01,
  0x80, 0xC1, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x06, 0x06,
  0x06, 0x03, 0x04, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x01,
  0x08, 0x03, 0x08, 0x03, 0x18, 0x02, 0x18, 0x06, 0x10, 0x0C, 0x10, 0x18,
  0x31, 0xF0, 0x3F, 0xC0, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7B, 0xC0, 0x30, 0x18, 0x18,
  0x02, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x04, 0x40, 0x01, 0x30, 0x00,
  0x4C, 0x00, 0x16, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0xD0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C,
  0x10, 0x03, 0x06, 0x01, 0x80, 0xC1, 0xC0, 0x1F, 0xC0, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x03, 0xC0, 0x07, 0xFC, 0x06, 0x06, 0x06, 0x03, 0x04, 0x03, 0x04,
  0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x03, 0x08, 0x03, 0x18,
  0x02, 0x18, 0x06, 0x10, 0x0C, 0x10, 0x38, 0x3F, 0xE0, 0x30, 0xC0, 0x30,
  0xC0, 0x20, 0x40, 0x20, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x40,
  0x20, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x80, 0x10, 0x80, 0x18, 0x00,
  0x7F, 0x00, 0x7D, 0xF0, 0x38, 0x08, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x83,
  0x81, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x20, 0x80, 0x04,
  0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0x82, 0x00, 0x10,
  0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x08, 0x30, 0x01, 0x04, 0x00, 0x60, 0xC0, 0x08, 0x18,
  0x03, 0x01, 0x00, 0xC0, 0x38, 0x30, 0x03, 0xFC, 0x00, 0x80, 0x03, 0x80,
  0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x60, 0x80, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x80, 0xC1, 0x80, 0xC1, 0x00, 0xC3, 0x00, 0xC2, 0x00, 0xC6,
  0x00, 0xC4, 0x00, 0xCC, 0x00, 0xC8, 0x00, 0xD8, 0x00, 0x58, 0x00, 0x50,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x03,
  0x00, 0x28, 0x01, 0xC0, 0x1A, 0x00, 0x70, 0x06, 0x80, 0x3C, 0x01, 0x20,
  0x0F, 0x00, 0xC8, 0x02, 0xC0, 0x22, 0x01, 0xB0, 0x18, 0x80, 0x4C, 0x06,
  0x20, 0x33, 0x01, 0x08, 0x08, 0xC0, 0xC2, 0x02, 0x30, 0x20, 0x81, 0x8C,
  0x18, 0x20, 0x43, 0x04, 0x08, 0x30, 0xC3, 0x02, 0x08, 0x30, 0xC0, 0x86,
  0x0C, 0x20, 0x21, 0x83, 0x18, 0x08, 0x40, 0xC4, 0x02, 0x30, 0x33, 0x00,
  0x88, 0x0C, 0xC0, 0x26, 0x03, 0x20, 0x09, 0x00, 0xD8, 0x02, 0x40, 0x34,
  0x00, 0xB0, 0x0F, 0x00, 0x28, 0x03, 0x80, 0x0E, 0x00, 0xA0, 0x03, 0x00,
  0x38, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x30, 0x10, 0x06, 0x01,
  0x80, 0x40, 0x18, 0x0C, 0x01, 0x80, 0x80, 0x08, 0x18, 0x00, 0x83, 0x00,
  0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x48, 0x00, 0x05, 0x80,
  0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xB0,
  0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0xC1,
  0x00, 0x08, 0x18, 0x01, 0x81, 0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x60,
  0x08, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x80, 0x09, 0x00,
  0x32, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x08, 0x10, 0x30, 0x20, 0x40,
  0x41, 0x80, 0x86, 0x01, 0x88, 0x03, 0x30, 0x06, 0x40, 0x05, 0x80, 0x0A,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0xFC, 0x00, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x61, 0x82, 0x08, 0x20,
  0x83, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x61, 0x82, 0x08, 0x20, 0x83, 0x0C,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0,
  0x01, 0xA0, 0x01, 0x30, 0x02, 0x10, 0x06, 0x10, 0x04, 0x18, 0x0C, 0x08,
  0x08, 0x0C, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x60, 0x02, 0x40, 0x03,
  0xC0, 0x03, 0xFF, 0xF0, 0x8C, 0x46, 0x23, 0x10, 0x00, 0x40, 0x03, 0xF3,
  0x06, 0x1B, 0x0C, 0x0A, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x04,
  0x20, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0x40, 0x70, 0x60, 0xD0,
  0x71, 0xB0, 0x3F, 0x30, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x20, 0x13, 0xF0, 0x2C,
  0x30, 0xF0, 0x31, 0xC0, 0x63, 0x00, 0x46, 0x00, 0x88, 0x01, 0x30, 0x02,
  0x60, 0x0C, 0x80, 0x19, 0x00, 0x32, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x30,
  0x06, 0x60, 0x19, 0xC0, 0x33, 0x80, 0xC5, 0x03, 0x0B, 0x0C, 0x13, 0xF0,
  0x00, 0x00, 0x40, 0x1F, 0xC1, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x04, 0x0F,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x41, 0x00, 0xFC, 0xC0,
  0x60, 0xB0, 0x30, 0x38, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x20, 0x04, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x0C,
  0x10, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x04,
  0x07, 0x01, 0x83, 0x40, 0x61, 0x90, 0x0F, 0xCC, 0x00, 0x00, 0x40, 0x1F,
  0x81, 0x86, 0x18, 0x11, 0x80, 0x88, 0x04, 0xC0, 0x24, 0x03, 0x20, 0x33,
  0x03, 0x18, 0xF0, 0xFC, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x04, 0x0F, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFC, 0x40, 0xC1, 0x60, 0xC0, 0xE0, 0xC0, 0x30, 0x60, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x10, 0x02, 0x18, 0x01, 0x0C, 0x01, 0x84, 0x00,
  0xC2, 0x00, 0x61, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x1C, 0x30,
  0x0E, 0x08, 0x0E, 0x06, 0x0D, 0x03, 0x0D, 0x80, 0xFC, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x04, 0x0E, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x20, 0x27,
  0xE0, 0xB0, 0xC7, 0x81, 0x1C, 0x04, 0x60, 0x11, 0x80, 0x44, 0x01, 0x30,
  0x0C, 0xC0, 0x32, 0x00, 0x88, 0x02, 0x20, 0x09, 0x80, 0x66, 0x01, 0x90,
  0x04, 0x40, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x22, 0x00, 0x80,
  0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x60, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04,
  0x08, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x78, 0x03, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x01,
  0x04, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x0C, 0x10, 0x08, 0x30, 0x08, 0x60,
  0x08, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x13, 0x80, 0x15, 0x80, 0x38, 0x80,
  0x38, 0x80, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0x40, 0x60, 0x40, 0x60, 0x60,
  0x40, 0x60, 0x40, 0x20, 0xC0, 0x30, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02,
  0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0x00, 0x20, 0x10, 0x13, 0xF1, 0xF8, 0x2C, 0x26, 0x18, 0xE0, 0x78, 0x11,
  0xC0, 0xE0, 0x23, 0x01, 0x80, 0x46, 0x03, 0x00, 0x88, 0x06, 0x03, 0x30,
  0x08, 0x06, 0x60, 0x10, 0x08, 0x80, 0x60, 0x11, 0x00, 0xC0, 0x26, 0x01,
  0x00, 0xCC, 0x02, 0x01, 0x98, 0x04, 0x02, 0x20, 0x18, 0x04, 0x40, 0x30,
  0x19, 0x80, 0x40, 0x33, 0x00, 0x80, 0x66, 0x03, 0x00, 0x88, 0x06, 0x01,
  0x10, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x09, 0xF8, 0x16, 0x18, 0x78, 0x10,
  0xE0, 0x21, 0x80, 0x43, 0x00, 0x84, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x40,
  0x10, 0x80, 0x23, 0x00, 0x46, 0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x18, 0x02, 0x00, 0x00, 0x40,
  0x07, 0xF0, 0x18, 0x30, 0x60, 0x61, 0x80, 0x43, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x20, 0x06, 0xC0, 0x0D, 0x80, 0x12, 0x00, 0x24, 0x00, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x04, 0xC0, 0x18, 0x80, 0x21, 0x00, 0xC3, 0x03, 0x03,
  0x0C, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x01, 0x3F, 0x00, 0xB0, 0xC0, 0xF0,
  0x30, 0x70, 0x18, 0x38, 0x04, 0x18, 0x02, 0x0C, 0x01, 0x0C, 0x00, 0x86,
  0x00, 0xC3, 0x00, 0x61, 0x00, 0x30, 0x80, 0x10, 0xC0, 0x08, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x06, 0x1C, 0x03, 0x0E, 0x03, 0x07, 0x03, 0x02, 0xC3,
  0x01, 0x3F, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x03, 0xF1, 0x06, 0x0B, 0x0C, 0x0E, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x20, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C,
  0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0x40, 0x70,
  0x60, 0xD0, 0x61, 0xB0, 0x3F, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x20, 0x9F, 0x0B, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x3F,
  0xC3, 0x06, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x88, 0x18, 0x7F, 0x80, 0x04, 0x02, 0x03,
  0x01, 0x80, 0x83, 0xFC, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x3C, 0x00, 0x08, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00,
  0x42, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x40, 0x10, 0x80, 0x23,
  0x00, 0xC6, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x18, 0xC0, 0x31, 0x80,
  0xE3, 0x03, 0x83, 0x0D, 0x03, 0xE2, 0x00, 0xC0, 0x1E, 0x00, 0xB0, 0x0D,
  0x80, 0x4C, 0x06, 0x60, 0x21, 0x03, 0x08, 0x10, 0x41, 0x82, 0x08, 0x10,
  0xC0, 0x84, 0x04, 0x60, 0x22, 0x01, 0x30, 0x09, 0x80, 0x58, 0x02, 0xC0,
  0x14, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x1E, 0x03, 0x80, 0xB0,
  0x1C, 0x0D, 0x81, 0xE0, 0x4C, 0x0B, 0x02, 0x60, 0x58, 0x33, 0x06, 0xC1,
  0x18, 0x26, 0x18, 0x43, 0x30, 0x82, 0x11, 0x84, 0x11, 0x8C, 0x60, 0x88,
  0x62, 0x04, 0x43, 0x30, 0x26, 0x19, 0x01, 0x20, 0x58, 0x0B, 0x02, 0x80,
  0x50, 0x14, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x00, 0x00, 0x06, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x60, 0x80, 0x30,
  0xC0, 0x08, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x34, 0x00, 0x13, 0x00, 0x19, 0x80, 0x18, 0x40,
  0x18, 0x30, 0x08, 0x18, 0x0C, 0x04, 0x0C, 0x02, 0x0C, 0x01, 0x80, 0x01,
  0x00, 0x30, 0x10, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x00, 0x80,
  0x18, 0x18, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x18, 0x60,
  0x01, 0x84, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x00, 0x98,
  0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x01, 0xF0, 0x0E, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x03,
  0xC0, 0x0F, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x00, 0x07, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xF0, 0x07, 0x80, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xCE, 0x06, 0x07, 0xF4, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 29, 8, 1, -29 },
  { 30, 9, 11, 12, 4, -29 },
  { 43, 19, 29, 18, 0, -29 },
  { 112, 17, 32, 16, 0, -30 },
  { 180, 21, 29, 24, 2, -29 },
  { 257, 17, 29, 18, 0, -29 },
  { 319, 4, 11, 6, 4, -29 },
  { 325, 11, 34, 10, 1, -28 },
  { 372, 11, 34, 10, -3, -28 },
  { 419, 12, 13, 16, 5, -30 },
  { 439, 15, 18, 18, 2, -23 },
  { 473, 6, 9, 7, -2, -4 },
  { 480, 9, 2, 11, 1, -12 },
  { 483, 2, 3, 7, 1, -3 },
  { 484, 17, 29, 12, -2, -29 },
  { 546, 15, 29, 16, 1, -29 },
  { 601, 8, 29, 16, 5, -29 },
  { 630, 17, 29, 16, -1, -29 },
  { 692, 16, 29, 16, 0, -29 },
  { 750, 16, 29, 16, 0, -29 },
  { 808, 17, 29, 16, 0, -29 },
  { 870, 16, 29, 16, 1, -29 },
  { 928, 16, 29, 16, 2, -29 },
  { 986, 17, 29, 16, 0, -29 },
  { 1048, 16, 29, 16, 0, -29 },
  { 1106, 7, 21, 7, 0, -21 },
  { 1125, 9, 26, 7, -2, -21 },
  { 1155, 15, 17, 18, 2, -23 },
  { 1187, 15, 10, 18, 2, -19 },
  { 1206, 15, 17, 18, 2, -23 },
  { 1238, 12, 29, 12, 1, -29 },
  { 1282, 23, 33, 25, 1, -29 },
  { 1377, 17, 29, 16, -3, -29 },
  { 1439, 17, 29, 18, 1, -29 },
  { 1501, 17, 29, 17, 2, -29 },
  { 1563, 18, 29, 20, 1, -29 },
  { 1629, 16, 29, 16, 1, -29 },
  { 1687, 17, 29, 15, 1, -29 },
  { 1749, 19, 29, 21, 2, -29 },
  { 1818, 20, 29, 21, 1, -29 },
  { 1891, 13, 29, 9, -2, -29 },
  { 1939, 14, 36, 7, -6, -29 },
  { 2002, 19, 29, 17, 1, -29 },
  { 2071, 10, 29, 15, 1, -29 },
  { 2108, 26, 29, 27, 1, -29 },
  { 2203, 21, 29, 21, 1, -29 },
  { 2280, 18, 29, 21, 2, -29 },
  { 2346, 16, 29, 17, 1, -29 },
  { 2404, 18, 36, 21, 2, -29 },
  { 2485, 16, 29, 17, 1, -29 },
  { 2543, 18, 29, 16, -1, -29 },
  { 2609, 15, 29, 14, 3, -29 },
  { 2664, 19, 29, 20, 2, -29 },
  { 2733, 16, 29, 16, 4, -29 },
  { 2791, 26, 29, 27, 4, -29 },
  { 2886, 20, 29, 15, -2, -29 },
  { 2959, 15, 29, 14, 3, -29 },
  { 3014, 18, 29, 15, -1, -29 },
  { 3080, 15, 35, 11, -1, -29 },
  { 3146, 6, 29, 13, 4, -29 },
  { 3168, 15, 35, 11, -3, -29 },
  { 3234, 16, 16, 18, 1, -29 },
  { 3266, 12, 1, 12, -3, 4 },
  { 3268, 4, 7, 9, 6, -31 },
  { 3272, 16, 22, 17, 1, -22 },
  { 3316, 15, 30, 18, 1, -30 },
  { 3373, 13, 22, 13, 1, -22 },
  { 3409, 18, 30, 18, 1, -30 },
  { 3477, 13, 22, 15, 1, -22 },
  { 3513, 19, 41, 9, -5, -31 },
  { 3611, 17, 32, 18, 0, -22 },
  { 3679, 14, 30, 17, 1, -30 },
  { 3732, 7, 29, 7, 1, -29 },
  { 3758, 13, 39, 7, -5, -29 },
  { 3822, 16, 30, 14, 0, -30 },
  { 3882, 8, 30, 7, 0, -30 },
  { 3912, 23, 22, 26, 1, -22 },
  { 3976, 15, 22, 17, 0, -22 },
  { 4018, 15, 22, 17, 1, -22 },
  { 4060, 17, 31, 18, -1, -22 },
  { 4126, 16, 31, 18, 1, -22 },
  { 4188, 12, 22, 11, 1, -22 },
  { 4221, 13, 22, 13, 0, -22 },
  { 4257, 9, 26, 9, 1, -26 },
  { 4287, 15, 21, 17, 1, -21 },
  { 4327, 13, 21, 13, 2, -21 },
  { 4362, 21, 21, 21, 2, -21 },
  { 4418, 17, 21, 14, -2, -21 },
  { 4463, 20, 31, 14, -4, -21 },
  { 4541, 14, 21, 12, -1, -21 },
  { 4578, 14, 35, 13, 1, -29 },
  { 4640, 1, 40, 16, 8, -30 },
  { 4645, 14, 35, 13, -2, -29 },
  { 4707, 15, 4, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC40PT7B_H_
