#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x06, 0x03, 0x00,
  0x30, 0xCC, 0x33, 0x08, 0x86, 0x21, 0x98, 0x66, 0x11, 0x04, 0x41, 0x10,
  0xCC, 0x20, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x08,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x83,
  0x11, 0xFF, 0xFE, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x20,
  0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0x0C,
  0x18, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00,
  0x60, 0xC0, 0x04, 0x08, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xE6, 0x30, 0x61, 0x00,
  0x18, 0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x04,
  0x20, 0x01, 0x88, 0x00, 0x32, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x21, 0x80, 0x08, 0x60,
  0x02, 0x18, 0x01, 0x86, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x30, 0x81,
  0x18, 0x3E, 0xFC, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0xC1, 0x8C,
  0x02, 0x0C, 0x10, 0x18, 0x20, 0x40, 0x41, 0x81, 0x03, 0x06, 0x04, 0x08,
  0x10, 0x30, 0x60, 0xC0, 0xC3, 0x03, 0x03, 0x08, 0x0C, 0x0C, 0x60, 0x20,
  0x21, 0x00, 0x81, 0x8C, 0x02, 0x06, 0x23, 0xE8, 0x11, 0x99, 0xA0, 0xCC,
  0xC3, 0x82, 0x22, 0x0F, 0x19, 0x98, 0x3F, 0xC4, 0x40, 0xDE, 0x33, 0x03,
  0x00, 0x8C, 0x0C, 0x06, 0x30, 0x30, 0x30, 0x80, 0x80, 0x82, 0x02, 0x06,
  0x18, 0x18, 0x10, 0x60, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x18,
  0x20, 0xC0, 0x61, 0x82, 0x00, 0xCC, 0x18, 0x03, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x01, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x30,
  0xC0, 0x04, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0xC0, 0x03, 0x98, 0x01, 0xC6, 0x04, 0x60, 0x83, 0x30, 0x30, 0xD8,
  0x0C, 0x26, 0x01, 0x99, 0x00, 0x64, 0xC0, 0x0B, 0x30, 0x03, 0x8C, 0x00,
  0xE3, 0x00, 0x38, 0xC0, 0x1E, 0x18, 0x0C, 0x87, 0x0E, 0x30, 0xFF, 0x0C,
  0x33, 0x32, 0x26, 0x64, 0x44, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x10, 0x40,
  0xE1, 0x00, 0x6C, 0x30, 0x7F, 0xC1, 0x80, 0x0D, 0x00, 0x66, 0x03, 0x08,
  0x18, 0x30, 0x40, 0x40, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x00, 0xFF,
  0xFF, 0xF0, 0xDF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x60,
  0xC0, 0x60, 0x60, 0x60, 0x10, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08,
  0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x62, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x0C, 0x10, 0x06, 0x08, 0x06, 0x06, 0x02, 0x03, 0x03, 0x00, 0xC7, 0x00,
  0x3F, 0x00, 0x03, 0x87, 0x87, 0xC6, 0x66, 0x36, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0E, 0x07, 0x00, 0x80, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x70, 0x18,
  0x08, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x20, 0x0C,
  0x0C, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1A, 0x00, 0x05, 0x80, 0x03, 0x60, 0x01, 0x90, 0x00, 0x44, 0x00,
  0x33, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x08, 0x01, 0x82, 0x00, 0xC1,
  0x80, 0x20, 0x60, 0x18, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x30, 0x20, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x83, 0xFF, 0xFE, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xC0, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0B, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x80, 0x30, 0x30, 0x38,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x3F, 0x81, 0xB8, 0xE0, 0xB0,
  0x30, 0xF0, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x00, 0x8C, 0x00, 0x44,
  0x00, 0x62, 0x00, 0x31, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x0C, 0x20, 0x06,
  0x18, 0x02, 0x0C, 0x03, 0x02, 0x03, 0x01, 0xC7, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x04, 0x10, 0x03, 0x04, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x18, 0x18, 0x04, 0x03, 0x07, 0x00, 0x63, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x03, 0xB0, 0x01, 0x86, 0x01, 0xC0, 0xC0, 0xC0, 0x30, 0x30, 0x06,
  0x18, 0x01, 0x84, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x00, 0x8C,
  0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x18, 0x07, 0x03, 0x83, 0x80, 0x7F,
  0x80, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x18, 0x30, 0x0C, 0x06, 0x06, 0x01,
  0x81, 0x00, 0x20, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x0E, 0x18, 0x07, 0x83, 0x03, 0x40, 0x7F, 0xB0, 0x0F, 0x8C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x38, 0x08, 0x18, 0x03, 0xFC,
  0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x18, 0x00, 0x01, 0xC0,
  0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0xC0, 0x81, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x10, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x08, 0x00, 0x01, 0x0C, 0x01, 0x00, 0x84, 0x07, 0xF0,
  0x46, 0x06, 0x18, 0x22, 0x06, 0x0C, 0x13, 0x06, 0x04, 0x09, 0x83, 0x02,
  0x04, 0x83, 0x03, 0x06, 0xC1, 0x81, 0x83, 0x60, 0x80, 0x81, 0xB0, 0xC0,
  0xC0, 0x90, 0x60, 0x60, 0xC8, 0x30, 0x30, 0x64, 0x10, 0x30, 0x22, 0x08,
  0x18, 0x33, 0x04, 0x1C, 0x11, 0x83, 0x0A, 0x18, 0x40, 0xD9, 0x98, 0x20,
  0x78, 0x78, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x02, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x05, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x66, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0x82, 0x00, 0x60,
  0x80, 0x10, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20,
  0x30, 0x08, 0x0F, 0xFF, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0x03, 0xFF, 0x00, 0x60, 0x70,
  0x08, 0x03, 0x01, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x20, 0x03, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0,
  0x80, 0x30, 0x30, 0x3C, 0x07, 0xFC, 0x00, 0xC0, 0xE0, 0x10, 0x06, 0x02,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x10, 0x40, 0x06, 0x08,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x60,
  0x06, 0x0C, 0x03, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xFC, 0x03, 0x80, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x06, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x30, 0x78, 0x02, 0x01, 0xC0, 0x20, 0x0E, 0x06,
  0x00, 0x60, 0x60, 0x02, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x21, 0x80, 0x06, 0x10, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x40, 0x0C, 0x0C, 0x01, 0x80, 0xC0,
  0x70, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x81, 0xFF, 0xC0, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0E, 0x01, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x0F, 0xE3, 0x00, 0x3F, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x81,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x01, 0x00, 0xE0,
  0x04, 0x01, 0xE0, 0x70, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x20, 0x00, 0xC0, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0x81, 0xFF, 0xFE,
  0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x04, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x40,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x38, 0x18, 0x03, 0x00, 0x80, 0x30, 0x04, 0x03, 0x00, 0x60, 0x38, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80,
  0x03, 0x18, 0x00, 0x11, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6E,
  0x00, 0x03, 0xD8, 0x00, 0x1C, 0xC0, 0x00, 0xC2, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0x60, 0x10, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x10, 0x0C,
  0x00, 0xC0, 0x60, 0x06, 0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x05, 0x00, 0x01, 0xE0, 0x68, 0x00,
  0x0B, 0x03, 0x40, 0x00, 0xD0, 0x1A, 0x00, 0x0D, 0x80, 0x90, 0x00, 0x6C,
  0x0C, 0x80, 0x06, 0x60, 0x66, 0x00, 0x33, 0x03, 0x30, 0x03, 0x10, 0x11,
  0x80, 0x19, 0x80, 0x8C, 0x01, 0x8C, 0x0C, 0x60, 0x0C, 0x60, 0x63, 0x00,
  0xC2, 0x03, 0x08, 0x06, 0x10, 0x10, 0x40, 0x61, 0x80, 0x82, 0x03, 0x0C,
  0x0C, 0x10, 0x30, 0x60, 0x60, 0x81, 0x82, 0x03, 0x06, 0x18, 0x10, 0x10,
  0x30, 0xC1, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x0C, 0x60, 0x60, 0x60, 0x66,
  0x02, 0x02, 0x03, 0x30, 0x30, 0x10, 0x1B, 0x01, 0x81, 0x80, 0x58, 0x0C,
  0x0C, 0x03, 0x80, 0x60, 0x60, 0x1C, 0x02, 0x02, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x10, 0x14, 0x00, 0x60,
  0x68, 0x00, 0xC0, 0xD8, 0x01, 0x81, 0xB0, 0x02, 0x02, 0x20, 0x04, 0x0C,
  0x40, 0x18, 0x18, 0xC0, 0x30, 0x31, 0x80, 0x60, 0x41, 0x00, 0x80, 0x82,
  0x01, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x10,
  0x20, 0x20, 0x30, 0xC0, 0xC0, 0x61, 0x81, 0x80, 0x43, 0x03, 0x00, 0x86,
  0x04, 0x01, 0x88, 0x18, 0x03, 0x30, 0x30, 0x02, 0x60, 0x60, 0x06, 0xC0,
  0xC0, 0x0D, 0x01, 0x00, 0x1A, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18,
  0x00, 0x70, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x01,
  0xC0, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30,
  0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01,
  0x20, 0x00, 0x16, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x38, 0x38, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0xC1, 0xC0, 0x20, 0x18, 0x08, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x08, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x60,
  0x60, 0x70, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xFC, 0x01, 0xC0, 0xE0, 0x30, 0x06, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00,
  0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06,
  0x03, 0x00, 0xC0, 0x38, 0x38, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xC1, 0xC0, 0x20, 0x18, 0x08,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x06, 0x08, 0x01, 0x06, 0x00, 0xC1,
  0x80, 0xE0, 0x61, 0xF0, 0x1F, 0xF0, 0x04, 0x18, 0x03, 0x06, 0x00, 0xC0,
  0x80, 0x30, 0x30, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x08, 0x30, 0x03, 0x08,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x07, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC1, 0x00,
  0x38, 0x38, 0x1E, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3,
  0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00,
  0xC3, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x20,
  0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x18,
  0x60, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x80, 0x80, 0x18, 0x06, 0x01, 0x80, 0x1C, 0x38, 0x00,
  0x7F, 0x80, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x08, 0x30,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x04, 0x06,
  0x01, 0x03, 0x00, 0x40, 0xC0, 0x10, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00,
  0x43, 0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x18, 0x00, 0x4C, 0x00, 0x13,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x30, 0x01, 0xB0, 0x01, 0x80, 0x0D,
  0x80, 0x1C, 0x00, 0x4C, 0x00, 0xA0, 0x06, 0x60, 0x0D, 0x00, 0x23, 0x00,
  0x68, 0x03, 0x18, 0x06, 0x40, 0x18, 0xC0, 0x32, 0x01, 0x86, 0x01, 0x10,
  0x0C, 0x30, 0x18, 0x80, 0x41, 0x80, 0x84, 0x06, 0x0C, 0x0C, 0x20, 0x30,
  0x60, 0x61, 0x03, 0x03, 0x02, 0x08, 0x18, 0x18, 0x30, 0x40, 0x80, 0xC1,
  0x02, 0x0C, 0x06, 0x18, 0x10, 0x40, 0x30, 0xC0, 0x86, 0x01, 0x8C, 0x04,
  0x30, 0x0C, 0x60, 0x23, 0x00, 0x62, 0x01, 0x18, 0x03, 0x30, 0x08, 0x80,
  0x19, 0x00, 0x4C, 0x00, 0xD8, 0x02, 0x60, 0x06, 0xC0, 0x16, 0x00, 0x34,
  0x00, 0xB0, 0x01, 0xE0, 0x05, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0x80, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x20, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30,
  0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x01, 0x81, 0x80,
  0x04, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x30,
  0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x08, 0x40, 0x18, 0x40, 0x30, 0x60, 0x30, 0x60, 0x60,
  0x60, 0x40, 0x60, 0xC0, 0x60, 0x80, 0x21, 0x80, 0x23, 0x00, 0x33, 0x00,
  0x36, 0x00, 0x34, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x20, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xC0, 0x81, 0x03, 0x06,
  0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x18, 0x30,
  0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x02,
  0x60, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x10, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x20, 0x60, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x66,
  0x00, 0x1B, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0xF0, 0xC3, 0x18, 0x43, 0x08,
  0x20, 0x00, 0xE0, 0x81, 0xFC, 0x81, 0x82, 0x41, 0x81, 0xA1, 0x80, 0x71,
  0x80, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01,
  0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x31, 0x00, 0x10, 0x80,
  0x18, 0x40, 0x0C, 0x20, 0x0E, 0x10, 0x07, 0x0C, 0x05, 0x06, 0x06, 0x81,
  0x86, 0x40, 0x7E, 0x60, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x1C, 0x03, 0x3F, 0x81, 0xB0, 0xE0, 0xB0, 0x30, 0x70, 0x08, 0x70, 0x06,
  0x38, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x11, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x06, 0x60, 0x02, 0x30, 0x03, 0x18,
  0x01, 0x8C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0xC3, 0xC0, 0xC1, 0x30, 0xC0,
  0x8F, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x60, 0x83, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x1C, 0x30, 0x0F, 0xE6, 0x03,
  0x06, 0x80, 0xC0, 0x50, 0x30, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x41, 0x80,
  0x08, 0x30, 0x03, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x03, 0x02, 0x00,
  0x60, 0x40, 0x1C, 0x08, 0x03, 0x81, 0x80, 0xF0, 0x30, 0x34, 0x03, 0x0C,
  0x80, 0x3F, 0x30, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x61, 0x83, 0x03, 0x18,
  0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x02, 0x60, 0x19, 0x00, 0xCC, 0x0E, 0x33,
  0xE0, 0xFE, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x06, 0x0F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x09, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0xCC, 0x06, 0x0D, 0x01, 0x80, 0xA0, 0x60, 0x1C, 0x18, 0x03, 0x83,
  0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20,
  0x06, 0x04, 0x00, 0xC0, 0x80, 0x38, 0x10, 0x07, 0x03, 0x01, 0xE0, 0x60,
  0x68, 0x06, 0x19, 0x00, 0x7E, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0xC0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x30, 0x0C, 0xFE, 0x0D, 0x87, 0x0A, 0x03, 0x0E,
  0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0x80, 0x10, 0x03, 0x03, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x03, 0x0C, 0x06, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x10, 0xC0, 0x11, 0x80, 0x33, 0x00,
  0x37, 0x80, 0x3D, 0x80, 0x39, 0x80, 0x30, 0x80, 0x60, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0x40, 0x40, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x80, 0x20,
  0x80, 0x30, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x00,
  0x38, 0x0E, 0x03, 0x3F, 0x0F, 0xE0, 0xD0, 0x66, 0x18, 0x28, 0x0A, 0x03,
  0x0C, 0x03, 0x80, 0xC7, 0x00, 0xC0, 0x31, 0x80, 0x30, 0x0C, 0x60, 0x18,
  0x02, 0x18, 0x06, 0x00, 0x84, 0x01, 0x80, 0x63, 0x00, 0x40, 0x18, 0xC0,
  0x10, 0x06, 0x30, 0x0C, 0x01, 0x08, 0x03, 0x00, 0xC2, 0x00, 0xC0, 0x31,
  0x80, 0x20, 0x0C, 0x60, 0x08, 0x02, 0x18, 0x06, 0x00, 0x84, 0x01, 0x80,
  0x61, 0x00, 0x60, 0x18, 0xC0, 0x10, 0x06, 0x30, 0x0C, 0x01, 0x0C, 0x03,
  0x00, 0x42, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x0C, 0xFE, 0x0D, 0x87, 0x0A,
  0x03, 0x0E, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10,
  0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0x80, 0x10, 0x00, 0xE0, 0x07, 0xF0, 0x18, 0x30, 0x60,
  0x31, 0x80, 0x66, 0x00, 0xCC, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x40, 0x06, 0x80,
  0x0D, 0x00, 0x12, 0x00, 0x64, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x1C, 0x70,
  0x1F, 0xC0, 0x00, 0x07, 0x00, 0x19, 0xFC, 0x01, 0xB0, 0xE0, 0x16, 0x06,
  0x01, 0x40, 0x20, 0x38, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x20, 0x40,
  0x06, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x01, 0x80, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0xE0, 0x60, 0x1B, 0x0C, 0x01,
  0x1F, 0x80, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0xC1, 0x83, 0x41, 0x80, 0xA1,
  0x80, 0x71, 0x80, 0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0x46, 0x00, 0x62, 0x00, 0x31, 0x00,
  0x18, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x0E, 0x10, 0x07, 0x0C, 0x07, 0x86,
  0x06, 0x81, 0x86, 0x40, 0x7E, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x38, 0x67, 0xC2, 0x60, 0x16, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0xC0,
  0x46, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x62, 0x01, 0x8C, 0x1C, 0x3F,
  0xE0, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x03, 0xFD, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x7C, 0x00, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x80, 0x30,
  0x80, 0x30, 0x80, 0x70, 0x80, 0x70, 0xC0, 0xB0, 0xC3, 0x20, 0x7E, 0x20,
  0xC0, 0x0E, 0x80, 0x19, 0x00, 0x62, 0x00, 0xC4, 0x03, 0x08, 0x06, 0x10,
  0x08, 0x20, 0x30, 0x40, 0x40, 0x81, 0x81, 0x82, 0x03, 0x0C, 0x06, 0x10,
  0x0C, 0x60, 0x18, 0x80, 0x33, 0x00, 0x64, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xA0, 0x14, 0x06, 0x80, 0xD0, 0x12, 0x02, 0x40,
  0xC8, 0x19, 0x02, 0x20, 0x44, 0x18, 0x83, 0x10, 0x62, 0x0C, 0x41, 0x08,
  0x21, 0x0C, 0x21, 0x84, 0x20, 0x84, 0x11, 0x82, 0x30, 0x46, 0x08, 0x81,
  0x10, 0x26, 0x04, 0xC0, 0x98, 0x12, 0x02, 0x40, 0x58, 0x0B, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00,
  0x02, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x0C, 0x01, 0x06, 0x00,
  0x61, 0x00, 0x18, 0xC0, 0x02, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x04, 0x01, 0x81, 0x80, 0x40, 0x60, 0x30, 0x18, 0x18,
  0x02, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x06, 0x00,
  0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x40, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x60, 0x00, 0x11, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x70, 0x70, 0xF0,
  0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 31, 9, 1, -31 },
  { 36, 10, 11, 13, 4, -31 },
  { 50, 20, 31, 20, 1, -31 },
  { 128, 18, 36, 18, 0, -33 },
  { 209, 22, 33, 27, 3, -32 },
  { 300, 18, 32, 20, 0, -32 },
  { 372, 4, 11, 7, 4, -31 },
  { 378, 13, 38, 11, 1, -31 },
  { 440, 12, 38, 11, -3, -31 },
  { 497, 14, 14, 17, 5, -33 },
  { 522, 17, 21, 20, 2, -26 },
  { 567, 6, 10, 8, -2, -4 },
  { 575, 10, 2, 12, 1, -13 },
  { 578, 3, 3, 8, 1, -3 },
  { 580, 19, 31, 13, -2, -31 },
  { 654, 17, 32, 18, 1, -32 },
  { 722, 9, 31, 18, 6, -31 },
  { 757, 19, 32, 18, -1, -32 },
  { 833, 18, 32, 18, 0, -32 },
  { 905, 18, 32, 18, 0, -32 },
  { 977, 18, 31, 18, 0, -31 },
  { 1047, 17, 32, 18, 2, -32 },
  { 1115, 16, 31, 18, 3, -31 },
  { 1177, 18, 32, 18, 0, -32 },
  { 1249, 18, 32, 18, 0, -32 },
  { 1321, 7, 23, 8, 0, -23 },
  { 1342, 10, 29, 8, -2, -23 },
  { 1379, 17, 19, 20, 2, -25 },
  { 1420, 17, 11, 20, 2, -21 },
  { 1444, 17, 19, 20, 2, -25 },
  { 1485, 14, 32, 13, 1, -32 },
  { 1541, 25, 35, 27, 1, -31 },
  { 1651, 18, 32, 18, -3, -32 },
  { 1723, 19, 31, 20, 1, -31 },
  { 1797, 19, 32, 19, 2, -32 },
  { 1873, 20, 31, 22, 1, -31 },
  { 1951, 18, 31, 18, 1, -31 },
  { 2021, 18, 31, 16, 1, -31 },
  { 2091, 22, 32, 23, 2, -32 },
  { 2179, 22, 31, 23, 1, -31 },
  { 2265, 14, 31, 9, -2, -31 },
  { 2320, 16, 39, 8, -7, -31 },
  { 2398, 21, 31, 18, 1, -31 },
  { 2480, 12, 31, 16, 1, -31 },
  { 2527, 29, 31, 29, 1, -31 },
  { 2640, 23, 31, 24, 1, -31 },
  { 2730, 20, 32, 23, 2, -32 },
  { 2810, 18, 31, 19, 1, -31 },
  { 2880, 20, 40, 23, 2, -32 },
  { 2980, 18, 31, 19, 1, -31 },
  { 3050, 19, 32, 17, -1, -32 },
  { 3126, 15, 31, 16, 4, -31 },
  { 3185, 21, 31, 22, 2, -31 },
  { 3267, 18, 31, 18, 4, -31 },
  { 3337, 29, 31, 30, 4, -31 },
  { 3450, 22, 31, 16, -3, -31 },
  { 3536, 16, 31, 16, 4, -31 },
  { 3598, 20, 31, 17, -1, -31 },
  { 3676, 16, 38, 12, -1, -31 },
  { 3752, 7, 31, 14, 4, -31 },
  { 3780, 16, 38, 12, -3, -31 },
  { 3856, 18, 16, 19, 1, -31 },
  { 3892, 14, 2, 13, -4, 4 },
  { 3896, 5, 7, 10, 6, -34 },
  { 3901, 17, 24, 19, 2, -24 },
  { 3952, 17, 33, 19, 1, -33 },
  { 4023, 14, 24, 15, 2, -24 },
  { 4065, 19, 33, 19, 2, -33 },
  { 4144, 14, 24, 17, 2, -24 },
  { 4186, 21, 45, 10, -6, -34 },
  { 4305, 19, 35, 19, 0, -24 },
  { 4389, 16, 33, 19, 1, -33 },
  { 4455, 8, 32, 8, 1, -32 },
  { 4487, 15, 43, 8, -6, -32 },
  { 4568, 16, 33, 15, 1, -33 },
  { 4634, 8, 33, 8, 1, -33 },
  { 4667, 26, 24, 28, 1, -24 },
  { 4745, 16, 24, 19, 1, -24 },
  { 4793, 15, 24, 19, 2, -24 },
  { 4838, 20, 34, 19, -2, -24 },
  { 4923, 17, 34, 19, 2, -24 },
  { 4996, 13, 24, 12, 1, -24 },
  { 5035, 14, 24, 14, 0, -24 },
  { 5077, 10, 29, 10, 1, -29 },
  { 5114, 16, 23, 19, 2, -23 },
  { 5160, 15, 23, 14, 2, -23 },
  { 5204, 22, 23, 23, 3, -23 },
  { 5268, 18, 23, 15, -2, -23 },
  { 5320, 22, 34, 15, -5, -23 },
  { 5414, 15, 23, 13, -1, -23 },
  { 5458, 16, 38, 14, 1, -31 },
  { 5534, 2, 44, 18, 8, -33 },
  { 5545, 16, 38, 14, -3, -31 },
  { 5621, 17, 4, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC44PT7B_H_
