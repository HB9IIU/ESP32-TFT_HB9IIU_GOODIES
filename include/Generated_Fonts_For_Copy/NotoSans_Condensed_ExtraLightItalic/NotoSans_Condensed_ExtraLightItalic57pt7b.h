#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x33, 0x03, 0x30, 0x73, 0x06, 0x30, 0x67, 0x06,
  0x60, 0x66, 0x0C, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x08, 0xC1, 0x8C, 0x18,
  0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x04,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3E, 0xDF,
  0x80, 0xE1, 0x06, 0x03, 0x82, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x66, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0E,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x08, 0x38, 0x10, 0x30, 0xE0, 0x3E, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x1F, 0xC0, 0x03,
  0x01, 0x87, 0x00, 0x30, 0x18, 0x18, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x60, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x30,
  0x06, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x18, 0x01, 0x80, 0x61, 0x80, 0x18,
  0x03, 0x0C, 0x00, 0xC0, 0x30, 0xC1, 0xE6, 0x01, 0x86, 0x3F, 0xB0, 0x0C,
  0x63, 0x8F, 0x80, 0xC6, 0x38, 0x3C, 0x06, 0x31, 0x81, 0xB0, 0x63, 0x18,
  0x0D, 0x87, 0x18, 0xC0, 0x6F, 0xF1, 0x86, 0x03, 0x3E, 0x0C, 0x60, 0x18,
  0x00, 0xC3, 0x00, 0xC0, 0x0C, 0x18, 0x06, 0x00, 0x61, 0x80, 0x30, 0x06,
  0x0C, 0x01, 0x80, 0x30, 0x60, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x08, 0x0C, 0x06, 0x00, 0x60, 0xE0, 0x30,
  0x03, 0x06, 0x03, 0x00, 0x1C, 0xE0, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x30, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x61, 0xC0, 0x00,
  0x63, 0x80, 0x00, 0x67, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x98, 0x00, 0x07, 0x0C, 0x00, 0x0E,
  0x0C, 0x03, 0x0C, 0x0E, 0x06, 0x18, 0x06, 0x06, 0x38, 0x06, 0x06, 0x30,
  0x03, 0x0C, 0x70, 0x03, 0x0C, 0x60, 0x03, 0x98, 0x60, 0x01, 0x98, 0xE0,
  0x01, 0xB0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0x60, 0x03, 0xE0, 0x60, 0x07, 0x30, 0x70, 0x0E, 0x30, 0x3E,
  0x7C, 0x38, 0x1F, 0xF0, 0x18, 0x01, 0x00, 0x00, 0x39, 0xCC, 0x63, 0x19,
  0x8C, 0x63, 0x11, 0x8C, 0x62, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x08, 0x0C,
  0x07, 0x06, 0x01, 0xE2, 0x00, 0x39, 0x07, 0x07, 0xFF, 0x80, 0xF8, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0xC6, 0x01, 0xC3, 0x01, 0xC0, 0xC1, 0xC0, 0x60,
  0x40, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x82,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x6F, 0xEE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1C,
  0x1C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00, 0x07, 0x30,
  0x00, 0x39, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x39, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00,
  0x07, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xE3,
  0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01,
  0x81, 0x80, 0x1C, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0xE0, 0x07,
  0xBE, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01,
  0xE0, 0x3E, 0x0E, 0x61, 0xC6, 0x38, 0xEE, 0x0C, 0x40, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xF0, 0x1E, 0x00, 0xC0,
  0x06, 0x00, 0x80, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0xF8, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x38, 0x00, 0x60,
  0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80,
  0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x04, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x80, 0x0E, 0x00, 0xF8, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x7E, 0x00, 0xC7, 0xFC, 0x03, 0x38, 0x38, 0x0D, 0x80, 0x70, 0x6C,
  0x00, 0xC1, 0xE0, 0x03, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00,
  0x63, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63,
  0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x38, 0x00, 0xC0, 0x60, 0x07, 0x01, 0xC0, 0x38,
  0x03, 0x01, 0xC0, 0x0F, 0xBE, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xE7, 0x00, 0x03,
  0x83, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x70, 0x00, 0x70, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x1F, 0xBF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0C, 0x03, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x07, 0x0E, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0xE1, 0x80, 0x03, 0x86, 0x00, 0x1E, 0x1C, 0x00, 0xD8, 0x30, 0x07, 0xC0,
  0xE0, 0x3B, 0x01, 0xFF, 0xCC, 0x01, 0xFC, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x39, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0xFF, 0x03, 0x0C, 0x01, 0xFF, 0x03, 0x18, 0x03, 0x03, 0x03, 0x18,
  0x06, 0x06, 0x03, 0x18, 0x0C, 0x06, 0x03, 0x30, 0x18, 0x06, 0x03, 0x30,
  0x18, 0x06, 0x03, 0x30, 0x30, 0x0C, 0x03, 0x60, 0x30, 0x0C, 0x02, 0x60,
  0x70, 0x0C, 0x06, 0x60, 0x60, 0x0C, 0x06, 0x60, 0x60, 0x18, 0x06, 0xC0,
  0x60, 0x18, 0x0C, 0xC0, 0x40, 0x18, 0x0C, 0xC0, 0xC0, 0x38, 0x0C, 0xC0,
  0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x70, 0x30, 0xC0,
  0xC0, 0xD0, 0x30, 0xC0, 0x60, 0xD8, 0x60, 0xC0, 0x73, 0x98, 0xC0, 0xC0,
  0x3F, 0x0F, 0x80, 0xC0, 0x08, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E,
  0x00, 0x38, 0x06, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x06, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x30, 0x1F, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0,
  0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x3C, 0x01, 0x81, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x0E, 0x03, 0x00, 0x1E, 0x03, 0x80, 0x3E, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x02, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0C, 0x0F,
  0xC0, 0x03, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x18,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x07, 0x80,
  0x60, 0x03, 0xC0, 0x18, 0x01, 0xC0, 0x0E, 0x03, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x00,
  0x02, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0xF0, 0xC0, 0x01, 0xFF, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x18, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x83, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00,
  0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x70,
  0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xDD, 0x80, 0x00, 0x1B, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0xC0,
  0x01, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xD8, 0x00, 0x00, 0xF8, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x36, 0x00, 0x00, 0x76, 0x01, 0xB0, 0x00, 0x03, 0x70,
  0x0D, 0x80, 0x00, 0x3B, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x06, 0x30, 0x00,
  0x1C, 0xC0, 0x31, 0x80, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x0E, 0x70, 0x1C,
  0x60, 0x00, 0x63, 0x00, 0xC3, 0x00, 0x07, 0x18, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x30, 0xC0, 0x03, 0x06, 0x01, 0x86, 0x00, 0x18, 0x70, 0x1C, 0x30,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x06, 0x0C, 0x00, 0xC0, 0xC0,
  0x30, 0x60, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x1C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x18, 0x0E, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x18, 0x06, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x60, 0x18, 0x06, 0x01, 0x86, 0x00, 0xC0, 0x30, 0x0C,
  0x30, 0x0E, 0x03, 0x80, 0x63, 0x00, 0x60, 0x18, 0x03, 0x98, 0x03, 0x00,
  0xC0, 0x0D, 0x80, 0x18, 0x06, 0x00, 0x6C, 0x00, 0xC0, 0x30, 0x03, 0xC0,
  0x0E, 0x03, 0x80, 0x1E, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x03, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30,
  0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x18, 0x06,
  0xC0, 0x00, 0x60, 0x1B, 0x00, 0x01, 0x80, 0x66, 0x00, 0x0E, 0x01, 0x98,
  0x00, 0x30, 0x06, 0x60, 0x00, 0xC0, 0x39, 0x80, 0x03, 0x00, 0xC3, 0x00,
  0x0C, 0x03, 0x0C, 0x00, 0x60, 0x0C, 0x30, 0x01, 0x80, 0x70, 0xC0, 0x06,
  0x01, 0x81, 0x80, 0x18, 0x06, 0x06, 0x00, 0xE0, 0x18, 0x18, 0x03, 0x00,
  0x60, 0x70, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x00, 0xC0, 0x38, 0x18, 0x03, 0x00, 0x60, 0x60, 0x1C, 0x01,
  0x81, 0x80, 0x60, 0x06, 0x06, 0x01, 0x80, 0x1C, 0x30, 0x06, 0x00, 0x30,
  0xC0, 0x18, 0x00, 0xC3, 0x00, 0xC0, 0x03, 0x0C, 0x03, 0x00, 0x0E, 0x70,
  0x0C, 0x00, 0x19, 0x80, 0x30, 0x00, 0x66, 0x01, 0xC0, 0x01, 0x98, 0x06,
  0x00, 0x07, 0x60, 0x18, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x3C, 0x01, 0x80,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0xE0,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xC1, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x01, 0xC0,
  0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x07, 0x01, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x0C, 0x07,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x07,
  0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x03, 0xC0, 0x38, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0xC1, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x01,
  0xC0, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0C, 0x01, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x38,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x03, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x1E,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0xC0,
  0x07, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x03,
  0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x6E,
  0x00, 0x07, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0x00, 0x0C, 0xE0, 0x00, 0xF0,
  0x00, 0x33, 0x80, 0x03, 0xC0, 0x01, 0x8E, 0x00, 0x1B, 0x00, 0x06, 0x38,
  0x00, 0x6C, 0x00, 0x38, 0xE0, 0x01, 0xB0, 0x00, 0xC3, 0x80, 0x0C, 0xC0,
  0x03, 0x06, 0x00, 0x33, 0x00, 0x18, 0x18, 0x01, 0x8C, 0x00, 0x60, 0x60,
  0x06, 0x30, 0x03, 0x81, 0x80, 0x18, 0xC0, 0x0C, 0x06, 0x00, 0xC3, 0x00,
  0x70, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x30, 0x06, 0x01, 0x80,
  0x60, 0xC0, 0x30, 0x06, 0x03, 0x83, 0x00, 0xC0, 0x18, 0x0C, 0x0C, 0x07,
  0x00, 0x60, 0x30, 0x30, 0x18, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x06, 0x06,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x30, 0x70,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x03, 0x06, 0x00, 0x18, 0x60,
  0x0C, 0x30, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x06, 0x70, 0x03, 0x18, 0x00, 0x19, 0x80, 0x0C, 0xE0, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x00,
  0x1E, 0x00, 0x0D, 0x80, 0x00, 0x58, 0x00, 0x36, 0x00, 0x01, 0x60, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x06,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x6E, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00,
  0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x38, 0x60, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x80, 0x01, 0xB0, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xE0,
  0x38, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x04, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x30, 0x1F, 0x3C, 0xC0, 0xE0, 0x32,
  0x07, 0x00, 0x78, 0x18, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63,
  0x80, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00,
  0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x1E,
  0x0E, 0x00, 0xD8, 0x18, 0x06, 0x40, 0x70, 0x3B, 0x00, 0xF7, 0xCC, 0x01,
  0xFC, 0x30, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x03, 0x80, 0x0C, 0x7F, 0x80, 0x33, 0x8F, 0x00, 0xD8,
  0x0E, 0x06, 0xC0, 0x18, 0x1A, 0x00, 0x70, 0x78, 0x00, 0xC1, 0xC0, 0x03,
  0x0F, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x01, 0xC3, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xC1, 0xC0,
  0x07, 0x07, 0x80, 0x18, 0x36, 0x00, 0xE0, 0xCC, 0x07, 0x03, 0x3C, 0xF8,
  0x0C, 0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x1F,
  0x0C, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x08, 0x0F,
  0x9E, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0xC0, 0x03,
  0xFC, 0x60, 0x07, 0xCF, 0x30, 0x07, 0x01, 0x98, 0x07, 0x00, 0x7C, 0x03,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30,
  0x30, 0x00, 0x38, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x38, 0x06, 0x00, 0x3C, 0x03, 0x80, 0x36, 0x00, 0xC0, 0x3B, 0x00, 0x70,
  0x39, 0x00, 0x1E, 0x79, 0x80, 0x07, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x07, 0x8F, 0x01, 0xC0, 0x60, 0x70, 0x0C,
  0x0C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xC7, 0x00, 0x18,
  0xC0, 0x07, 0x18, 0x01, 0xC7, 0x00, 0x70, 0xC0, 0x3C, 0x18, 0x3F, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x40, 0x3E, 0xF8, 0x03,
  0xFE, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF1, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xE3, 0x00, 0x7C, 0xF3, 0x00, 0xE0, 0x33, 0x01, 0xC0, 0x1B, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x30, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x30,
  0x01, 0xE0, 0x38, 0x03, 0x60, 0x18, 0x07, 0x60, 0x1C, 0x0E, 0xC0, 0x0F,
  0x3C, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x80,
  0x1C, 0x00, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x38, 0x01, 0x8F, 0xF0,
  0x0C, 0xE3, 0xC0, 0x6C, 0x07, 0x06, 0xC0, 0x18, 0x3C, 0x00, 0xC1, 0xC0,
  0x06, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x1C, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x8F,
  0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x60,
  0x1C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0E, 0x00,
  0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0xE7, 0x00, 0x06, 0x78, 0x00, 0x37, 0xE0, 0x01, 0xF3, 0x00, 0x0F,
  0x18, 0x00, 0xF0, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0,
  0x1C, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x1C, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0xC0,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0xC7, 0xF0, 0x3F, 0xC0, 0x33, 0x8E, 0x1C,
  0x78, 0x19, 0x81, 0xCC, 0x06, 0x06, 0xC0, 0x36, 0x01, 0x81, 0xE0, 0x0F,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00,
  0x30, 0x01, 0x83, 0x80, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x18, 0x30,
  0x01, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x87, 0x00, 0x18, 0x00, 0xC1,
  0x80, 0x06, 0x00, 0x30, 0x60, 0x03, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x03,
  0x06, 0x00, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x00,
  0x18, 0x30, 0x01, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x01, 0x83, 0x00, 0x18,
  0x00, 0xC1, 0x80, 0x06, 0x00, 0x30, 0x60, 0x01, 0x80, 0x0C, 0x18, 0x00,
  0xC0, 0x03, 0x06, 0x00, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x00, 0x18, 0x30, 0x01, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x07, 0x80, 0x18, 0xFF, 0x00, 0xCF, 0x3C, 0x0C, 0xC0, 0x70, 0x6C,
  0x01, 0x83, 0xC0, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x18,
  0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00,
  0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xF8, 0x01, 0xE3, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0x60,
  0x07, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01,
  0x8E, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0xEF,
  0x80, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x70, 0x00, 0x31, 0xFE,
  0x00, 0x19, 0xC7, 0x80, 0x09, 0xC0, 0xE0, 0x0D, 0xC0, 0x30, 0x06, 0xC0,
  0x1C, 0x03, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xE0, 0x01, 0x80, 0xE0,
  0x00, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x03, 0xE0, 0x0E, 0x01, 0x98, 0x0E,
  0x00, 0xCF, 0x3E, 0x00, 0x63, 0xFC, 0x00, 0x30, 0x20, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFE, 0x30, 0x1E, 0x3C, 0xC0, 0xE0, 0x33, 0x07,
  0x00, 0x6C, 0x18, 0x01, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31,
  0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80,
  0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0xF0, 0xC0, 0x03, 0x83, 0x00, 0x1E, 0x0E,
  0x00, 0xD8, 0x18, 0x07, 0x60, 0x70, 0x3B, 0x00, 0xF3, 0xCC, 0x01, 0xFC,
  0x30, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x81, 0x8F, 0xC0, 0xCF, 0x20, 0xCC, 0x00, 0x6C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF0,
  0x0F, 0x0F, 0x83, 0x80, 0x20, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x08, 0x03, 0x81, 0xE3, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x07, 0xFF, 0x7F,
  0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x20, 0x7E, 0x01, 0x00, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x70, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0xE0, 0xC0,
  0x07, 0x06, 0x00, 0x78, 0x30, 0x06, 0xC1, 0xC0, 0x64, 0x07, 0x9E, 0x60,
  0x1F, 0xE3, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x61, 0x80, 0x38,
  0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x70, 0x01, 0x98, 0x00,
  0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x70,
  0x01, 0xB0, 0x01, 0x40, 0x0C, 0xE0, 0x0D, 0x00, 0x33, 0x80, 0x34, 0x01,
  0x86, 0x01, 0x90, 0x06, 0x18, 0x06, 0x40, 0x38, 0x60, 0x31, 0x80, 0xC1,
  0x80, 0xC6, 0x03, 0x06, 0x03, 0x18, 0x18, 0x18, 0x18, 0x60, 0x60, 0x60,
  0x61, 0x83, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x0C, 0x18, 0x30, 0x18, 0x60,
  0x61, 0x80, 0x61, 0x81, 0x86, 0x01, 0x8E, 0x06, 0x30, 0x06, 0x30, 0x18,
  0xC0, 0x18, 0xC0, 0x63, 0x00, 0x66, 0x01, 0x98, 0x01, 0x98, 0x06, 0x60,
  0x06, 0xC0, 0x1B, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x78, 0x01, 0xB0, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70,
  0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x38, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0x80, 0x07, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x38, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x78,
  0x7C, 0x07, 0x00, 0x7D, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 41, 12, 1, -41 },
  { 63, 12, 15, 16, 6, -41 },
  { 86, 26, 41, 26, 1, -41 },
  { 220, 23, 46, 23, 1, -43 },
  { 353, 29, 42, 35, 3, -41 },
  { 506, 24, 42, 25, 0, -41 },
  { 632, 5, 15, 9, 6, -41 },
  { 642, 16, 50, 14, 2, -41 },
  { 742, 16, 50, 14, -4, -41 },
  { 842, 17, 18, 22, 7, -43 },
  { 881, 21, 26, 26, 3, -33 },
  { 950, 7, 13, 10, -2, -6 },
  { 962, 13, 2, 16, 1, -16 },
  { 966, 4, 4, 10, 1, -4 },
  { 968, 25, 41, 17, -3, -41 },
  { 1097, 21, 42, 23, 2, -41 },
  { 1208, 12, 41, 23, 7, -41 },
  { 1270, 24, 41, 23, -1, -41 },
  { 1393, 24, 42, 23, -1, -41 },
  { 1519, 24, 41, 23, -1, -41 },
  { 1642, 24, 42, 23, 0, -41 },
  { 1768, 22, 42, 23, 2, -41 },
  { 1884, 22, 41, 23, 3, -41 },
  { 1997, 24, 42, 23, 0, -41 },
  { 2123, 22, 42, 23, 1, -41 },
  { 2239, 9, 30, 10, 1, -30 },
  { 2273, 13, 37, 10, -3, -30 },
  { 2334, 21, 25, 26, 3, -33 },
  { 2400, 21, 14, 26, 3, -27 },
  { 2437, 21, 25, 26, 3, -33 },
  { 2503, 17, 41, 17, 2, -41 },
  { 2591, 32, 46, 35, 2, -41 },
  { 2775, 24, 41, 23, -4, -41 },
  { 2898, 25, 41, 26, 1, -41 },
  { 3027, 25, 42, 24, 3, -41 },
  { 3159, 26, 41, 28, 1, -41 },
  { 3293, 24, 41, 23, 1, -41 },
  { 3416, 24, 41, 21, 1, -41 },
  { 3539, 28, 42, 30, 3, -41 },
  { 3686, 29, 41, 30, 1, -41 },
  { 3835, 18, 41, 12, -2, -41 },
  { 3928, 21, 51, 11, -9, -41 },
  { 4062, 27, 41, 24, 1, -41 },
  { 4201, 15, 41, 21, 1, -41 },
  { 4278, 37, 41, 38, 1, -41 },
  { 4468, 30, 41, 30, 1, -41 },
  { 4622, 26, 42, 30, 3, -41 },
  { 4759, 24, 41, 24, 1, -41 },
  { 4882, 26, 51, 30, 3, -41 },
  { 5048, 24, 41, 24, 1, -41 },
  { 5171, 25, 42, 22, -1, -41 },
  { 5303, 20, 41, 20, 5, -41 },
  { 5406, 27, 42, 29, 3, -41 },
  { 5548, 23, 41, 23, 5, -41 },
  { 5666, 38, 41, 39, 5, -41 },
  { 5861, 28, 41, 21, -3, -41 },
  { 6005, 20, 41, 20, 5, -41 },
  { 6108, 27, 41, 22, -2, -41 },
  { 6247, 21, 50, 16, -1, -41 },
  { 6379, 8, 41, 18, 6, -41 },
  { 6420, 21, 50, 16, -4, -41 },
  { 6552, 22, 22, 25, 2, -41 },
  { 6613, 18, 2, 17, -5, 5 },
  { 6618, 6, 9, 13, 8, -44 },
  { 6625, 22, 32, 25, 2, -31 },
  { 6713, 22, 44, 25, 1, -43 },
  { 6834, 18, 32, 19, 2, -31 },
  { 6906, 25, 44, 25, 2, -43 },
  { 7044, 19, 32, 22, 2, -31 },
  { 7120, 27, 58, 12, -7, -44 },
  { 7316, 24, 45, 25, 0, -31 },
  { 7451, 21, 43, 24, 1, -43 },
  { 7564, 11, 41, 10, 1, -41 },
  { 7621, 20, 55, 10, -8, -41 },
  { 7759, 21, 43, 20, 1, -43 },
  { 7872, 11, 43, 10, 1, -43 },
  { 7932, 34, 31, 37, 1, -31 },
  { 8064, 21, 31, 24, 1, -31 },
  { 8146, 20, 32, 24, 2, -31 },
  { 8226, 25, 44, 25, -2, -31 },
  { 8364, 22, 44, 25, 2, -31 },
  { 8485, 17, 31, 16, 1, -31 },
  { 8551, 19, 32, 19, 0, -31 },
  { 8627, 12, 38, 13, 2, -37 },
  { 8684, 21, 31, 24, 2, -30 },
  { 8766, 18, 30, 19, 3, -30 },
  { 8834, 30, 30, 30, 3, -30 },
  { 8947, 23, 30, 20, -2, -30 },
  { 9034, 28, 44, 19, -6, -30 },
  { 9188, 20, 30, 17, -2, -30 },
  { 9263, 20, 50, 18, 2, -41 },
  { 9388, 2, 57, 23, 11, -43 },
  { 9403, 19, 50, 18, -3, -41 },
  { 9522, 21, 6, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC57PT7B_H_
