#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x1E, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x18, 0x0E, 0x18,
  0x0C, 0x38, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x70,
  0x18, 0x70, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x30, 0xE0, 0x30, 0xC0,
  0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xE1, 0x87, 0x80, 0x1C, 0x0C, 0x04,
  0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x31, 0xE0, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0xF0, 0x10, 0x06,
  0x0F, 0x00, 0xE0, 0x31, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0E, 0x00, 0x71, 0xE0, 0x00, 0x60, 0x07, 0x07, 0x00, 0x07,
  0x00, 0x70, 0x18, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x06,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x70, 0x01, 0xC0,
  0x0E, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x60, 0x03, 0x81, 0x80,
  0x03, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0x0E,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x03, 0x07, 0x07, 0xE3,
  0x80, 0x38, 0x70, 0xFF, 0x9C, 0x01, 0xC3, 0x0F, 0x0E, 0xE0, 0x0C, 0x38,
  0x70, 0x37, 0x00, 0xE1, 0x87, 0x01, 0xB8, 0x0E, 0x1C, 0x70, 0x0E, 0xC0,
  0x71, 0xC3, 0x80, 0x77, 0x07, 0x0E, 0x38, 0x03, 0xBC, 0xF0, 0xE1, 0xC0,
  0x1C, 0xFF, 0x06, 0x0C, 0x00, 0xE3, 0xF0, 0x70, 0xE0, 0x07, 0x00, 0x03,
  0x07, 0x00, 0x30, 0x00, 0x38, 0x30, 0x01, 0x80, 0x03, 0x81, 0x80, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x0C, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0xE0,
  0x0E, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x00, 0x70, 0x70, 0x07, 0x00, 0x03,
  0xFF, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0,
  0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE1, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x30, 0x70, 0x1C, 0x01, 0xC3, 0xC0, 0x38, 0x07,
  0x0E, 0x00, 0xE0, 0x18, 0x70, 0x03, 0x80, 0xE3, 0x80, 0x07, 0x03, 0x0E,
  0x00, 0x1C, 0x1C, 0x30, 0x00, 0x38, 0x61, 0xC0, 0x00, 0xE3, 0x87, 0x00,
  0x03, 0x8C, 0x18, 0x00, 0x07, 0x70, 0x60, 0x00, 0x1D, 0x83, 0x80, 0x00,
  0x3E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0x03, 0xB8, 0x1C, 0x00, 0x1C, 0xE0,
  0x38, 0x01, 0xE1, 0x80, 0xF8, 0x0F, 0x07, 0x01, 0xFF, 0xF8, 0x1C, 0x03,
  0xFF, 0x80, 0x38, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC3,
  0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x7C, 0x18, 0x00, 0x7C, 0x60,
  0x00, 0x79, 0x07, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0x60, 0x1E, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0,
  0x3D, 0xC1, 0xE3, 0x87, 0x86, 0x1E, 0x0C, 0xF0, 0x38, 0xC0, 0x71, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xC0, 0x03, 0xC0,
  0x01, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x20, 0x00, 0x7C, 0x00,
  0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x38, 0xFF, 0xF0, 0x03,
  0x1E, 0x07, 0x80, 0x33, 0x80, 0x3C, 0x07, 0x60, 0x01, 0xC0, 0x7C, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x60,
  0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70,
  0x01, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xEE,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x06, 0xC0, 0x70, 0x00, 0xDC, 0x03, 0x80, 0x39, 0xC0, 0x3E, 0x1F, 0x18,
  0x01, 0xFF, 0xE1, 0x80, 0x07, 0xF8, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x08, 0x03, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x80, 0x7E, 0x7F, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0xE0,
  0x06, 0x06, 0x00, 0x1F, 0xFC, 0x03, 0x07, 0x00, 0x1F, 0x1E, 0x01, 0x83,
  0x00, 0x1C, 0x06, 0x00, 0xC3, 0x80, 0x1C, 0x03, 0x00, 0x61, 0x80, 0x1C,
  0x03, 0x80, 0x30, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0x30, 0x06, 0x00, 0x70, 0x07, 0x38,
  0x07, 0x00, 0x38, 0x03, 0x1C, 0x03, 0x00, 0x18, 0x01, 0x8C, 0x03, 0x80,
  0x0C, 0x00, 0xC6, 0x01, 0xC0, 0x0E, 0x00, 0xE7, 0x00, 0xC0, 0x07, 0x00,
  0x73, 0x80, 0x60, 0x03, 0x00, 0x31, 0xC0, 0x70, 0x03, 0x80, 0x38, 0xC0,
  0x38, 0x01, 0xC0, 0x1C, 0x60, 0x1C, 0x00, 0xE0, 0x0C, 0x30, 0x0C, 0x00,
  0xE0, 0x0E, 0x18, 0x06, 0x00, 0x70, 0x06, 0x0C, 0x03, 0x00, 0x38, 0x07,
  0x0E, 0x01, 0x80, 0x3C, 0x03, 0x07, 0x00, 0xE0, 0x36, 0x03, 0x83, 0x80,
  0x70, 0x1B, 0x03, 0x81, 0xC0, 0x18, 0x19, 0xC1, 0x80, 0xE0, 0x0F, 0x38,
  0x77, 0xC0, 0x30, 0x03, 0xFC, 0x3F, 0x80, 0x18, 0x00, 0xF8, 0x07, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3C,
  0x00, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0xFC,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x01,
  0xE0, 0x03, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0xFF, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x70,
  0x00, 0x0F, 0xFE, 0x0E, 0x00, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x80, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x0E, 0x7C,
  0x00, 0x00, 0x03, 0x3F, 0x00, 0x00, 0x00, 0xDC, 0xE0, 0x00, 0x00, 0x76,
  0x38, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x06,
  0xC0, 0x00, 0x00, 0x1D, 0x80, 0x0D, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0x30, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x03, 0x38,
  0x00, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00, 0x00, 0x63, 0x80, 0x1C, 0x60,
  0x00, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x00, 0x0E, 0x38, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x70, 0x03, 0x86, 0x00,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x0C, 0x1C, 0x00,
  0x03, 0x83, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x60, 0x03, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x06, 0x03, 0x00, 0x07,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0,
  0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0x30, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC3, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x87, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x9C, 0x00, 0x30, 0x01, 0x80, 0x07, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0E, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1D, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0x06,
  0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0xDC, 0x00, 0x00, 0xE0, 0x03, 0x70,
  0x00, 0x03, 0x80, 0x1D, 0xC0, 0x00, 0x0E, 0x00, 0x73, 0x00, 0x00, 0x30,
  0x01, 0xCE, 0x00, 0x01, 0xC0, 0x06, 0x38, 0x00, 0x07, 0x00, 0x18, 0xE0,
  0x00, 0x1C, 0x00, 0xE1, 0x80, 0x00, 0x60, 0x03, 0x87, 0x00, 0x01, 0x80,
  0x0E, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x70, 0x00, 0x38, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0x07, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x00,
  0x60, 0x38, 0x00, 0x70, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x06, 0x0C,
  0x00, 0x70, 0x00, 0x1C, 0x70, 0x01, 0x80, 0x00, 0x71, 0xC0, 0x06, 0x00,
  0x01, 0xC7, 0x00, 0x38, 0x00, 0x03, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x60,
  0x03, 0x80, 0x00, 0x3B, 0x80, 0x0C, 0x00, 0x00, 0xEE, 0x00, 0x30, 0x00,
  0x01, 0xB8, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x1C, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x3C, 0x00, 0x70, 0x0F, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x80,
  0x7E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x80,
  0x0C, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x40, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0D, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x38, 0x00, 0x18, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x61, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xC0,
  0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x1C, 0x06, 0x00,
  0x70, 0x18, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x30, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x30,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x1D, 0xC0,
  0x00, 0x0D, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x0E,
  0x00, 0x18, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x0C, 0x01, 0xFF,
  0xE1, 0x80, 0x7C, 0x0E, 0x30, 0x1E, 0x00, 0xCE, 0x07, 0x80, 0x0D, 0x80,
  0xE0, 0x01, 0xB0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x1E, 0x0C, 0x00, 0x03, 0xC1, 0x80, 0x00, 0xF0, 0x30, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x36, 0x03, 0xC0, 0x0C,
  0xC0, 0x38, 0x03, 0x98, 0x07, 0x81, 0xE3, 0x00, 0x7F, 0xF8, 0xE0, 0x07,
  0xFC, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x0C, 0x1F, 0xF0, 0x00, 0xC3, 0xFF,
  0x80, 0x1C, 0xF0, 0x3C, 0x01, 0xDC, 0x01, 0xE0, 0x1D, 0x80, 0x0E, 0x01,
  0xB0, 0x00, 0x60, 0x1F, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x1E, 0x06, 0xC0, 0x01,
  0xC0, 0x6E, 0x00, 0x38, 0x06, 0x60, 0x07, 0x00, 0xE7, 0x81, 0xE0, 0x0C,
  0x3F, 0xFC, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3E, 0x01, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3F, 0xE0, 0xE0, 0x01, 0xFF,
  0xF1, 0x80, 0x07, 0xC0, 0xE7, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0x78, 0x00,
  0xDC, 0x00, 0xE0, 0x00, 0xF8, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x1E, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x01, 0xE0, 0x0C, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0x80, 0x30, 0x00,
  0x1E, 0x00, 0x60, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xD8, 0x01, 0xC0, 0x03,
  0x70, 0x03, 0x80, 0x0E, 0xE0, 0x03, 0x80, 0x39, 0x80, 0x07, 0x81, 0xE3,
  0x00, 0x07, 0xFF, 0x86, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0x80,
  0xE0, 0x1E, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x63,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x0C, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x70,
  0x01, 0xE0, 0xE0, 0x1F, 0x81, 0x87, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x02, 0x03, 0xC0, 0x3C, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x18, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x21, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x3F,
  0xFE, 0x30, 0x00, 0xF8, 0x1C, 0x60, 0x03, 0xC0, 0x1C, 0xC0, 0x0F, 0x00,
  0x1B, 0x80, 0x1C, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x78, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0xC0, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x3C, 0x01, 0x80, 0x00, 0x78, 0x03, 0x00, 0x01, 0xF0, 0x06, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x6E, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x70, 0x07, 0x30, 0x00, 0xF0, 0x3C,
  0x60, 0x00, 0xFF, 0xF1, 0xC0, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x3C, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x7C,
  0x00, 0x18, 0x3F, 0xE0, 0x03, 0x1F, 0xFE, 0x00, 0xE7, 0x81, 0xE0, 0x1D,
  0xC0, 0x1C, 0x03, 0xF0, 0x01, 0xC0, 0x6C, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x60, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x21, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x01,
  0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x39,
  0xF8, 0x00, 0x07, 0x77, 0x00, 0x00, 0xDC, 0xE0, 0x00, 0x1F, 0x0C, 0x00,
  0x07, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x70, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x18, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0xE7, 0x03, 0xC7, 0x81, 0xE0, 0x1D, 0x80, 0x39,
  0xC0, 0x1C, 0x03, 0x60, 0x03, 0x30, 0x01, 0xC0, 0x6C, 0x00, 0x7C, 0x00,
  0x38, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x78, 0x00, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x18, 0x3F, 0xE0,
  0x03, 0x1F, 0xFE, 0x00, 0xE7, 0x81, 0xE0, 0x1D, 0xC0, 0x1C, 0x03, 0x70,
  0x01, 0xC0, 0x6C, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x03, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x78, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x78,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x1F, 0xF0, 0x00, 0x0C, 0x3F, 0xF8, 0x00, 0x1C,
  0x70, 0x3C, 0x00, 0x1C, 0xE0, 0x1E, 0x00, 0x19, 0xC0, 0x0E, 0x00, 0x1B,
  0x80, 0x06, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0,
  0x01, 0xC0, 0x06, 0xE0, 0x03, 0x80, 0x06, 0x60, 0x07, 0x00, 0x0E, 0x78,
  0x1E, 0x00, 0x0E, 0x3F, 0xFC, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF,
  0x07, 0x00, 0x7F, 0xFC, 0x60, 0x0F, 0x01, 0xC6, 0x01, 0xE0, 0x0E, 0x60,
  0x3C, 0x00, 0x6E, 0x03, 0x80, 0x03, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x0C,
  0x00, 0x07, 0xC0, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0xF8, 0x0E, 0x00, 0x1B, 0x80, 0xE0, 0x03, 0xB8, 0x07, 0x00, 0x73, 0x00,
  0x78, 0x1E, 0x30, 0x03, 0xFF, 0xC7, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x03, 0x07, 0xF0, 0x0C, 0x7F, 0xC0, 0x73, 0xC0, 0x01, 0x9C, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xF0, 0x07, 0x01, 0xC0,
  0x01, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x3C, 0x0C,
  0x00, 0x0F, 0x03, 0x00, 0x07, 0xC0, 0xC0, 0x03, 0xF0, 0x38, 0x01, 0xD8,
  0x0E, 0x00, 0xE6, 0x03, 0xC0, 0x71, 0x80, 0x7F, 0xF8, 0xE0, 0x0F, 0xFC,
  0x38, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x80, 0x07,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03,
  0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x0D, 0xC0, 0x01, 0xF0,
  0x00, 0xEE, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x73, 0x80,
  0x06, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x18, 0xE0, 0x03, 0x38, 0x01,
  0xC7, 0x00, 0x19, 0xC0, 0x0C, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x0C,
  0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x70, 0x70, 0x06, 0x1C, 0x03, 0x83,
  0x80, 0x70, 0xE0, 0x18, 0x1C, 0x03, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x38,
  0x0C, 0x03, 0x01, 0xC1, 0xC0, 0xE0, 0x18, 0x0C, 0x0E, 0x07, 0x00, 0xC0,
  0xE0, 0x70, 0x30, 0x06, 0x06, 0x03, 0x83, 0x80, 0x30, 0x70, 0x1C, 0x18,
  0x01, 0x83, 0x00, 0xE1, 0xC0, 0x0C, 0x38, 0x07, 0x0E, 0x00, 0x61, 0xC0,
  0x38, 0x60, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x0E, 0x30, 0x00,
  0xC6, 0x00, 0x73, 0x80, 0x06, 0x70, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xFF, 0xE8, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 51, 15, 1, -51 },
  { 97, 16, 18, 21, 7, -51 },
  { 133, 33, 51, 32, 1, -51 },
  { 344, 29, 59, 30, 1, -55 },
  { 558, 37, 53, 44, 4, -52 },
  { 804, 30, 53, 32, 0, -52 },
  { 1003, 7, 18, 12, 7, -51 },
  { 1019, 20, 62, 18, 2, -51 },
  { 1174, 20, 62, 18, -5, -51 },
  { 1329, 22, 24, 28, 8, -55 },
  { 1395, 28, 33, 33, 3, -42 },
  { 1511, 10, 16, 13, -3, -7 },
  { 1531, 16, 3, 20, 2, -21 },
  { 1537, 5, 5, 13, 1, -5 },
  { 1541, 30, 51, 22, -3, -51 },
  { 1733, 27, 53, 30, 2, -52 },
  { 1912, 15, 51, 30, 9, -51 },
  { 2008, 31, 52, 30, -2, -52 },
  { 2210, 30, 53, 30, -1, -52 },
  { 2409, 30, 52, 30, -1, -52 },
  { 2604, 30, 52, 30, 0, -51 },
  { 2799, 28, 53, 30, 3, -52 },
  { 2985, 28, 51, 30, 4, -51 },
  { 3164, 30, 53, 30, 0, -52 },
  { 3363, 28, 53, 30, 1, -52 },
  { 3549, 11, 38, 13, 1, -38 },
  { 3602, 15, 47, 13, -3, -38 },
  { 3691, 28, 31, 33, 3, -41 },
  { 3800, 28, 17, 33, 3, -34 },
  { 3860, 28, 31, 33, 3, -41 },
  { 3969, 22, 52, 21, 2, -52 },
  { 4112, 41, 57, 45, 2, -51 },
  { 4405, 30, 52, 29, -5, -52 },
  { 4600, 31, 51, 32, 1, -51 },
  { 4798, 31, 53, 30, 4, -52 },
  { 5004, 33, 51, 36, 1, -51 },
  { 5215, 30, 51, 29, 1, -51 },
  { 5407, 31, 51, 27, 1, -51 },
  { 5605, 35, 53, 38, 4, -52 },
  { 5837, 37, 51, 37, 1, -51 },
  { 6073, 23, 51, 15, -3, -51 },
  { 6220, 26, 64, 13, -11, -51 },
  { 6428, 34, 51, 30, 1, -51 },
  { 6645, 20, 51, 26, 1, -51 },
  { 6773, 47, 51, 48, 1, -51 },
  { 7073, 38, 51, 38, 1, -51 },
  { 7316, 34, 53, 38, 3, -52 },
  { 7542, 30, 51, 30, 1, -51 },
  { 7734, 34, 64, 38, 3, -52 },
  { 8006, 30, 51, 31, 1, -51 },
  { 8198, 31, 53, 28, -1, -52 },
  { 8404, 26, 51, 26, 6, -51 },
  { 8570, 35, 52, 37, 3, -51 },
  { 8798, 29, 51, 30, 6, -51 },
  { 8983, 47, 51, 49, 7, -51 },
  { 9283, 36, 51, 27, -4, -51 },
  { 9513, 26, 51, 26, 6, -51 },
  { 9679, 33, 51, 27, -2, -51 },
  { 9890, 26, 62, 20, -1, -51 },
  { 10092, 11, 51, 23, 7, -51 },
  { 10163, 26, 62, 20, -5, -51 },
  { 10365, 29, 27, 32, 2, -51 },
  { 10463, 22, 2, 22, -6, 7 },
  { 10469, 7, 11, 16, 11, -55 },
  { 10479, 27, 40, 31, 3, -39 },
  { 10614, 28, 56, 32, 1, -55 },
  { 10810, 22, 40, 24, 3, -39 },
  { 10920, 31, 56, 32, 3, -55 },
  { 11137, 23, 40, 28, 3, -39 },
  { 11252, 34, 72, 16, -9, -55 },
  { 11558, 31, 56, 32, 0, -39 },
  { 11775, 27, 55, 31, 1, -55 },
  { 11961, 14, 52, 13, 1, -52 },
  { 12052, 25, 69, 13, -10, -52 },
  { 12268, 27, 55, 25, 1, -55 },
  { 12454, 14, 55, 13, 1, -55 },
  { 12551, 43, 39, 47, 1, -39 },
  { 12761, 27, 39, 31, 1, -39 },
  { 12893, 25, 40, 31, 3, -39 },
  { 13018, 32, 56, 32, -3, -39 },
  { 13242, 28, 56, 32, 3, -39 },
  { 13438, 22, 39, 20, 1, -39 },
  { 13546, 24, 40, 23, -1, -39 },
  { 13666, 16, 48, 16, 2, -47 },
  { 13762, 26, 39, 31, 3, -38 },
  { 13889, 23, 38, 23, 4, -38 },
  { 13999, 37, 38, 38, 4, -38 },
  { 14175, 30, 38, 25, -3, -38 },
  { 14318, 36, 56, 24, -8, -38 },
  { 14570, 25, 38, 22, -2, -38 },
  { 14689, 25, 62, 23, 2, -51 },
  { 14883, 2, 72, 29, 14, -55 },
  { 14901, 25, 62, 23, -4, -51 },
  { 15095, 28, 7, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC72PT7B_H_
