#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0x55, 0x6A, 0x12, 0x28, 0x53, 0xF2,
  0x45, 0x0A, 0x7E, 0x50, 0xA2, 0x40, 0x08, 0xF5, 0x14, 0x30, 0x41, 0x8A,
  0x2A, 0xE6, 0x10, 0x63, 0x26, 0x54, 0xCA, 0xB6, 0xF6, 0x95, 0x2A, 0x96,
  0x30, 0x18, 0x92, 0x4A, 0x30, 0x85, 0x65, 0x8A, 0x2F, 0x40, 0xF0, 0x08,
  0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x04, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x12, 0x24, 0x80, 0x2B, 0x4A, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x56, 0xF0,
  0x80, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00, 0x18,
  0x92, 0x51, 0x45, 0x18, 0x62, 0x8A, 0x27, 0x00, 0x2E, 0x94, 0x92, 0x92,
  0x00, 0x38, 0x10, 0x41, 0x04, 0x21, 0x08, 0x42, 0x0F, 0x80, 0x38, 0x10,
  0x41, 0x08, 0xC0, 0x82, 0x08, 0x2F, 0x00, 0x04, 0x31, 0x45, 0x29, 0x24,
  0xA2, 0x7C, 0x41, 0x00, 0x3C, 0x82, 0x10, 0x70, 0x20, 0x82, 0x08, 0x2F,
  0x00, 0x1B, 0x11, 0x0E, 0x4A, 0x31, 0x94, 0xB8, 0x7C, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x08, 0x00, 0x18, 0x94, 0x51, 0x28, 0xC4, 0xA2, 0x8A,
  0x27, 0x00, 0x18, 0x94, 0x51, 0x45, 0x13, 0xC2, 0x08, 0x4E, 0x00, 0x20,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x24, 0x48, 0x08, 0x99, 0x04, 0x18, 0x20,
  0xF8, 0x01, 0xF0, 0x82, 0x0C, 0x11, 0x32, 0x00, 0x70, 0x42, 0x11, 0x11,
  0x08, 0x00, 0x20, 0x1E, 0x21, 0x41, 0x9D, 0xA5, 0xA5, 0xA9, 0xCA, 0xBA,
  0x84, 0x80, 0xF8, 0x04, 0x30, 0xC5, 0x14, 0x93, 0xD1, 0x45, 0x18, 0x40,
  0x3C, 0x44, 0x89, 0x14, 0x4F, 0x11, 0x22, 0x45, 0x0B, 0xE0, 0x1C, 0x84,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x00, 0x3C, 0x44, 0x89, 0x14, 0x28,
  0x50, 0xA1, 0x45, 0x13, 0xC0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10, 0x20,
  0x41, 0x03, 0xC0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10, 0x20, 0x41, 0x02,
  0x00, 0x1E, 0x41, 0x04, 0x08, 0x11, 0x21, 0x42, 0x85, 0x09, 0xE0, 0x21,
  0x21, 0x21, 0x22, 0x42, 0x7E, 0x42, 0x42, 0x44, 0x84, 0x84, 0x18, 0x84,
  0x21, 0x10, 0x84, 0x22, 0x38, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x60, 0x22, 0x44, 0x91, 0x45, 0x0E, 0x14, 0x28, 0x49, 0x12, 0x20,
  0x22, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x20, 0x48, 0x13, 0x0C, 0xC5, 0x51,
  0x94, 0xA5, 0x29, 0x52, 0x54, 0xA6, 0x48, 0x90, 0x21, 0x21, 0x31, 0x31,
  0x52, 0x4A, 0x4A, 0x4A, 0x4A, 0x84, 0x84, 0x1C, 0xC9, 0x0C, 0x18, 0x30,
  0x61, 0x42, 0x85, 0x11, 0xC0, 0x38, 0x92, 0x49, 0x45, 0x37, 0x10, 0x42,
  0x08, 0x00, 0x1C, 0xC9, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x11, 0x41,
  0x01, 0x02, 0x00, 0x38, 0x92, 0x49, 0x45, 0x27, 0x14, 0x4A, 0x28, 0x80,
  0x3D, 0x04, 0x10, 0x20, 0x40, 0x82, 0x08, 0x2F, 0x00, 0xFC, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x08, 0x00, 0x42, 0x85, 0x0A, 0x28, 0x50, 0xA1,
  0x42, 0x89, 0x13, 0xC0, 0x86, 0x18, 0x62, 0x8A, 0x49, 0x28, 0xA3, 0x04,
  0x00, 0x84, 0x61, 0x18, 0xCA, 0x32, 0x94, 0xA5, 0x4A, 0x52, 0x98, 0xC6,
  0x31, 0x08, 0x40, 0x11, 0x12, 0x14, 0x14, 0x08, 0x08, 0x18, 0x28, 0x28,
  0x48, 0x84, 0x86, 0x28, 0x94, 0x61, 0x84, 0x10, 0x41, 0x08, 0x00, 0x3C,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x0F, 0x00, 0x19, 0x08, 0x44, 0x21,
  0x08, 0x44, 0x21, 0x0E, 0x00, 0xAA, 0xAA, 0x54, 0x18, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x84, 0x4E, 0x00, 0x10, 0x62, 0x89, 0x46, 0x10, 0xF0, 0x90,
  0x7C, 0x63, 0x18, 0xCA, 0x5E, 0x20, 0x82, 0x0F, 0x25, 0x14, 0x51, 0x46,
  0x2F, 0x00, 0x78, 0x88, 0x88, 0x8E, 0x04, 0x10, 0x5D, 0x8A, 0x28, 0xA2,
  0x92, 0x4F, 0x00, 0x79, 0x9E, 0x88, 0x8E, 0x0E, 0x10, 0x20, 0xE1, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x20, 0x00, 0x3D, 0x14, 0x51,
  0x86, 0x28, 0x9E, 0x08, 0x21, 0x38, 0x20, 0x82, 0x0F, 0x25, 0x14, 0x52,
  0x8A, 0x28, 0x80, 0x20, 0x14, 0x92, 0x92, 0x00, 0x08, 0x00, 0x11, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x22, 0x00, 0x20, 0x82, 0x09, 0x49, 0x46, 0x14,
  0x92, 0x49, 0x00, 0x24, 0x94, 0x92, 0x92, 0x00, 0x5B, 0xB2, 0x51, 0x29,
  0x14, 0x8C, 0x46, 0x25, 0x12, 0x5C, 0x94, 0x51, 0x4A, 0x28, 0xA2, 0x74,
  0x63, 0x18, 0xC6, 0x5C, 0x1E, 0x24, 0x89, 0x12, 0x24, 0x51, 0x3C, 0x40,
  0x82, 0x00, 0x7C, 0x63, 0x18, 0xCA, 0x5E, 0x10, 0x88, 0x40, 0x59, 0x10,
  0x84, 0x42, 0x10, 0x3A, 0x10, 0x82, 0x08, 0x5C, 0x22, 0x74, 0x44, 0x48,
  0x8E, 0x8C, 0x63, 0x19, 0x4A, 0x5E, 0x8C, 0xA5, 0x4A, 0x63, 0x10, 0x91,
  0x92, 0xB2, 0xB4, 0xD4, 0xD4, 0x88, 0x88, 0x26, 0x48, 0x60, 0x81, 0x05,
  0x12, 0x64, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x20, 0xC0, 0x78, 0x84, 0x44, 0x22, 0x1C, 0x0C, 0x41, 0x08, 0x20, 0x8C,
  0x10, 0x41, 0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x42, 0x11, 0x08, 0x22,
  0x11, 0x08, 0x4C, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 11, 7, 0, -11 },
  { 18, 6, 12, 6, 0, -11 },
  { 27, 7, 11, 9, 1, -11 },
  { 37, 6, 11, 7, 0, -11 },
  { 46, 1, 4, 2, 2, -11 },
  { 47, 5, 13, 4, 0, -11 },
  { 56, 4, 13, 4, -1, -11 },
  { 63, 4, 4, 6, 2, -11 },
  { 65, 5, 7, 7, 1, -9 },
  { 70, 2, 4, 3, -1, -2 },
  { 71, 4, 1, 4, 0, -5 },
  { 72, 1, 1, 3, 0, -1 },
  { 73, 7, 11, 5, -1, -11 },
  { 83, 6, 11, 6, 0, -11 },
  { 92, 3, 11, 6, 2, -11 },
  { 97, 6, 11, 6, 0, -11 },
  { 106, 6, 11, 6, 0, -11 },
  { 115, 6, 11, 6, 0, -11 },
  { 124, 6, 11, 6, 0, -11 },
  { 133, 5, 11, 6, 1, -11 },
  { 140, 6, 11, 6, 1, -11 },
  { 149, 6, 11, 6, 0, -11 },
  { 158, 6, 11, 6, 0, -11 },
  { 167, 3, 8, 3, 0, -8 },
  { 170, 4, 10, 3, -1, -8 },
  { 175, 5, 7, 7, 1, -9 },
  { 180, 5, 4, 7, 1, -7 },
  { 183, 5, 7, 7, 1, -9 },
  { 188, 5, 11, 4, 0, -11 },
  { 195, 8, 12, 9, 1, -11 },
  { 207, 6, 11, 6, -1, -11 },
  { 216, 7, 11, 7, 0, -11 },
  { 226, 6, 11, 6, 1, -11 },
  { 235, 7, 11, 7, 0, -11 },
  { 245, 7, 11, 6, 0, -11 },
  { 255, 7, 11, 6, 0, -11 },
  { 265, 7, 11, 8, 1, -11 },
  { 275, 8, 11, 8, 0, -11 },
  { 286, 5, 11, 3, -1, -11 },
  { 293, 5, 14, 3, -2, -11 },
  { 302, 7, 11, 6, 0, -11 },
  { 312, 4, 11, 5, 0, -11 },
  { 318, 10, 11, 10, 0, -11 },
  { 332, 8, 11, 8, 0, -11 },
  { 343, 7, 11, 8, 1, -11 },
  { 353, 6, 11, 6, 0, -11 },
  { 362, 7, 14, 8, 1, -11 },
  { 375, 6, 11, 6, 0, -11 },
  { 384, 6, 11, 6, 0, -11 },
  { 393, 6, 11, 5, 1, -11 },
  { 402, 7, 11, 8, 1, -11 },
  { 412, 6, 11, 6, 1, -11 },
  { 421, 10, 11, 10, 1, -11 },
  { 435, 8, 11, 6, -1, -11 },
  { 446, 6, 11, 5, 1, -11 },
  { 455, 6, 11, 6, 0, -11 },
  { 464, 5, 13, 4, 0, -11 },
  { 473, 2, 11, 5, 2, -11 },
  { 476, 5, 13, 4, -1, -11 },
  { 485, 6, 6, 7, 0, -11 },
  { 490, 4, 1, 5, -1, 1 },
  { 491, 2, 2, 3, 2, -11 },
  { 492, 5, 8, 7, 1, -8 },
  { 497, 6, 11, 7, 0, -11 },
  { 506, 4, 8, 5, 1, -8 },
  { 510, 6, 11, 7, 1, -11 },
  { 519, 4, 8, 6, 1, -8 },
  { 523, 7, 15, 3, -2, -11 },
  { 537, 6, 12, 7, 0, -8 },
  { 546, 6, 11, 6, 0, -11 },
  { 555, 3, 11, 3, 0, -11 },
  { 560, 5, 15, 3, -2, -11 },
  { 570, 6, 11, 5, 0, -11 },
  { 579, 3, 11, 3, 0, -11 },
  { 584, 9, 8, 10, 0, -8 },
  { 593, 6, 8, 6, 0, -8 },
  { 599, 5, 8, 6, 1, -8 },
  { 604, 7, 11, 7, -1, -8 },
  { 614, 5, 12, 7, 1, -8 },
  { 622, 5, 8, 4, 0, -8 },
  { 627, 5, 8, 5, 0, -8 },
  { 632, 4, 10, 3, 0, -10 },
  { 637, 5, 8, 6, 1, -8 },
  { 642, 5, 8, 5, 1, -8 },
  { 647, 8, 8, 8, 1, -8 },
  { 655, 7, 8, 5, -1, -8 },
  { 662, 8, 12, 5, -2, -8 },
  { 674, 5, 8, 5, 0, -8 },
  { 679, 6, 13, 5, 0, -11 },
  { 689, 1, 15, 6, 3, -11 },
  { 691, 5, 13, 5, -1, -11 },
  { 700, 5, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC15PT7B_H_
