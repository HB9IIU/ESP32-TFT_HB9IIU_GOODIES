#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x07,
  0x18, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x02, 0x18, 0x30, 0x81, 0x8C,
  0x0C, 0x60, 0x63, 0x02, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x79, 0x8F, 0x01, 0xC3, 0x02, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x60,
  0x00, 0x1C, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8E, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x07, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0xE0, 0x60, 0x43, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xC0, 0x39, 0xC0, 0x07, 0x01, 0x83, 0x00, 0x18,
  0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x00,
  0xC0, 0x60, 0x1C, 0x03, 0x03, 0x00, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x30,
  0x60, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x06, 0x0C, 0x00, 0x60, 0x18, 0x70,
  0x01, 0x80, 0x61, 0x81, 0x8C, 0x01, 0x8C, 0x3F, 0xB0, 0x0C, 0x31, 0xC7,
  0xC0, 0x31, 0x8E, 0x0F, 0x81, 0x86, 0x30, 0x36, 0x06, 0x31, 0x80, 0xD8,
  0x31, 0xC6, 0x03, 0x71, 0x86, 0x38, 0x0C, 0xFC, 0x30, 0xC0, 0x31, 0xC0,
  0xC3, 0x00, 0xC0, 0x06, 0x1C, 0x03, 0x00, 0x18, 0x60, 0x0C, 0x00, 0xC1,
  0x80, 0x30, 0x07, 0x06, 0x01, 0xC0, 0x18, 0x18, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x03,
  0x80, 0x30, 0x30, 0x0C, 0x00, 0x61, 0xC0, 0x60, 0x01, 0xCE, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0E, 0x01,
  0x87, 0x03, 0x01, 0x87, 0x01, 0x80, 0xC3, 0x00, 0xE0, 0x63, 0x00, 0x30,
  0x61, 0x80, 0x1C, 0x31, 0x80, 0x06, 0x30, 0xC0, 0x03, 0x18, 0x60, 0x01,
  0xD8, 0x70, 0x00, 0x6C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x0F, 0x81, 0x80, 0x06, 0xC0, 0xE0, 0x0E, 0x70, 0x38,
  0x0E, 0x18, 0x1F, 0x3E, 0x0C, 0x03, 0xFE, 0x07, 0x00, 0x60, 0x00, 0x00,
  0x19, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x63, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x30, 0x10, 0x0F,
  0x0C, 0x00, 0xE3, 0x00, 0x0E, 0xC3, 0xC0, 0xFF, 0xF0, 0x1E, 0x00, 0x0D,
  0x00, 0x06, 0x60, 0x03, 0x18, 0x01, 0x83, 0x01, 0xC0, 0xC0, 0x60, 0x18,
  0x10, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xCF,
  0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x38, 0x01, 0xC0,
  0xC0, 0x07, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x07,
  0x38, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70,
  0x00, 0x19, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x63,
  0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00,
  0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x80, 0x18,
  0x06, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x30, 0x38, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x7C, 0x07, 0x60,
  0xF7, 0x0E, 0x30, 0xE1, 0x9E, 0x0C, 0x40, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x9F, 0x00,
  0x1E, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x8F, 0x80, 0x1E, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x07,
  0x80, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x80, 0x03, 0x80, 0xC0,
  0x0F, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x18, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x7C, 0x00, 0xC7, 0xFE, 0x01, 0x9E, 0x1E, 0x03, 0x60, 0x0C, 0x0F,
  0x80, 0x1C, 0x1E, 0x00, 0x18, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80,
  0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x01, 0x80, 0x07, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF7, 0x00, 0x03, 0xC3, 0x80, 0x07, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x70, 0x30, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x3C, 0x03, 0x80, 0x1F, 0xBF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xF3, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03,
  0x80, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x1C,
  0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60,
  0x00, 0x70, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x03, 0x00,
  0x3E, 0x07, 0x00, 0xEC, 0x07, 0x87, 0x98, 0x07, 0xFC, 0x60, 0x03, 0xE0,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x01, 0xEF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0xF9, 0xF0, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xE0,
  0x07, 0xF8, 0x18, 0x60, 0x0F, 0xFC, 0x0C, 0x70, 0x0E, 0x06, 0x06, 0x30,
  0x0E, 0x06, 0x03, 0x18, 0x06, 0x03, 0x01, 0x98, 0x06, 0x01, 0x80, 0xCC,
  0x06, 0x00, 0xC0, 0x66, 0x03, 0x00, 0xC0, 0x37, 0x03, 0x00, 0x60, 0x1B,
  0x01, 0x80, 0x30, 0x19, 0x80, 0xC0, 0x38, 0x0C, 0xC0, 0xC0, 0x18, 0x06,
  0x60, 0x60, 0x0C, 0x03, 0x70, 0x30, 0x06, 0x03, 0x30, 0x18, 0x07, 0x01,
  0x98, 0x0C, 0x03, 0x00, 0xCC, 0x06, 0x03, 0x80, 0xC6, 0x03, 0x01, 0xC0,
  0x63, 0x01, 0x81, 0xE0, 0x61, 0x80, 0xC0, 0xF0, 0x70, 0xC0, 0x60, 0xC8,
  0x30, 0x60, 0x1D, 0xC7, 0xF0, 0x30, 0x0F, 0xC1, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x38, 0x06, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x38, 0x07, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C,
  0x07, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x00,
  0x1E, 0x01, 0x80, 0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x70,
  0x07, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x0E,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x03, 0x00, 0x07, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x1F, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0xF0, 0x02, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0x80, 0xF8, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x03,
  0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x07, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x01, 0xE0, 0x07, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE0,
  0xFE, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x01, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xFE, 0x1C, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18,
  0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x2F,
  0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0C,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x0C,
  0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x18, 0x07, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x06, 0x78, 0x00, 0x00, 0x67, 0x80, 0x00, 0x0E, 0xD8,
  0x00, 0x00, 0xF9, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x06, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x76, 0x00, 0x00,
  0x36, 0x00, 0xCC, 0x00, 0x00, 0xEC, 0x01, 0x98, 0x00, 0x01, 0x98, 0x03,
  0x30, 0x00, 0x07, 0x70, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x1C, 0xC0, 0x00,
  0x39, 0x80, 0x31, 0x80, 0x00, 0x63, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00,
  0xC6, 0x00, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x07, 0x18, 0x00,
  0x18, 0x60, 0x0C, 0x38, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x03, 0x87, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x01, 0x81, 0x80,
  0x1C, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00, 0xE0, 0xE0,
  0x0C, 0x0C, 0x01, 0x81, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x03, 0x01, 0xC1, 0x80, 0x60, 0x0E, 0x01, 0x83, 0x00, 0xC0, 0x18, 0x03,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x60, 0x0E,
  0x00, 0xC0, 0x18, 0xC0, 0x18, 0x03, 0x00, 0x33, 0x00, 0x30, 0x06, 0x00,
  0x66, 0x00, 0x60, 0x0C, 0x00, 0xD8, 0x00, 0xC0, 0x18, 0x01, 0xB0, 0x03,
  0x80, 0x70, 0x03, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x80, 0x0C, 0x01, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x60, 0x0F, 0x00, 0x00, 0xC0,
  0x1B, 0x00, 0x01, 0x80, 0x76, 0x00, 0x07, 0x00, 0xCC, 0x00, 0x0E, 0x01,
  0x9C, 0x00, 0x18, 0x03, 0x18, 0x00, 0x30, 0x06, 0x30, 0x00, 0x60, 0x1C,
  0x60, 0x01, 0xC0, 0x30, 0xE0, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x00, 0xC1,
  0x80, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x07, 0x07, 0x00, 0x70, 0x0C, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x30, 0x1C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x01, 0x83, 0x80, 0x60, 0x03, 0x06,
  0x00, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x0E, 0x18, 0x03, 0x00, 0x0C, 0x30,
  0x0E, 0x00, 0x18, 0xE0, 0x18, 0x00, 0x31, 0x80, 0x30, 0x00, 0x73, 0x00,
  0x60, 0x00, 0x66, 0x00, 0xC0, 0x00, 0xCC, 0x03, 0x80, 0x01, 0xB8, 0x06,
  0x00, 0x03, 0xE0, 0x0C, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x01, 0xC0,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0,
  0x3C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00,
  0x06, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x3C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07,
  0x00, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x80, 0x30, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xF0,
  0xFC, 0x01, 0xE0, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x07,
  0x00, 0xE0, 0x07, 0x80, 0x3F, 0xDF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x38, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x60, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x78,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C,
  0xE0, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x80,
  0x60, 0x03, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x01, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x00, 0x3C, 0x00,
  0x0E, 0xC0, 0x00, 0xF0, 0x00, 0x33, 0x00, 0x03, 0xC0, 0x01, 0xCC, 0x00,
  0x1B, 0x00, 0x06, 0x30, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00,
  0xE3, 0x00, 0x0C, 0xC0, 0x03, 0x0C, 0x00, 0x73, 0x00, 0x1C, 0x30, 0x01,
  0x8C, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x30, 0x07, 0x0C, 0x01, 0xC0, 0xC0, 0x18,
  0x30, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x38, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x0C, 0x0E, 0x03, 0x03, 0x80, 0x30, 0x30, 0x0C, 0x0C, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0x30, 0xE0, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x03,
  0x1C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x00, 0xCC, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x0D,
  0xC0, 0x03, 0x70, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x0E,
  0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x01, 0x80,
  0x38, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0xE0, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x38,
  0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1,
  0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x0E, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x66, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x86, 0x18, 0x30,
  0xC1, 0x82, 0x0C, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x0C, 0x03, 0xC7, 0x10,
  0x0E, 0x03, 0x60, 0x38, 0x06, 0xC0, 0xE0, 0x05, 0x83, 0x80, 0x0F, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80,
  0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0,
  0xC0, 0x01, 0xC1, 0x80, 0x07, 0x83, 0x80, 0x1E, 0x03, 0x00, 0x3C, 0x06,
  0x00, 0xD8, 0x0E, 0x03, 0x30, 0x0F, 0xBC, 0x60, 0x0F, 0xF1, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x78, 0x00, 0xC3, 0xFC, 0x01, 0x9E, 0x3C,
  0x03, 0x70, 0x1C, 0x06, 0xC0, 0x38, 0x1B, 0x00, 0x30, 0x3C, 0x00, 0x70,
  0x78, 0x00, 0xE0, 0xE0, 0x00, 0xC3, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x0E,
  0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x38, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x3C, 0x00, 0x60, 0x78, 0x01, 0xC1,
  0xB0, 0x07, 0x03, 0x30, 0x1C, 0x06, 0x3D, 0xF0, 0x0C, 0x3F, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x03, 0xE3, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x08, 0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x03, 0xC1, 0x80, 0x07, 0xF8, 0x60, 0x03,
  0xC7, 0x18, 0x01, 0xC0, 0x6E, 0x00, 0xE0, 0x0B, 0x00, 0x70, 0x03, 0xC0,
  0x38, 0x00, 0xF0, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0xF0, 0x0C, 0x00, 0x3C, 0x03, 0x80, 0x1B, 0x00, 0x60, 0x07, 0x80, 0x18,
  0x03, 0x60, 0x07, 0x03, 0x98, 0x00, 0xFB, 0xC6, 0x00, 0x1F, 0xE1, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x03, 0xC7, 0x00,
  0xE0, 0x70, 0x30, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x1C,
  0x00, 0x63, 0x00, 0x1C, 0xE0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x38, 0xE0,
  0x0E, 0x18, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x0C, 0x07, 0xCF, 0x80, 0x7F, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0xC0, 0x0F, 0x1C, 0x60,
  0x0E, 0x03, 0x30, 0x0E, 0x00, 0xB0, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x06, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x03, 0x80, 0x01,
  0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xC0,
  0x01, 0xE0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xF0, 0x18, 0x00, 0x78, 0x0E,
  0x00, 0x6C, 0x03, 0x00, 0x7C, 0x01, 0x80, 0x36, 0x00, 0xE0, 0x73, 0x00,
  0x3E, 0xF1, 0x80, 0x0F, 0xF0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x20, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x30, 0xFF, 0x00, 0xCF, 0x1E, 0x03, 0x70,
  0x18, 0x0F, 0x00, 0x70, 0x68, 0x00, 0xC1, 0xE0, 0x03, 0x07, 0x00, 0x0C,
  0x1C, 0x00, 0x70, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x31, 0xC0, 0x00,
  0xC6, 0x00, 0x07, 0x3C, 0x00, 0x19, 0xB0, 0x00, 0x6C, 0xC0, 0x01, 0xE3,
  0x00, 0x07, 0x8E, 0x00, 0x3C, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x07, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x60, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0xC0, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x63,
  0xFC, 0x0F, 0xF0, 0x0C, 0xE3, 0xC7, 0x8F, 0x01, 0xB0, 0x19, 0xC0, 0x60,
  0x2C, 0x03, 0xB0, 0x0E, 0x0D, 0x00, 0x3C, 0x00, 0xC1, 0xE0, 0x07, 0x00,
  0x18, 0x38, 0x00, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x00, 0x18, 0x38, 0x00, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x00, 0x60,
  0xC0, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x01, 0x83, 0x00, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x01, 0xC1, 0x80,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x00,
  0xC1, 0x80, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0C, 0x7F, 0xC0, 0x33, 0xC7, 0x80, 0xDC,
  0x06, 0x02, 0xC0, 0x1C, 0x1B, 0x00, 0x30, 0x78, 0x00, 0xC1, 0xC0, 0x03,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xC1, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00,
  0x3C, 0x78, 0x03, 0x80, 0xE0, 0x30, 0x03, 0x03, 0x80, 0x1C, 0x38, 0x00,
  0xE1, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07,
  0x60, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6C, 0x00,
  0x07, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x1C, 0x0F,
  0x00, 0xFB, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x18, 0x7F, 0x80, 0x06, 0x38, 0xF0, 0x01, 0x98, 0x0E, 0x00, 0x6C,
  0x01, 0x80, 0x36, 0x00, 0x60, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00,
  0xE0, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03,
  0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x01,
  0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x06, 0x60, 0x38, 0x01, 0x8F,
  0x7C, 0x00, 0x61, 0xFE, 0x00, 0x18, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x0C, 0x03, 0xC7, 0x18,
  0x0E, 0x03, 0x30, 0x38, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x06,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x03,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0xE0,
  0xC0, 0x01, 0xC1, 0x80, 0x07, 0x83, 0x80, 0x1B, 0x03, 0x00, 0x3E, 0x06,
  0x00, 0xD8, 0x0E, 0x03, 0x30, 0x0F, 0xBC, 0x60, 0x0F, 0xF1, 0xC0, 0x07,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xC7, 0xF0, 0x33, 0xC8, 0x0D,
  0xC0, 0x02, 0xE0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x0F, 0x07, 0x83,
  0x80, 0x20, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC1, 0x00, 0x78, 0x3E, 0x7E, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x3F, 0xFB, 0xFF, 0x81, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7B,
  0x01, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01,
  0xC3, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x87,
  0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00,
  0x1C, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03,
  0x83, 0x00, 0x1E, 0x0C, 0x00, 0xD0, 0x38, 0x06, 0xC0, 0x60, 0x3B, 0x01,
  0xF7, 0x8C, 0x03, 0xFC, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xFC, 0x00,
  0x1B, 0x80, 0x03, 0x70, 0x00, 0xCE, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E,
  0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x03, 0x80, 0x60, 0x60,
  0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00, 0xC7, 0x00,
  0x18, 0xC0, 0x03, 0x38, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x70, 0x01, 0xB0, 0x03, 0xC0,
  0x0C, 0xC0, 0x0F, 0x00, 0x33, 0x00, 0x6C, 0x01, 0xCC, 0x01, 0xB0, 0x06,
  0x30, 0x0E, 0xC0, 0x18, 0xC0, 0x33, 0x00, 0xC3, 0x00, 0xCC, 0x03, 0x0C,
  0x06, 0x30, 0x18, 0x30, 0x18, 0xC0, 0x60, 0xC0, 0xC3, 0x03, 0x83, 0x03,
  0x0C, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x30, 0x60, 0xC1, 0x80, 0xC3, 0x83,
  0x06, 0x03, 0x0C, 0x0C, 0x38, 0x0C, 0x30, 0x30, 0xC0, 0x31, 0x80, 0xC3,
  0x00, 0xC6, 0x03, 0x18, 0x03, 0x30, 0x0C, 0x60, 0x0C, 0xC0, 0x33, 0x00,
  0x37, 0x00, 0xCC, 0x00, 0xD8, 0x03, 0x30, 0x03, 0x60, 0x0D, 0x80, 0x0F,
  0x00, 0x36, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x07, 0x01, 0x80,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xE0,
  0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x71,
  0x80, 0x00, 0x33, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x03, 0x86,
  0x00, 0x07, 0x07, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x18, 0x03, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01,
  0x80, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0x9F, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0x1F,
  0xFA, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 42, 13, 1, -42 },
  { 64, 13, 15, 17, 6, -42 },
  { 89, 27, 42, 27, 1, -42 },
  { 231, 23, 48, 24, 1, -45 },
  { 369, 30, 44, 36, 3, -43 },
  { 534, 25, 44, 26, 0, -43 },
  { 672, 5, 15, 10, 6, -42 },
  { 682, 16, 51, 15, 2, -42 },
  { 784, 16, 51, 15, -4, -42 },
  { 886, 18, 19, 23, 7, -45 },
  { 929, 22, 27, 27, 3, -34 },
  { 1004, 8, 14, 10, -2, -6 },
  { 1018, 13, 2, 16, 2, -17 },
  { 1022, 4, 4, 11, 1, -4 },
  { 1024, 25, 42, 18, -3, -42 },
  { 1156, 22, 44, 24, 2, -43 },
  { 1277, 13, 42, 24, 7, -42 },
  { 1346, 25, 43, 24, -1, -43 },
  { 1481, 25, 44, 24, -1, -43 },
  { 1619, 25, 43, 24, -1, -43 },
  { 1754, 24, 43, 24, 0, -42 },
  { 1883, 23, 44, 24, 2, -43 },
  { 2010, 23, 42, 24, 3, -42 },
  { 2131, 24, 44, 24, 0, -43 },
  { 2263, 23, 44, 24, 1, -43 },
  { 2390, 9, 31, 11, 1, -31 },
  { 2425, 13, 39, 11, -3, -31 },
  { 2489, 22, 26, 27, 3, -34 },
  { 2561, 22, 14, 27, 3, -28 },
  { 2600, 22, 26, 27, 3, -34 },
  { 2672, 18, 43, 18, 2, -43 },
  { 2769, 33, 47, 36, 2, -42 },
  { 2963, 24, 42, 24, -4, -42 },
  { 3089, 25, 42, 26, 1, -42 },
  { 3221, 26, 44, 25, 3, -43 },
  { 3364, 27, 42, 29, 1, -42 },
  { 3506, 25, 42, 24, 1, -42 },
  { 3638, 25, 42, 22, 1, -42 },
  { 3770, 29, 44, 31, 3, -43 },
  { 3930, 30, 42, 31, 1, -42 },
  { 4088, 18, 42, 13, -2, -42 },
  { 4183, 21, 52, 11, -9, -42 },
  { 4320, 28, 42, 24, 1, -42 },
  { 4467, 16, 42, 21, 1, -42 },
  { 4551, 39, 42, 39, 1, -42 },
  { 4756, 31, 42, 32, 1, -42 },
  { 4919, 27, 44, 31, 3, -43 },
  { 5068, 24, 42, 25, 1, -42 },
  { 5194, 27, 53, 31, 3, -43 },
  { 5373, 24, 42, 25, 1, -42 },
  { 5499, 26, 44, 23, -1, -43 },
  { 5642, 21, 42, 21, 5, -42 },
  { 5753, 28, 43, 30, 3, -42 },
  { 5904, 24, 42, 24, 5, -42 },
  { 6030, 38, 42, 40, 6, -42 },
  { 6230, 29, 42, 22, -3, -42 },
  { 6383, 21, 42, 21, 5, -42 },
  { 6494, 27, 42, 22, -2, -42 },
  { 6636, 21, 51, 17, -1, -42 },
  { 6770, 9, 42, 19, 6, -42 },
  { 6818, 22, 51, 17, -4, -42 },
  { 6959, 23, 22, 26, 2, -42 },
  { 7023, 18, 2, 18, -5, 6 },
  { 7028, 6, 9, 13, 9, -45 },
  { 7035, 23, 33, 26, 2, -32 },
  { 7130, 23, 46, 26, 1, -45 },
  { 7263, 19, 33, 20, 2, -32 },
  { 7342, 26, 46, 26, 2, -45 },
  { 7492, 19, 33, 23, 2, -32 },
  { 7571, 28, 59, 13, -8, -45 },
  { 7778, 25, 46, 26, 0, -32 },
  { 7922, 22, 45, 25, 1, -45 },
  { 8046, 11, 42, 11, 1, -42 },
  { 8104, 20, 56, 11, -8, -42 },
  { 8244, 22, 45, 21, 1, -45 },
  { 8368, 11, 45, 10, 1, -45 },
  { 8430, 35, 32, 38, 1, -32 },
  { 8570, 22, 32, 25, 1, -32 },
  { 8658, 21, 33, 25, 2, -32 },
  { 8745, 26, 46, 26, -2, -32 },
  { 8895, 23, 46, 26, 2, -32 },
  { 9028, 18, 32, 17, 1, -32 },
  { 9100, 19, 33, 19, 0, -32 },
  { 9179, 13, 40, 14, 2, -39 },
  { 9244, 22, 32, 25, 2, -31 },
  { 9332, 19, 31, 19, 3, -31 },
  { 9406, 30, 31, 31, 4, -31 },
  { 9523, 24, 31, 20, -2, -31 },
  { 9616, 29, 45, 20, -6, -31 },
  { 9780, 21, 31, 18, -2, -31 },
  { 9862, 20, 51, 19, 2, -42 },
  { 9990, 2, 59, 24, 11, -45 },
  { 10005, 21, 51, 19, -4, -42 },
  { 10139, 22, 6, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC59PT7B_H_
