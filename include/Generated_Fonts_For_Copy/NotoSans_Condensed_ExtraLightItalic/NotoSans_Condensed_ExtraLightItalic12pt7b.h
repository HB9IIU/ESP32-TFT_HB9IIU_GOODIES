#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0xE0, 0x14, 0xA2, 0x9F, 0x51, 0x4F,
  0x98, 0xA0, 0x13, 0xD4, 0xC2, 0x18, 0xC6, 0xC2, 0x00, 0x46, 0xAB, 0x2C,
  0xFE, 0xD5, 0x55, 0x98, 0x11, 0x52, 0x62, 0x36, 0x72, 0xE8, 0xF0, 0x12,
  0x44, 0x48, 0x88, 0x88, 0x40, 0x22, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2D,
  0x62, 0x44, 0xF4, 0x44, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x11, 0x52, 0x98, 0xC6, 0x52, 0xE0, 0x75, 0xAA, 0x80, 0x70,
  0x42, 0x11, 0x11, 0x08, 0xF0, 0x32, 0x42, 0x13, 0x08, 0x42, 0xE0, 0x08,
  0xCA, 0x65, 0x4B, 0xE2, 0x20, 0x3A, 0x10, 0x83, 0x08, 0x42, 0xE0, 0x19,
  0x10, 0xC5, 0x46, 0x32, 0x70, 0xF1, 0x12, 0x24, 0x48, 0x80, 0x32, 0x52,
  0x93, 0x2A, 0x52, 0xF0, 0x32, 0x52, 0x94, 0x9C, 0x42, 0xE0, 0x40, 0x20,
  0x20, 0x00, 0x94, 0x16, 0x84, 0x30, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0x61,
  0x11, 0x24, 0x40, 0x80, 0x1C, 0x45, 0x0A, 0xFA, 0xB5, 0x6A, 0xCA, 0x80,
  0xF0, 0x08, 0x46, 0x32, 0x9D, 0x29, 0x88, 0x32, 0x52, 0x97, 0x26, 0x31,
  0xF0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x39, 0x14, 0x51, 0x45, 0x18,
  0xA2, 0xF0, 0x3A, 0x10, 0x87, 0x22, 0x10, 0xF0, 0x3A, 0x10, 0x87, 0x22,
  0x10, 0x80, 0x3A, 0x21, 0x09, 0x46, 0x32, 0xF0, 0x25, 0x14, 0x51, 0x79,
  0x18, 0xA2, 0x88, 0x65, 0x24, 0x94, 0xC0, 0x11, 0x11, 0x11, 0x22, 0x22,
  0xC0, 0x25, 0x25, 0x14, 0x61, 0x89, 0x24, 0x90, 0x29, 0x24, 0xA4, 0xE0,
  0x21, 0x21, 0x23, 0x62, 0x66, 0x66, 0xAA, 0x92, 0x92, 0x22, 0x45, 0x92,
  0xA5, 0x4A, 0xA5, 0x44, 0x88, 0x32, 0x63, 0x18, 0xC6, 0x32, 0xE0, 0x32,
  0x52, 0x95, 0xB2, 0x10, 0x80, 0x32, 0x63, 0x18, 0xC6, 0x32, 0xE1, 0x08,
  0x32, 0x52, 0x94, 0xBA, 0x52, 0x90, 0x3A, 0x10, 0x82, 0x08, 0x42, 0xE0,
  0xF4, 0x44, 0x44, 0x88, 0x80, 0x4C, 0x63, 0x18, 0xCA, 0x52, 0xE0, 0x8C,
  0x65, 0x2A, 0x53, 0x18, 0x80, 0x89, 0x91, 0x92, 0xAA, 0xAA, 0xCC, 0xC8,
  0x88, 0x88, 0x24, 0x91, 0x84, 0x10, 0x43, 0x12, 0x88, 0x99, 0xAA, 0xC4,
  0x88, 0x80, 0x78, 0x44, 0x22, 0x21, 0x10, 0xF0, 0x32, 0x44, 0x44, 0x88,
  0x88, 0xC0, 0xAA, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38,
  0x11, 0x94, 0x98, 0x80, 0xF0, 0xC0, 0x7A, 0x63, 0x29, 0x78, 0x22, 0x14,
  0xD4, 0xA6, 0x32, 0xF0, 0x74, 0x88, 0x87, 0x04, 0x13, 0x92, 0x4A, 0x28,
  0xA4, 0xF0, 0x75, 0xE8, 0x87, 0x0C, 0x21, 0x84, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x30, 0x7A, 0x63, 0x19, 0x78, 0x42, 0xE0, 0x22, 0x14, 0xD4, 0xA6,
  0x52, 0x90, 0x41, 0x5A, 0x80, 0x08, 0x00, 0x21, 0x08, 0x84, 0x21, 0x09,
  0x80, 0x22, 0x12, 0xA6, 0x32, 0x94, 0x90, 0x29, 0x24, 0xA4, 0x80, 0x7E,
  0x95, 0x4C, 0x99, 0x32, 0x40, 0x7A, 0x53, 0x29, 0x48, 0x7A, 0x63, 0x19,
  0x38, 0x7A, 0x53, 0x19, 0x7A, 0x10, 0x80, 0x7A, 0x63, 0x19, 0x78, 0x42,
  0x10, 0x74, 0x48, 0x88, 0x74, 0x42, 0x2E, 0x4D, 0x25, 0x26, 0x4A, 0x53,
  0x29, 0x78, 0xBA, 0xCC, 0x88, 0xA6, 0xAE, 0xAA, 0x92, 0x40, 0x56, 0x26,
  0xAA, 0x24, 0xA2, 0x8C, 0x20, 0x82, 0x10, 0x80, 0x72, 0x44, 0x8E, 0x19,
  0x08, 0x42, 0x61, 0x08, 0x42, 0x10, 0xFF, 0xF0, 0x21, 0x11, 0x11, 0x22,
  0x22, 0xC0, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 3, 1, -9 },
  { 7, 6, 9, 5, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 6, 9, 7, 1, -9 },
  { 28, 5, 9, 5, 0, -9 },
  { 34, 1, 4, 2, 1, -9 },
  { 35, 4, 11, 3, 0, -9 },
  { 41, 4, 11, 3, -1, -9 },
  { 47, 4, 4, 5, 1, -9 },
  { 49, 4, 6, 5, 1, -7 },
  { 52, 2, 3, 2, -1, -1 },
  { 53, 3, 1, 3, 0, -4 },
  { 54, 1, 1, 2, 0, -1 },
  { 55, 6, 9, 4, -1, -9 },
  { 62, 5, 9, 5, 0, -9 },
  { 68, 2, 9, 5, 2, -9 },
  { 71, 5, 9, 5, 0, -9 },
  { 77, 5, 9, 5, 0, -9 },
  { 83, 5, 9, 5, 0, -9 },
  { 89, 5, 9, 5, 0, -9 },
  { 95, 5, 9, 5, 0, -9 },
  { 101, 4, 9, 5, 1, -9 },
  { 106, 5, 9, 5, 0, -9 },
  { 112, 5, 9, 5, 0, -9 },
  { 118, 2, 6, 2, 0, -6 },
  { 120, 3, 8, 2, -1, -6 },
  { 123, 4, 5, 5, 1, -7 },
  { 126, 4, 3, 5, 1, -6 },
  { 128, 4, 5, 5, 1, -7 },
  { 131, 4, 9, 4, 0, -9 },
  { 136, 7, 10, 7, 0, -9 },
  { 145, 5, 9, 5, -1, -9 },
  { 151, 5, 9, 5, 0, -9 },
  { 157, 5, 9, 5, 1, -9 },
  { 163, 6, 9, 6, 0, -9 },
  { 170, 5, 9, 5, 0, -9 },
  { 176, 5, 9, 4, 0, -9 },
  { 182, 5, 9, 6, 1, -9 },
  { 188, 6, 9, 6, 0, -9 },
  { 195, 3, 9, 3, 0, -9 },
  { 199, 4, 11, 2, -2, -9 },
  { 205, 6, 9, 5, 0, -9 },
  { 212, 3, 9, 4, 0, -9 },
  { 216, 8, 9, 8, 0, -9 },
  { 225, 7, 9, 6, 0, -9 },
  { 233, 5, 9, 6, 1, -9 },
  { 239, 5, 9, 5, 0, -9 },
  { 245, 5, 11, 6, 1, -9 },
  { 252, 5, 9, 5, 0, -9 },
  { 258, 5, 9, 5, 0, -9 },
  { 264, 4, 9, 4, 1, -9 },
  { 269, 5, 9, 6, 1, -9 },
  { 275, 5, 9, 5, 1, -9 },
  { 281, 8, 9, 8, 1, -9 },
  { 290, 6, 9, 4, -1, -9 },
  { 297, 4, 9, 4, 1, -9 },
  { 302, 5, 9, 5, 0, -9 },
  { 308, 4, 11, 3, 0, -9 },
  { 314, 2, 9, 4, 1, -9 },
  { 317, 5, 11, 3, -1, -9 },
  { 324, 5, 5, 5, 0, -9 },
  { 328, 4, 1, 4, -1, 1 },
  { 329, 1, 2, 3, 2, -9 },
  { 330, 5, 6, 5, 0, -6 },
  { 334, 5, 9, 5, 0, -9 },
  { 340, 4, 6, 4, 0, -6 },
  { 343, 6, 9, 5, 0, -9 },
  { 350, 4, 6, 5, 0, -6 },
  { 353, 6, 12, 3, -2, -9 },
  { 362, 5, 9, 5, 0, -6 },
  { 368, 5, 9, 5, 0, -9 },
  { 374, 2, 9, 2, 0, -9 },
  { 377, 5, 12, 2, -2, -9 },
  { 385, 5, 9, 4, 0, -9 },
  { 391, 3, 9, 2, 0, -9 },
  { 395, 7, 6, 8, 0, -6 },
  { 401, 5, 6, 5, 0, -6 },
  { 405, 5, 6, 5, 0, -6 },
  { 409, 5, 9, 5, 0, -6 },
  { 415, 5, 9, 5, 0, -6 },
  { 421, 4, 6, 3, 0, -6 },
  { 424, 4, 6, 4, 0, -6 },
  { 427, 3, 8, 3, 0, -8 },
  { 430, 5, 6, 5, 0, -6 },
  { 434, 4, 6, 4, 1, -6 },
  { 437, 6, 6, 6, 1, -6 },
  { 442, 4, 6, 4, 0, -6 },
  { 445, 6, 9, 4, -1, -6 },
  { 452, 4, 6, 4, 0, -6 },
  { 455, 5, 11, 4, 0, -9 },
  { 462, 1, 12, 5, 2, -9 },
  { 464, 4, 11, 4, -1, -9 },
  { 470, 4, 1, 5, 1, -5 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC12PT7B_H_
