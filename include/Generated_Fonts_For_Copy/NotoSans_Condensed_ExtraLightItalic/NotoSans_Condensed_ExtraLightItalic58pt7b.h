#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x67, 0x06,
  0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x8C, 0x18,
  0x81, 0x80, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0xF1, 0x87, 0x03, 0x83, 0x02, 0x06, 0x04, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x1C,
  0x40, 0x00, 0x1D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8E,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x1C, 0x00, 0x10, 0x70, 0x20, 0x21, 0xC0, 0x7E, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x10,
  0x0F, 0xE0, 0x01, 0x80, 0x71, 0xC0, 0x06, 0x03, 0x83, 0x00, 0x30, 0x0C,
  0x0C, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0,
  0xC0, 0x18, 0x03, 0x03, 0x00, 0x60, 0x0C, 0x18, 0x01, 0x80, 0x70, 0xE0,
  0x06, 0x01, 0x83, 0x00, 0x18, 0x06, 0x18, 0x00, 0xE0, 0x18, 0x60, 0x03,
  0x00, 0xE3, 0x0F, 0xCC, 0x03, 0x0C, 0x7F, 0xB0, 0x0C, 0x63, 0x86, 0xC0,
  0x63, 0x8C, 0x1F, 0x81, 0x8C, 0x60, 0x36, 0x0C, 0x61, 0x80, 0xD8, 0x61,
  0x8C, 0x03, 0x3F, 0x8C, 0x30, 0x0C, 0x78, 0x31, 0xC0, 0x30, 0x01, 0x86,
  0x01, 0xC0, 0x0E, 0x18, 0x06, 0x00, 0x30, 0x60, 0x18, 0x01, 0x83, 0x80,
  0x60, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x30,
  0x06, 0x03, 0x00, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x07,
  0x00, 0xC0, 0x60, 0x18, 0x03, 0x03, 0x80, 0xC0, 0x0C, 0x0C, 0x03, 0x00,
  0x30, 0x60, 0x18, 0x00, 0x63, 0x80, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0x63, 0x80, 0x00, 0x77, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x9C, 0x00, 0x07,
  0x0C, 0x00, 0x0E, 0x0E, 0x03, 0x1C, 0x06, 0x03, 0x18, 0x06, 0x06, 0x38,
  0x07, 0x06, 0x30, 0x03, 0x0E, 0x60, 0x03, 0x8C, 0x60, 0x01, 0x9C, 0x60,
  0x01, 0x98, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x03, 0xB0, 0x70, 0x07, 0x30, 0x78,
  0x0E, 0x38, 0x3E, 0x7C, 0x18, 0x1F, 0xF0, 0x1C, 0x01, 0x00, 0x00, 0x39,
  0xCC, 0x63, 0x19, 0x8C, 0x63, 0x11, 0x8C, 0x62, 0x00, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x08, 0x0C, 0x07, 0x06, 0x01, 0xC3, 0x00, 0x39, 0x81, 0x06, 0x8F,
  0x80, 0xFF, 0x80, 0x70, 0x00, 0xE8, 0x00, 0xE6, 0x00, 0xC3, 0x00, 0xC0,
  0xC1, 0xC0, 0x60, 0x40, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x1C, 0x30, 0xE1, 0x82, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xEE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x1C, 0x1C, 0x01,
  0xC0, 0x60, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x0E, 0xE0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x77, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x07,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80,
  0x0E, 0x0E, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x07, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x03,
  0xB0, 0x76, 0x0E, 0x63, 0xC6, 0x70, 0x6E, 0x0E, 0x40, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x40,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1E,
  0x07, 0x80, 0x1C, 0x00, 0xC0, 0x08, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x0F, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x0F, 0x00, 0xF8, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x78, 0x10, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x61, 0xFE, 0x00, 0xCF,
  0xFE, 0x01, 0xB8, 0x0E, 0x07, 0xC0, 0x0C, 0x0D, 0x00, 0x1C, 0x1E, 0x00,
  0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80, 0x01,
  0x87, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x1C,
  0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x06,
  0x01, 0xC0, 0x07, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x80, 0x06, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x0E, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x70,
  0x00, 0x60, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF7, 0x00, 0x01, 0xC3, 0x80, 0x07, 0x81, 0xC0, 0x0E, 0x00, 0xC0,
  0x1C, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x30, 0x00, 0x70, 0x70, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x70, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x1F, 0x3F, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80,
  0x0F, 0x07, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x70, 0x70,
  0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x03, 0x86, 0x00,
  0x0E, 0x1C, 0x00, 0x78, 0x30, 0x03, 0x60, 0xE0, 0x1D, 0x81, 0xC0, 0xEC,
  0x03, 0xFE, 0x30, 0x07, 0xE0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF7, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x07, 0x03, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x03, 0x83,
  0xC1, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x07,
  0x80, 0x30, 0xC0, 0x0F, 0xF8, 0x18, 0x60, 0x1C, 0x18, 0x0C, 0x60, 0x1C,
  0x0C, 0x06, 0x30, 0x0C, 0x06, 0x03, 0x30, 0x0C, 0x07, 0x01, 0x98, 0x0C,
  0x03, 0x01, 0x8C, 0x06, 0x01, 0x80, 0xC6, 0x06, 0x00, 0xC0, 0x66, 0x03,
  0x00, 0xC0, 0x33, 0x01, 0x80, 0x60, 0x19, 0x81, 0x80, 0x30, 0x0C, 0xC0,
  0xC0, 0x18, 0x0C, 0xC0, 0x60, 0x18, 0x06, 0x60, 0x30, 0x0C, 0x03, 0x30,
  0x10, 0x06, 0x03, 0x18, 0x18, 0x07, 0x01, 0x8C, 0x0C, 0x03, 0x81, 0x86,
  0x06, 0x03, 0xC0, 0xC3, 0x01, 0x81, 0x60, 0xC1, 0x80, 0xC1, 0xB0, 0xE0,
  0xC0, 0x73, 0x8D, 0xE0, 0x60, 0x1F, 0x87, 0xE0, 0x30, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x38,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0xE0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x38,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x3E, 0x00, 0x60, 0x03,
  0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00,
  0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x03,
  0x00, 0x1E, 0x03, 0x80, 0x3E, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x07,
  0x00, 0x10, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x01, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0C,
  0x01, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x60,
  0x18, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x03,
  0x80, 0x60, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0E, 0x03, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0xF8, 0xE0, 0x01, 0xFF, 0x8C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0x80, 0x3C, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0xEF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00,
  0x18, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0xED,
  0x80, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0xF9, 0x80, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0xD8, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x1B, 0x00, 0x00, 0x1B, 0x80,
  0x6C, 0x00, 0x00, 0x6C, 0x01, 0x98, 0x00, 0x03, 0x30, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x39, 0x80, 0x00, 0x63, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x31, 0x80, 0x01,
  0x86, 0x01, 0x86, 0x00, 0x06, 0x38, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x03, 0x87, 0x00, 0x38,
  0x30, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x30, 0x30, 0x07, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x1C, 0x0E, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x06, 0x03,
  0x03, 0x80, 0xC0, 0x18, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x70, 0x0C,
  0x03, 0x00, 0xC1, 0x80, 0x70, 0x0C, 0x03, 0x8E, 0x01, 0x80, 0x30, 0x06,
  0x30, 0x06, 0x01, 0xC0, 0x19, 0xC0, 0x18, 0x06, 0x00, 0x66, 0x00, 0xE0,
  0x18, 0x01, 0xB8, 0x03, 0x00, 0x60, 0x06, 0xC0, 0x0C, 0x01, 0x80, 0x1F,
  0x00, 0x30, 0x0E, 0x00, 0x78, 0x00, 0xC0, 0x30, 0x01, 0xE0, 0x07, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x18, 0x03, 0xC0, 0x00, 0x30, 0x07, 0x80, 0x00, 0x60, 0x0F, 0x00, 0x01,
  0xC0, 0x3B, 0x00, 0x03, 0x00, 0x66, 0x00, 0x06, 0x00, 0xCC, 0x00, 0x0C,
  0x01, 0x98, 0x00, 0x18, 0x03, 0x18, 0x00, 0x60, 0x0E, 0x30, 0x00, 0xC0,
  0x18, 0x60, 0x01, 0x80, 0x30, 0xC0, 0x03, 0x00, 0x61, 0xC0, 0x0E, 0x00,
  0xC1, 0x80, 0x18, 0x03, 0x03, 0x00, 0x30, 0x06, 0x06, 0x00, 0x60, 0x0C,
  0x0E, 0x00, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0x70, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x70, 0x18, 0x03, 0x00, 0x60, 0x30, 0x06, 0x00,
  0xC0, 0xE0, 0x1C, 0x01, 0x81, 0x80, 0x30, 0x03, 0x83, 0x00, 0x60, 0x03,
  0x06, 0x00, 0xC0, 0x06, 0x1C, 0x01, 0x80, 0x0C, 0x30, 0x07, 0x00, 0x1C,
  0x60, 0x0C, 0x00, 0x18, 0xC0, 0x18, 0x00, 0x31, 0x80, 0x30, 0x00, 0x67,
  0x00, 0xE0, 0x00, 0xEC, 0x01, 0x80, 0x00, 0xD8, 0x03, 0x00, 0x01, 0xB0,
  0x06, 0x00, 0x03, 0x60, 0x0C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x3C, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x06, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0C, 0x00,
  0xE0, 0x0C, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xE0, 0x1C, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x06,
  0x01, 0xC0, 0x07, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x0C, 0x03, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x30, 0x03, 0x80,
  0x70, 0x01, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x0E, 0x00,
  0x20, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x0F, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x78, 0x07, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0xE0, 0x30, 0x01, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x31,
  0xC0, 0x00, 0x63, 0x00, 0x00, 0x46, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0xEC, 0x00,
  0x1B, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x03,
  0x98, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x03, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x18, 0x03, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x30, 0x0C, 0x06, 0x01,
  0x81, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x03, 0x80, 0x60, 0x60, 0x18, 0x18, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x18, 0x38, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x06,
  0x0C, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x01, 0x86, 0x00, 0xE1,
  0x80, 0x0C, 0x70, 0x06, 0x18, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x67, 0x00,
  0x06, 0xC0, 0x03, 0x30, 0x00, 0x36, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x38, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0x60, 0x70, 0x07, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x07, 0x0E,
  0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01,
  0xB8, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0xC0, 0x03, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x0E, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x60, 0x00, 0x31, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x00, 0x3F, 0x04,
  0x03, 0xFE, 0x30, 0x1C, 0x0C, 0xC0, 0xE0, 0x1B, 0x07, 0x00, 0x6C, 0x38,
  0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x01, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00,
  0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0xF0, 0xC0, 0x03, 0x83, 0x80, 0x1E, 0x06, 0x00, 0xD8, 0x18,
  0x03, 0x60, 0x70, 0x39, 0x80, 0xFB, 0xCC, 0x01, 0xFC, 0x30, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x1F, 0x80, 0x31, 0xFF, 0x00, 0xCE, 0x0E, 0x03, 0x60, 0x18,
  0x1B, 0x00, 0x70, 0x78, 0x00, 0xC1, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x3C,
  0x00, 0x30, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x71,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x0C,
  0x1E, 0x00, 0x70, 0xD8, 0x03, 0x83, 0x30, 0x1C, 0x0C, 0xFB, 0xE0, 0x30,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1C, 0x04,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x04, 0x0F, 0x9E,
  0x00, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0xC3, 0x80, 0x0F, 0xFC, 0xC0, 0x07, 0x03, 0x30, 0x03, 0x80, 0x6C,
  0x01, 0xC0, 0x0B, 0x00, 0x60, 0x03, 0xC0, 0x30, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x30, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00,
  0x07, 0x00, 0xC0, 0x03, 0xC0, 0x30, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x01,
  0x80, 0x36, 0x00, 0x60, 0x1D, 0x80, 0x1C, 0x0E, 0x60, 0x03, 0xEF, 0x18,
  0x00, 0x7F, 0x8C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x07, 0x03, 0x01, 0xC0, 0x70, 0x70, 0x06, 0x1C, 0x00, 0xC3, 0x00,
  0x18, 0xE0, 0x03, 0x18, 0x00, 0xE7, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x01,
  0xC7, 0x00, 0x70, 0xC0, 0x3C, 0x18, 0xFE, 0x03, 0xFF, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x60, 0x3C, 0xFC, 0x03, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0x80, 0x1F, 0xF8, 0x80, 0x1C,
  0x0C, 0xC0, 0x1C, 0x03, 0x60, 0x1C, 0x00, 0xB0, 0x0C, 0x00, 0x78, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xE0, 0x30, 0x00, 0xF0, 0x1C, 0x00,
  0xF0, 0x06, 0x00, 0xF8, 0x03, 0x00, 0xEC, 0x01, 0xC0, 0xE6, 0x00, 0x7D,
  0xE7, 0x00, 0x1F, 0xE3, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x40, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x87, 0xF0, 0x0C, 0x7F, 0xC0, 0x6E, 0x07, 0x03, 0x60, 0x18, 0x36, 0x00,
  0xC1, 0xE0, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x87,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x30, 0xE0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x00, 0x00, 0x40, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x08, 0x70, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x07,
  0x00, 0x38, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00,
  0x31, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x7C, 0x00, 0x1B, 0x30, 0x00, 0x7C,
  0xC0, 0x01, 0xE3, 0x00, 0x0F, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x00, 0x03, 0x0F, 0xC0, 0x7F, 0x00, 0xCF, 0xF8,
  0x3F, 0xE0, 0x37, 0x07, 0x38, 0x1C, 0x0B, 0x00, 0xCC, 0x07, 0x06, 0x80,
  0x36, 0x00, 0xC1, 0xE0, 0x0F, 0x00, 0x30, 0x70, 0x03, 0xC0, 0x0C, 0x1C,
  0x00, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0x01,
  0x87, 0x00, 0x18, 0x00, 0x61, 0x80, 0x06, 0x00, 0x38, 0x60, 0x01, 0x80,
  0x0C, 0x18, 0x00, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x00, 0xC3, 0x80, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0x06, 0x0C, 0x00,
  0x70, 0x01, 0x83, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x06, 0x00, 0x18, 0x60,
  0x01, 0x80, 0x0E, 0x18, 0x00, 0x60, 0x03, 0x06, 0x00, 0x38, 0x00, 0xC3,
  0x80, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x03, 0x0F, 0xE0, 0x18, 0xFF, 0x80, 0xDC,
  0x0E, 0x04, 0xC0, 0x30, 0x6C, 0x01, 0x83, 0xC0, 0x0C, 0x1C, 0x00, 0x60,
  0xE0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00,
  0x70, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E,
  0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x0E, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x70, 0x38, 0x07,
  0x00, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x07,
  0x18, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x77, 0x00,
  0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x37,
  0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x73, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x1C, 0x18,
  0x01, 0xC0, 0xE0, 0x0C, 0x03, 0x01, 0xC0, 0x1F, 0x7C, 0x00, 0x7F, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x60, 0xFC, 0x00, 0x31, 0xFF, 0x00, 0x19, 0x81,
  0xC0, 0x0D, 0x80, 0x60, 0x0D, 0x80, 0x38, 0x06, 0xC0, 0x0C, 0x03, 0xC0,
  0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0C,
  0x03, 0xC0, 0x0E, 0x03, 0xE0, 0x0E, 0x01, 0x98, 0x0E, 0x00, 0xCF, 0xBE,
  0x00, 0x61, 0xFC, 0x00, 0x30, 0x38, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x06,
  0x01, 0xFF, 0x88, 0x07, 0x03, 0x30, 0x1C, 0x03, 0x60, 0x70, 0x02, 0xC0,
  0xC0, 0x05, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x61, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38,
  0x30, 0x00, 0x70, 0x60, 0x01, 0xE0, 0xC0, 0x03, 0xC1, 0xC0, 0x0F, 0x03,
  0x80, 0x3E, 0x03, 0x00, 0x6C, 0x07, 0x03, 0x98, 0x07, 0xDE, 0x70, 0x07,
  0xF8, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x0F, 0xC0, 0xC7, 0xE0,
  0x37, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x03,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x08,
  0x03, 0x81, 0xF3, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x03, 0xFF, 0x7F, 0xF0,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x20, 0x3F, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x38, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1,
  0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x83, 0x00, 0x1C,
  0x0C, 0x00, 0xF0, 0x38, 0x06, 0xC0, 0xE0, 0x33, 0x01, 0xF7, 0x8C, 0x03,
  0xFC, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x1C, 0x01,
  0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03,
  0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x16, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0D, 0x80,
  0x0E, 0x00, 0x36, 0x00, 0x38, 0x01, 0x98, 0x01, 0xE0, 0x06, 0x60, 0x07,
  0x80, 0x39, 0x80, 0x36, 0x00, 0xC6, 0x00, 0xD8, 0x03, 0x18, 0x06, 0x60,
  0x18, 0x60, 0x19, 0x80, 0x61, 0x80, 0xE6, 0x03, 0x86, 0x03, 0x18, 0x0C,
  0x18, 0x0C, 0x60, 0x30, 0x60, 0x61, 0x81, 0x81, 0x81, 0x86, 0x06, 0x06,
  0x0C, 0x18, 0x30, 0x18, 0x30, 0x60, 0xC0, 0x61, 0x81, 0x87, 0x01, 0x86,
  0x06, 0x18, 0x06, 0x18, 0x18, 0x60, 0x18, 0xC0, 0x63, 0x00, 0x63, 0x01,
  0x8C, 0x01, 0x98, 0x06, 0x70, 0x06, 0x60, 0x19, 0x80, 0x1B, 0x00, 0x66,
  0x00, 0x6C, 0x01, 0xB0, 0x01, 0xB0, 0x06, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x07, 0x01, 0x80, 0x0E, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xE0,
  0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x73,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x86, 0x00, 0x03, 0x86, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x21, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x05, 0xFF,
  0x80, 0x3E, 0x07, 0x81, 0xE0, 0x0F, 0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 41, 12, 1, -41 },
  { 63, 12, 15, 17, 6, -41 },
  { 86, 26, 41, 26, 1, -41 },
  { 220, 23, 47, 24, 1, -44 },
  { 356, 30, 43, 35, 3, -42 },
  { 518, 24, 43, 26, 0, -42 },
  { 647, 5, 15, 9, 6, -41 },
  { 657, 16, 50, 14, 2, -41 },
  { 757, 16, 50, 14, -4, -41 },
  { 857, 17, 19, 23, 7, -44 },
  { 898, 22, 27, 26, 3, -34 },
  { 973, 7, 13, 10, -2, -6 },
  { 985, 12, 2, 16, 2, -17 },
  { 988, 4, 4, 10, 1, -4 },
  { 990, 25, 41, 18, -3, -41 },
  { 1119, 21, 43, 24, 2, -42 },
  { 1232, 12, 41, 24, 7, -41 },
  { 1294, 24, 42, 24, -1, -42 },
  { 1420, 25, 43, 24, -1, -42 },
  { 1555, 24, 42, 24, -1, -42 },
  { 1681, 24, 42, 24, 0, -41 },
  { 1807, 23, 43, 24, 2, -42 },
  { 1931, 23, 41, 24, 3, -41 },
  { 2049, 24, 43, 24, 0, -42 },
  { 2178, 22, 43, 24, 1, -42 },
  { 2297, 9, 31, 10, 1, -31 },
  { 2332, 13, 38, 11, -3, -31 },
  { 2394, 22, 25, 26, 3, -33 },
  { 2463, 22, 15, 26, 3, -28 },
  { 2505, 22, 25, 26, 3, -33 },
  { 2574, 17, 42, 17, 2, -42 },
  { 2664, 33, 46, 36, 2, -41 },
  { 2854, 24, 42, 23, -4, -42 },
  { 2980, 25, 41, 26, 1, -41 },
  { 3109, 25, 43, 24, 3, -42 },
  { 3244, 26, 41, 29, 1, -41 },
  { 3378, 24, 41, 23, 1, -41 },
  { 3501, 24, 41, 21, 1, -41 },
  { 3624, 28, 43, 31, 3, -42 },
  { 3775, 30, 41, 30, 1, -41 },
  { 3929, 18, 41, 12, -2, -41 },
  { 4022, 21, 51, 11, -9, -41 },
  { 4156, 28, 41, 24, 1, -41 },
  { 4300, 16, 41, 21, 1, -41 },
  { 4382, 38, 41, 38, 1, -41 },
  { 4577, 31, 41, 31, 1, -41 },
  { 4736, 27, 43, 31, 3, -42 },
  { 4882, 24, 41, 24, 1, -41 },
  { 5005, 27, 52, 31, 3, -42 },
  { 5181, 24, 41, 25, 1, -41 },
  { 5304, 25, 43, 23, -1, -42 },
  { 5439, 21, 41, 21, 5, -41 },
  { 5547, 28, 42, 30, 3, -41 },
  { 5694, 23, 41, 24, 5, -41 },
  { 5812, 37, 41, 39, 6, -41 },
  { 6002, 29, 41, 22, -3, -41 },
  { 6151, 21, 41, 21, 5, -41 },
  { 6259, 27, 41, 22, -2, -41 },
  { 6398, 21, 50, 16, -1, -41 },
  { 6530, 8, 41, 19, 6, -41 },
  { 6571, 21, 50, 16, -4, -41 },
  { 6703, 23, 21, 26, 2, -41 },
  { 6764, 18, 2, 17, -5, 5 },
  { 6769, 7, 9, 13, 8, -44 },
  { 6777, 22, 32, 25, 2, -31 },
  { 6865, 22, 45, 25, 1, -44 },
  { 6989, 18, 32, 19, 2, -31 },
  { 7061, 26, 45, 26, 2, -44 },
  { 7208, 19, 32, 22, 2, -31 },
  { 7284, 27, 58, 13, -7, -44 },
  { 7480, 25, 45, 26, 0, -31 },
  { 7621, 21, 44, 25, 1, -44 },
  { 7737, 11, 42, 10, 1, -42 },
  { 7795, 20, 56, 11, -8, -42 },
  { 7935, 22, 44, 20, 1, -44 },
  { 8056, 11, 44, 10, 1, -44 },
  { 8117, 34, 31, 37, 1, -31 },
  { 8249, 21, 31, 25, 1, -31 },
  { 8331, 21, 32, 25, 2, -31 },
  { 8415, 25, 44, 25, -2, -31 },
  { 8553, 23, 45, 26, 2, -31 },
  { 8683, 18, 31, 16, 1, -31 },
  { 8753, 19, 32, 19, 0, -31 },
  { 8829, 13, 39, 13, 2, -38 },
  { 8893, 22, 32, 25, 2, -31 },
  { 8981, 19, 31, 19, 3, -31 },
  { 9055, 30, 31, 31, 3, -31 },
  { 9172, 24, 31, 20, -2, -31 },
  { 9265, 29, 45, 20, -6, -31 },
  { 9429, 21, 31, 17, -2, -31 },
  { 9511, 20, 50, 19, 2, -41 },
  { 9636, 2, 58, 23, 11, -44 },
  { 9651, 20, 50, 18, -3, -41 },
  { 9776, 22, 5, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC58PT7B_H_
