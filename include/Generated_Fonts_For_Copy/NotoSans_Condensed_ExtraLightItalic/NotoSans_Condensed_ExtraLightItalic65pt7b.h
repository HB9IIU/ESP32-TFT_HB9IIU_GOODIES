#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x00, 0x1C, 0x0E, 0x38, 0x18, 0x70, 0x70, 0xC0, 0xE1,
  0x81, 0xC3, 0x03, 0x0E, 0x06, 0x18, 0x0C, 0x30, 0x38, 0x60, 0x60, 0xC0,
  0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x30, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xF3, 0x3F, 0x00,
  0xF0, 0xC1, 0x80, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0E,
  0x08, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x09, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x04, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x02, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18,
  0x38, 0x08, 0x06, 0x1C, 0x03, 0xC3, 0x1E, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x01, 0xFE, 0x00, 0x06, 0x01, 0xE3,
  0x80, 0x07, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xE0,
  0x30, 0x01, 0x80, 0x60, 0x18, 0x01, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x0E,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x30, 0x30, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x0C, 0x1C, 0x00,
  0x60, 0x06, 0x0C, 0x00, 0x30, 0x07, 0x0C, 0x00, 0x18, 0x03, 0x06, 0x0F,
  0xCC, 0x01, 0x86, 0x1F, 0xF6, 0x01, 0xC7, 0x1C, 0x3B, 0x00, 0xC3, 0x0C,
  0x0D, 0x80, 0xE3, 0x8C, 0x07, 0xC0, 0x61, 0x8E, 0x03, 0xF0, 0x71, 0x86,
  0x00, 0xDC, 0x70, 0xC3, 0x00, 0xEF, 0xF0, 0xC3, 0x80, 0x73, 0xE0, 0xE1,
  0x80, 0x38, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x70, 0xE0, 0x0C, 0x00, 0x30,
  0x60, 0x06, 0x00, 0x38, 0x30, 0x03, 0x00, 0x18, 0x18, 0x03, 0x80, 0x18,
  0x0C, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x60, 0x0E,
  0x03, 0x00, 0x70, 0x06, 0x01, 0x80, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x80, 0x18, 0x0E, 0x01,
  0x80, 0x0E, 0x06, 0x01, 0xC0, 0x03, 0x07, 0x00, 0xC0, 0x01, 0xEF, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x03,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1D, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x30, 0xE0, 0x38, 0x0E, 0x38, 0x03,
  0x01, 0x86, 0x00, 0x70, 0x31, 0xC0, 0x0E, 0x0C, 0x30, 0x00, 0xC1, 0x8E,
  0x00, 0x1C, 0x71, 0x80, 0x01, 0x8C, 0x30, 0x00, 0x3B, 0x86, 0x00, 0x07,
  0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x7C, 0x0C, 0x00, 0x0F, 0x81, 0xC0, 0x03, 0x30, 0x38, 0x01, 0xC7,
  0x03, 0x80, 0x70, 0x60, 0x3F, 0xFC, 0x0E, 0x03, 0xFF, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x39, 0xCE, 0x63, 0x19, 0xCC, 0x63, 0x19, 0x8C, 0x63, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x01,
  0x80, 0xC0, 0x3C, 0x18, 0x01, 0xC3, 0x00, 0x1E, 0x40, 0x60, 0xFB, 0xFC,
  0x07, 0xFC, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x01,
  0xC0, 0xC0, 0x70, 0x18, 0x1C, 0x01, 0x81, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00,
  0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00,
  0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x1F,
  0x80, 0xFE, 0x07, 0x38, 0x78, 0xC3, 0xC3, 0x3C, 0x1C, 0x60, 0x71, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0xE0, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0x60, 0x01, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x09, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x02, 0x00, 0x0F, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x18, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x61, 0xFF, 0x00,
  0x18, 0xFF, 0xE0, 0x0E, 0xF0, 0x1C, 0x03, 0x70, 0x03, 0x80, 0xD8, 0x00,
  0xE0, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00,
  0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x06, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x1C, 0x1E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01,
  0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x8F, 0x00, 0x0E,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x07,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E,
  0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x30, 0x00,
  0x3C, 0x1C, 0x00, 0x3E, 0x0E, 0x00, 0x36, 0x03, 0x80, 0x3B, 0x00, 0xF0,
  0x79, 0x80, 0x3F, 0xF1, 0xC0, 0x0F, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x08, 0x07, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x87,
  0xC0, 0x40, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x0F, 0xF0, 0x0C, 0x18, 0x01, 0xFF, 0xC0,
  0x61, 0xC0, 0x1C, 0x0C, 0x03, 0x0C, 0x01, 0xC0, 0x60, 0x18, 0xE0, 0x1C,
  0x03, 0x00, 0xC6, 0x00, 0xC0, 0x38, 0x06, 0x30, 0x0C, 0x01, 0x80, 0x73,
  0x80, 0xE0, 0x0C, 0x03, 0x98, 0x06, 0x00, 0x60, 0x18, 0xC0, 0x30, 0x07,
  0x00, 0xC6, 0x03, 0x80, 0x30, 0x06, 0x70, 0x18, 0x01, 0x80, 0x33, 0x00,
  0xC0, 0x1C, 0x03, 0x98, 0x0E, 0x00, 0xE0, 0x18, 0xC0, 0x60, 0x06, 0x00,
  0xC6, 0x03, 0x00, 0x30, 0x0E, 0x30, 0x18, 0x03, 0x80, 0x63, 0x80, 0xC0,
  0x1C, 0x03, 0x1C, 0x06, 0x01, 0xC0, 0x30, 0xC0, 0x30, 0x0E, 0x01, 0x86,
  0x01, 0x80, 0xD0, 0x18, 0x30, 0x0C, 0x06, 0x81, 0xC1, 0x80, 0x70, 0x66,
  0x1C, 0x0C, 0x01, 0xCE, 0x3B, 0xC0, 0x70, 0x0F, 0xE0, 0xFC, 0x03, 0x80,
  0x1C, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x30, 0x01, 0xE0, 0x07,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x80, 0x60, 0x01, 0xF0, 0x06, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x20, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x02,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x01, 0x80, 0x07,
  0xC0, 0x06, 0x00, 0x7C, 0x00, 0x18, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x02, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x60, 0x00, 0x7F,
  0xF0, 0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x20, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x0F, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xEF, 0x80,
  0x00, 0x01, 0x9B, 0x80, 0x00, 0x03, 0x67, 0x00, 0x00, 0x07, 0x86, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0x60, 0x06, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x80, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x07, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x80, 0x19, 0x80, 0x00, 0x06,
  0x70, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x00, 0x31, 0x80,
  0x1C, 0xC0, 0x00, 0x0E, 0x30, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x63,
  0x80, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x00, 0x0C, 0x30, 0x03, 0x86, 0x00,
  0x03, 0x86, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0x1C,
  0x38, 0x01, 0x83, 0x00, 0x03, 0x07, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0,
  0x0E, 0x0C, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x07, 0x07, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x06, 0x03, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x30,
  0x1C, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x07, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x03, 0x80, 0x70, 0x03, 0x00, 0x60, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x1C, 0x01, 0x80, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x03, 0x00, 0x38, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE7, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0xC0, 0x06, 0x00, 0x70, 0x01, 0xB8, 0x00, 0xC0, 0x0C,
  0x00, 0x36, 0x00, 0x38, 0x01, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x30,
  0x07, 0x80, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x01,
  0x80, 0x1B, 0x00, 0x00, 0x60, 0x0E, 0xC0, 0x00, 0x38, 0x03, 0xB8, 0x00,
  0x0E, 0x00, 0xCE, 0x00, 0x03, 0x00, 0x31, 0x80, 0x00, 0xC0, 0x0C, 0x60,
  0x00, 0x30, 0x07, 0x1C, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x07, 0x00, 0x60,
  0xC0, 0x01, 0x80, 0x18, 0x30, 0x00, 0x60, 0x0E, 0x0E, 0x00, 0x18, 0x03,
  0x83, 0x80, 0x0E, 0x00, 0xC0, 0x60, 0x03, 0x80, 0x30, 0x18, 0x00, 0xC0,
  0x0C, 0x07, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x06, 0x00, 0xE0,
  0x18, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0xC0, 0x0C, 0x00, 0x70, 0x30, 0x03, 0x00, 0x0C, 0x0C, 0x01, 0xC0,
  0x03, 0x07, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x18, 0x00, 0x38, 0x60, 0x06,
  0x00, 0x06, 0x18, 0x03, 0x80, 0x01, 0x86, 0x00, 0xE0, 0x00, 0x73, 0x80,
  0x30, 0x00, 0x1C, 0xE0, 0x0C, 0x00, 0x03, 0x30, 0x03, 0x00, 0x00, 0xCC,
  0x01, 0xC0, 0x00, 0x3B, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x01,
  0xF0, 0x06, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0x06, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x30, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30,
  0x1C, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x0C, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x38, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x01, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xC0, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x08, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3A, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x78, 0x00, 0x06, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x60, 0x00, 0x39, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0x38, 0x00, 0x1D, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x70,
  0x00, 0x30, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x1C, 0x00, 0x1D, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x0E,
  0x00, 0x18, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xC3, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x03, 0x80, 0x38, 0x38, 0x03,
  0x80, 0x70, 0x06, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x1C, 0x03, 0x00, 0x38, 0x06, 0x03, 0x80, 0x60, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x00, 0x1C, 0x0E, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0x80, 0x38, 0x18, 0x00, 0x70, 0x30, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x1C, 0x18, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x00, 0xE1,
  0x80, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00,
  0x38, 0xC0, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x0E, 0x60, 0x00, 0xE6,
  0x00, 0x01, 0xDC, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x00, 0x03, 0x30, 0x00,
  0x07, 0x60, 0x00, 0x66, 0x00, 0x00, 0xFC, 0x00, 0x0D, 0xC0, 0x00, 0x1F,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x67, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60,
  0x60, 0x01, 0xC0, 0xE0, 0x03, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x18, 0x00, 0x70, 0x70, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x8E,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x03,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06,
  0x06, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0xC0, 0x1E, 0x3C, 0x60,
  0x1C, 0x07, 0x30, 0x1C, 0x01, 0xB8, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x87, 0x00, 0x03,
  0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x06, 0x00, 0x1F, 0x03, 0x00, 0x0F, 0x01,
  0xC0, 0x0D, 0x80, 0xE0, 0x0C, 0xC0, 0x38, 0x1C, 0x60, 0x0F, 0xFC, 0x60,
  0x03, 0xFC, 0x30, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x03, 0x0F, 0xF8, 0x01, 0x8E, 0x1E,
  0x01, 0xCC, 0x03, 0x80, 0xEC, 0x01, 0xC0, 0x6C, 0x00, 0x70, 0x3E, 0x00,
  0x38, 0x1E, 0x00, 0x0C, 0x1E, 0x00, 0x06, 0x0F, 0x00, 0x03, 0x07, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x06, 0xC0, 0x0E, 0x03, 0x60, 0x0F, 0x03, 0x18, 0x0F, 0x01, 0x8F, 0xFF,
  0x00, 0xC3, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xC0, 0x1F, 0x0C, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x02, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0x07, 0x00, 0x07, 0xFE, 0x38, 0x00, 0x7C, 0x79, 0x80, 0x07, 0x00, 0xCC,
  0x00, 0x70, 0x03, 0x60, 0x07, 0x00, 0x1F, 0x00, 0x70, 0x00, 0xF0, 0x03,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x07, 0x80, 0x18, 0x00, 0x6C, 0x00, 0xC0, 0x07, 0xE0, 0x07, 0x00,
  0x36, 0x00, 0x38, 0x03, 0x30, 0x00, 0xE0, 0x71, 0x80, 0x03, 0xFF, 0x0C,
  0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xC0, 0x07, 0x87, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x18, 0x0E,
  0x00, 0x60, 0x70, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00,
  0x61, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x83,
  0x00, 0x3C, 0x1C, 0x03, 0xE0, 0x71, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xC3, 0x00, 0x1F, 0x1E, 0x60, 0x03, 0x80, 0x66, 0x00, 0x70,
  0x03, 0x60, 0x0E, 0x00, 0x36, 0x01, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x18, 0x00,
  0x6C, 0x01, 0x80, 0x0F, 0xC0, 0x1C, 0x00, 0xD8, 0x01, 0xC0, 0x19, 0x80,
  0x0E, 0x07, 0x18, 0x00, 0x7F, 0xE3, 0x80, 0x03, 0xFC, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x80, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC1, 0xF8, 0x01, 0x87, 0xFC, 0x01, 0x9F, 0x1E, 0x01, 0xB8,
  0x07, 0x03, 0xF0, 0x07, 0x03, 0x60, 0x03, 0x03, 0xC0, 0x03, 0x03, 0x80,
  0x03, 0x07, 0x80, 0x03, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00,
  0x18, 0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x00, 0x20,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x03,
  0x00, 0xE0, 0x03, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x06,
  0x07, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x78, 0x00, 0x0C, 0xF8, 0x00, 0x1D, 0xD8, 0x00, 0x1F,
  0x9C, 0x00, 0x1F, 0x1C, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x06, 0x3F, 0xE0, 0x7F, 0xE0, 0x19, 0xC3, 0xC3, 0xC7,
  0x80, 0xEE, 0x03, 0x9C, 0x07, 0x03, 0x60, 0x0E, 0xC0, 0x0C, 0x0D, 0x00,
  0x1F, 0x00, 0x30, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x03,
  0x07, 0x80, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x70, 0x00,
  0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x38, 0x00, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0x01, 0x83, 0x00, 0x07,
  0x00, 0x06, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x60, 0x00, 0xE1,
  0xC0, 0x01, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x60, 0x00, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x70, 0x00, 0x60, 0xC0, 0x01, 0xC0,
  0x03, 0x83, 0x00, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x70,
  0x00, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x80, 0x03, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x18, 0x00, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xC0, 0x01, 0x83, 0x80,
  0x07, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0x87, 0xFC, 0x01, 0x9F, 0x1E, 0x03, 0xB8, 0x07, 0x03, 0x70, 0x07,
  0x03, 0x60, 0x03, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x07, 0x80, 0x03,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x06,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70,
  0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0,
  0x01, 0xE1, 0xE0, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC7,
  0x00, 0x03, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x0F, 0xF8, 0x00, 0x31, 0xC3,
  0xC0, 0x07, 0x38, 0x0E, 0x00, 0x66, 0x00, 0x60, 0x06, 0xC0, 0x07, 0x00,
  0x6C, 0x00, 0x70, 0x07, 0x80, 0x03, 0x00, 0xF0, 0x00, 0x30, 0x0F, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x30, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x0D,
  0x80, 0x1C, 0x00, 0xD8, 0x03, 0xC0, 0x1C, 0xC0, 0x78, 0x01, 0xCF, 0xFF,
  0x00, 0x18, 0x7F, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFC, 0x70, 0x07, 0x87, 0x98, 0x07, 0x80, 0x66, 0x01, 0xC0,
  0x0D, 0x80, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0xF0, 0x18, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xB0, 0x18, 0x00, 0x7C, 0x07, 0x00,
  0x36, 0x01, 0xC0, 0x19, 0x80, 0x38, 0x1C, 0x60, 0x07, 0xFE, 0x38, 0x00,
  0xFF, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x18, 0xFF, 0x01, 0x9F, 0x20,
  0x3B, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x78, 0x3E, 0x07, 0x00, 0x20, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x10, 0x01, 0xC0, 0xC0, 0x1E, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0xFF,
  0xF3, 0xFF, 0xC1, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70,
  0x00, 0x30, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x36, 0x01, 0x80, 0x3B,
  0x00, 0xE0, 0x39, 0x80, 0x3F, 0xF8, 0xC0, 0x0F, 0xF0, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E,
  0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x0E, 0x01,
  0xC0, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0xE0,
  0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06,
  0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00,
  0x6E, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0xEC, 0x00, 0x7C, 0x00, 0x66,
  0x00, 0x36, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x39, 0x80, 0x19, 0x80, 0x18,
  0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x0E,
  0x18, 0x07, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x03,
  0x83, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC1, 0x81, 0xC0, 0xC0, 0xE0, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x70, 0x30, 0x70, 0x18, 0x30, 0x18,
  0x30, 0x0C, 0x38, 0x0C, 0x38, 0x06, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x03,
  0x0C, 0x01, 0x8C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x67, 0x00,
  0x67, 0x00, 0x33, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x1B, 0x80, 0x0D, 0x80,
  0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x70, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0xF8, 0x03, 0xE1, 0xE8, 0x00, 0x7F, 0xE4, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 46, 14, 1, -46 },
  { 76, 15, 16, 19, 6, -46 },
  { 106, 29, 46, 29, 1, -46 },
  { 273, 26, 53, 27, 1, -49 },
  { 446, 33, 48, 40, 4, -47 },
  { 644, 27, 48, 29, 0, -47 },
  { 806, 5, 16, 10, 7, -46 },
  { 816, 18, 56, 16, 2, -46 },
  { 942, 18, 56, 16, -4, -46 },
  { 1068, 19, 21, 25, 8, -49 },
  { 1118, 25, 30, 30, 3, -38 },
  { 1212, 9, 15, 11, -3, -7 },
  { 1229, 14, 3, 18, 2, -19 },
  { 1235, 4, 5, 12, 1, -5 },
  { 1238, 28, 46, 20, -3, -46 },
  { 1399, 24, 48, 27, 2, -47 },
  { 1543, 14, 46, 27, 8, -46 },
  { 1624, 27, 47, 27, -1, -47 },
  { 1783, 27, 48, 27, -1, -47 },
  { 1945, 27, 47, 27, -1, -47 },
  { 2104, 27, 47, 27, 0, -46 },
  { 2263, 26, 48, 27, 2, -47 },
  { 2419, 25, 46, 27, 4, -46 },
  { 2563, 27, 48, 27, 0, -47 },
  { 2725, 25, 48, 27, 1, -47 },
  { 2875, 10, 35, 12, 1, -35 },
  { 2919, 14, 43, 12, -3, -35 },
  { 2995, 25, 28, 30, 3, -37 },
  { 3083, 25, 16, 30, 3, -31 },
  { 3133, 25, 28, 30, 3, -37 },
  { 3221, 20, 47, 19, 2, -47 },
  { 3339, 37, 52, 40, 2, -46 },
  { 3580, 26, 47, 26, -4, -47 },
  { 3733, 28, 46, 29, 1, -46 },
  { 3894, 29, 48, 27, 3, -47 },
  { 4068, 30, 46, 32, 1, -46 },
  { 4241, 27, 46, 26, 1, -46 },
  { 4397, 27, 46, 24, 1, -46 },
  { 4553, 32, 48, 34, 3, -47 },
  { 4745, 33, 46, 34, 1, -46 },
  { 4935, 21, 46, 14, -3, -46 },
  { 5056, 23, 57, 12, -10, -46 },
  { 5220, 31, 46, 27, 1, -46 },
  { 5399, 18, 46, 24, 1, -46 },
  { 5503, 43, 46, 43, 1, -46 },
  { 5751, 34, 46, 35, 1, -46 },
  { 5947, 30, 48, 35, 3, -47 },
  { 6127, 27, 46, 27, 1, -46 },
  { 6283, 30, 58, 35, 3, -47 },
  { 6501, 27, 46, 28, 1, -46 },
  { 6657, 28, 48, 26, -1, -47 },
  { 6825, 23, 46, 23, 6, -46 },
  { 6958, 31, 47, 33, 3, -46 },
  { 7141, 26, 46, 27, 6, -46 },
  { 7291, 43, 46, 44, 6, -46 },
  { 7539, 33, 46, 24, -4, -46 },
  { 7729, 23, 46, 23, 6, -46 },
  { 7862, 30, 46, 25, -2, -46 },
  { 8035, 24, 56, 18, -1, -46 },
  { 8203, 9, 46, 21, 7, -46 },
  { 8255, 23, 56, 18, -4, -46 },
  { 8416, 26, 24, 29, 2, -46 },
  { 8494, 20, 2, 20, -5, 6 },
  { 8499, 8, 11, 14, 9, -50 },
  { 8510, 25, 36, 28, 2, -35 },
  { 8623, 25, 50, 28, 1, -49 },
  { 8780, 21, 36, 22, 2, -35 },
  { 8875, 29, 50, 29, 2, -49 },
  { 9057, 22, 36, 25, 2, -35 },
  { 9156, 30, 66, 14, -8, -50 },
  { 9404, 28, 51, 29, 0, -35 },
  { 9583, 24, 49, 28, 1, -49 },
  { 9730, 12, 47, 12, 1, -47 },
  { 9801, 23, 63, 12, -9, -47 },
  { 9983, 24, 49, 23, 1, -49 },
  { 10130, 13, 49, 11, 1, -49 },
  { 10210, 38, 35, 42, 1, -35 },
  { 10377, 24, 35, 28, 1, -35 },
  { 10482, 23, 36, 28, 2, -35 },
  { 10586, 28, 50, 28, -2, -35 },
  { 10761, 26, 50, 29, 2, -35 },
  { 10924, 20, 35, 18, 1, -35 },
  { 11012, 21, 36, 21, 0, -35 },
  { 11107, 14, 44, 15, 2, -43 },
  { 11184, 25, 35, 28, 2, -34 },
  { 11294, 20, 34, 21, 4, -34 },
  { 11379, 33, 34, 35, 4, -34 },
  { 11520, 27, 34, 22, -3, -34 },
  { 11635, 32, 50, 22, -7, -34 },
  { 11835, 23, 34, 20, -2, -34 },
  { 11933, 23, 56, 21, 2, -46 },
  { 12094, 3, 65, 26, 12, -49 },
  { 12119, 23, 56, 21, -4, -46 },
  { 12280, 25, 6, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC65PT7B_H_
