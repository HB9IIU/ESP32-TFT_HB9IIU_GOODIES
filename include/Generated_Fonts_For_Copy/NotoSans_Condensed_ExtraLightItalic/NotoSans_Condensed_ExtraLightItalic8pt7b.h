#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x35, 0x66, 0xAC, 0x75, 0x27, 0x80, 0x55, 0xA8,
  0xB6, 0xB8, 0x2D, 0x7B, 0xC0, 0xC0, 0x5A, 0xA8, 0x24, 0x92, 0xB0, 0x64,
  0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB, 0x80, 0x66,
  0xA0, 0x64, 0x95, 0x80, 0x64, 0xB3, 0xC0, 0x25, 0xDE, 0x80, 0x6B, 0x13,
  0xC0, 0x2B, 0x5B, 0xC0, 0x72, 0x24, 0x48, 0x6D, 0xDB, 0xC0, 0x76, 0xB3,
  0x80, 0x10, 0x18, 0x2B, 0x10, 0xFC, 0x8C, 0xE0, 0x45, 0x29, 0x00, 0x32,
  0x6F, 0xBF, 0xC1, 0x80, 0x11, 0x37, 0x59, 0x65, 0x5A, 0xAE, 0x34, 0x88,
  0x8E, 0x65, 0x59, 0x9E, 0x74, 0x4A, 0x8C, 0x74, 0x4A, 0x88, 0x34, 0x8B,
  0x9F, 0x55, 0x5B, 0x9A, 0x56, 0xA0, 0x24, 0xA4, 0xB0, 0x56, 0x4C, 0xAA,
  0x56, 0xB0, 0x4A, 0x57, 0xBE, 0xD4, 0x55, 0x5B, 0xAA, 0x35, 0x99, 0x9E,
  0x6D, 0xA9, 0x00, 0x35, 0x99, 0x9E, 0x20, 0x6D, 0xEB, 0x40, 0x71, 0x13,
  0xC0, 0xF2, 0x49, 0x00, 0x55, 0x99, 0x9E, 0xB7, 0x49, 0x00, 0xAD, 0x7D,
  0x6A, 0x50, 0x56, 0x44, 0xCA, 0xBA, 0x49, 0x00, 0x65, 0x29, 0x80, 0x69,
  0x49, 0x20, 0xFC, 0x24, 0x92, 0x70, 0x2E, 0x80, 0xE0, 0x80, 0x76, 0xF0,
  0x4A, 0xDB, 0xC0, 0x72, 0x60, 0x13, 0x5A, 0xAE, 0x7E, 0x60, 0x36, 0x24,
  0x44, 0x48, 0x76, 0xF3, 0x80, 0x4A, 0xDB, 0x40, 0x4A, 0xA0, 0x20, 0xA4,
  0x94, 0x4A, 0xAD, 0x40, 0x5A, 0xA0, 0x7D, 0x6B, 0x50, 0xF6, 0xD0, 0x76,
  0xF0, 0xF6, 0xF9, 0x00, 0x76, 0xF2, 0x40, 0xF2, 0x40, 0xF1, 0x60, 0x6A,
  0x80, 0xB6, 0xE0, 0xB5, 0x40, 0xAD, 0x99, 0x40, 0xA9, 0x60, 0x55, 0x64,
  0x4C, 0x6A, 0x60, 0x29, 0x65, 0x30, 0xFF, 0x55, 0x68, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 3, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 2, 7, 2, 0, -6 },
  { 20, 3, 7, 2, -1, -6 },
  { 23, 2, 3, 3, 1, -6 },
  { 24, 3, 4, 4, 0, -5 },
  { 26, 1, 2, 1, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 1, 0, -1 },
  { 29, 3, 6, 2, 0, -6 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 2, 6, 3, 1, -6 },
  { 37, 3, 6, 3, 0, -6 },
  { 40, 3, 6, 3, 0, -6 },
  { 43, 3, 6, 3, 0, -6 },
  { 46, 3, 6, 3, 0, -6 },
  { 49, 3, 6, 3, 0, -6 },
  { 52, 4, 6, 3, 0, -6 },
  { 55, 3, 6, 3, 0, -6 },
  { 58, 3, 6, 3, 0, -6 },
  { 61, 1, 4, 1, 0, -4 },
  { 62, 1, 5, 1, 0, -4 },
  { 63, 3, 4, 4, 0, -5 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -5 },
  { 68, 3, 6, 2, 0, -6 },
  { 71, 5, 7, 5, 0, -6 },
  { 76, 4, 6, 3, -1, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 4, 6, 3, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 3, 0, -6 },
  { 91, 4, 6, 3, 0, -6 },
  { 94, 4, 6, 4, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 2, 6, 2, 0, -6 },
  { 102, 3, 7, 1, -1, -6 },
  { 105, 4, 6, 3, 0, -6 },
  { 108, 2, 6, 3, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 4, 0, -6 },
  { 117, 4, 6, 4, 0, -6 },
  { 120, 3, 6, 3, 0, -6 },
  { 123, 4, 7, 4, 0, -6 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 3, 6, 3, 1, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 3, 6, 3, 1, -6 },
  { 142, 5, 6, 5, 1, -6 },
  { 146, 4, 6, 3, 0, -6 },
  { 149, 3, 6, 3, 1, -6 },
  { 152, 3, 6, 3, 0, -6 },
  { 155, 3, 7, 2, 0, -6 },
  { 158, 1, 6, 3, 1, -6 },
  { 159, 3, 7, 2, -1, -6 },
  { 162, 3, 3, 4, 0, -6 },
  { 164, 3, 1, 2, -1, 0 },
  { 165, 1, 1, 2, 1, -6 },
  { 166, 3, 4, 4, 0, -4 },
  { 168, 3, 6, 4, 0, -6 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 4, 8, 2, -1, -6 },
  { 182, 3, 6, 4, 0, -4 },
  { 185, 3, 6, 3, 0, -6 },
  { 188, 2, 6, 1, 0, -6 },
  { 190, 3, 8, 1, -1, -6 },
  { 193, 3, 6, 3, 0, -6 },
  { 196, 2, 6, 1, 0, -6 },
  { 198, 5, 4, 5, 0, -4 },
  { 201, 3, 4, 3, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 3, 6, 4, 0, -4 },
  { 208, 3, 6, 4, 0, -4 },
  { 211, 3, 4, 2, 0, -4 },
  { 213, 3, 4, 3, 0, -4 },
  { 215, 2, 5, 2, 0, -5 },
  { 217, 3, 4, 3, 0, -4 },
  { 219, 3, 4, 3, 0, -4 },
  { 221, 5, 4, 4, 0, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 4, 6, 3, -1, -4 },
  { 229, 3, 4, 2, 0, -4 },
  { 231, 3, 7, 3, 0, -6 },
  { 234, 1, 8, 3, 1, -6 },
  { 235, 2, 7, 3, 0, -6 },
  { 237, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC8PT7B_H_
