#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC71PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x18, 0x0E, 0x18,
  0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x70,
  0x18, 0x70, 0x38, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xE0, 0x30, 0xC0,
  0x60, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xB7, 0xF0, 0x07,
  0x87, 0x07, 0x00, 0xF0, 0x60, 0x10, 0x1E, 0x06, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00,
  0xC3, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x80, 0x30, 0x78, 0x0C,
  0x06, 0x1F, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x18, 0x03,
  0x87, 0x00, 0x03, 0x80, 0x70, 0x38, 0x00, 0x30, 0x06, 0x01, 0x80, 0x06,
  0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x38, 0x06, 0x00, 0x30, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x06, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x03, 0x03, 0x80, 0x06, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x07, 0x07, 0x00, 0x0E, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x06, 0x0C, 0x0F,
  0x8E, 0x00, 0xE1, 0xC3, 0xFC, 0xE0, 0x0C, 0x18, 0x7D, 0xEE, 0x00, 0xC3,
  0x87, 0x07, 0xE0, 0x1C, 0x30, 0xE0, 0x7E, 0x03, 0x87, 0x1C, 0x03, 0xE0,
  0x38, 0xE1, 0x80, 0x36, 0x07, 0x0C, 0x38, 0x03, 0x70, 0xE1, 0xC3, 0x00,
  0x33, 0xFC, 0x18, 0x70, 0x03, 0x1F, 0x83, 0x87, 0x00, 0x30, 0x00, 0x30,
  0x60, 0x07, 0x00, 0x07, 0x06, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x07, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x01, 0xC0, 0x30, 0x07, 0x00, 0x1C, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0xE0, 0x0C, 0x00, 0x0E, 0x1C, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x38,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x1E, 0x07, 0x00,
  0x70, 0xF0, 0x1C, 0x01, 0x83, 0x80, 0x38, 0x0E, 0x1C, 0x00, 0xE0, 0x38,
  0xE0, 0x01, 0x81, 0xC3, 0x80, 0x07, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x70,
  0x00, 0x38, 0xE1, 0xC0, 0x00, 0xE7, 0x06, 0x00, 0x01, 0x9C, 0x18, 0x00,
  0x07, 0xE0, 0xE0, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x80, 0x60, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xFC,
  0x07, 0x00, 0x07, 0x38, 0x0E, 0x00, 0x78, 0xE0, 0x3C, 0x03, 0xC1, 0x80,
  0x7F, 0xFC, 0x07, 0x00, 0xFF, 0xE0, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x0C,
  0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x3E, 0x06, 0x00, 0x3C, 0x30,
  0x00, 0x3C, 0xC0, 0x30, 0x3F, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x70,
  0x38, 0x03, 0x80, 0x60, 0x1C, 0x01, 0xC0, 0x20, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x73, 0xFF, 0xE7, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xE0, 0x3D, 0xC0, 0xF3, 0x03, 0xC6, 0x1E, 0x1C, 0x78, 0x39, 0xE0,
  0x71, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x08, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x78, 0x1F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x10,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0x01, 0x80, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x83, 0xFC, 0x00, 0x71, 0xFF, 0xE0, 0x0C, 0x7C, 0x3E, 0x01,
  0x9C, 0x01, 0xC0, 0x76, 0x00, 0x1C, 0x0F, 0x80, 0x03, 0x81, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x37, 0x03,
  0xC0, 0x1C, 0xC0, 0x3C, 0x0F, 0x18, 0x03, 0xFF, 0xC7, 0x00, 0x3F, 0xE0,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x3C,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7C,
  0x1F, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x0F, 0xFC, 0x06,
  0x07, 0x00, 0x1F, 0xFC, 0x03, 0x83, 0x00, 0x1C, 0x06, 0x01, 0xC3, 0x80,
  0x1C, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x03, 0x80, 0x60, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x30, 0x06, 0x00, 0x70, 0x06, 0x38, 0x07, 0x00, 0x30, 0x07, 0x1C, 0x03,
  0x00, 0x18, 0x03, 0x8C, 0x03, 0x80, 0x1C, 0x01, 0x86, 0x01, 0xC0, 0x0E,
  0x00, 0xC7, 0x00, 0xC0, 0x06, 0x00, 0x63, 0x80, 0xE0, 0x07, 0x00, 0x71,
  0xC0, 0x70, 0x03, 0x80, 0x30, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0x60, 0x18,
  0x00, 0xC0, 0x1C, 0x30, 0x0C, 0x00, 0xE0, 0x0C, 0x18, 0x06, 0x00, 0x70,
  0x0E, 0x1C, 0x03, 0x00, 0x78, 0x06, 0x0E, 0x01, 0x80, 0x3C, 0x07, 0x07,
  0x00, 0xC0, 0x36, 0x03, 0x03, 0x80, 0x70, 0x1B, 0x03, 0x81, 0xC0, 0x38,
  0x19, 0x83, 0x80, 0xE0, 0x0E, 0x38, 0xE3, 0x80, 0x70, 0x07, 0xF8, 0x3F,
  0x80, 0x18, 0x00, 0xF8, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x01,
  0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x7C, 0x00,
  0x60, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x7C, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x01, 0xE0, 0x03,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x07, 0xE0, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC3,
  0x80, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x41, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x01, 0x87, 0x80, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x7C, 0x00,
  0x00, 0x03, 0x3F, 0x00, 0x00, 0x00, 0xDD, 0xC0, 0x00, 0x00, 0x76, 0x30,
  0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x06, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0D, 0x80,
  0x00, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x76, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x70, 0x01, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0x00, 0x39, 0x80, 0x0E, 0x70, 0x00,
  0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0x60, 0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x07, 0x0C, 0x00, 0x01,
  0xC3, 0x80, 0x0C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x0E, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x06, 0x07, 0x00, 0x07, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0xC0, 0x30, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x60, 0x07, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x18, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0xE0, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x86, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0xE0, 0x01, 0x80, 0x0E, 0x00,
  0x1D, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x60, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0xD8,
  0x00, 0x00, 0xE0, 0x03, 0x60, 0x00, 0x03, 0x00, 0x1D, 0xC0, 0x00, 0x1C,
  0x00, 0x77, 0x00, 0x00, 0x70, 0x01, 0xCC, 0x00, 0x01, 0xC0, 0x06, 0x30,
  0x00, 0x06, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x00, 0xE3, 0x80, 0x00, 0xE0,
  0x03, 0x86, 0x00, 0x03, 0x80, 0x0E, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x70,
  0x00, 0x30, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x07, 0x03, 0x00, 0x07, 0x00,
  0x1C, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x70, 0x01, 0x80, 0xE0,
  0x01, 0x80, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x01, 0x80,
  0x60, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x30,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0xC0, 0x07, 0x00, 0x03, 0x83,
  0x00, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x00, 0x18, 0x70, 0x01, 0x80,
  0x00, 0x71, 0xC0, 0x06, 0x00, 0x01, 0xC6, 0x00, 0x38, 0x00, 0x07, 0x38,
  0x00, 0xE0, 0x00, 0x0C, 0xE0, 0x03, 0x80, 0x00, 0x3B, 0x80, 0x0C, 0x00,
  0x00, 0xEE, 0x00, 0x30, 0x00, 0x03, 0xB0, 0x01, 0xC0, 0x00, 0x06, 0xC0,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0xF8, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x3C, 0x00, 0x70, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xF0, 0x03, 0x00, 0x07, 0x80, 0x0C, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x30, 0x00, 0x06, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0xCC, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x30, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x83, 0x00,
  0x03, 0x8C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0xC0, 0x07, 0x00, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x1C, 0x0C,
  0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x30, 0x03, 0x80, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x03, 0x00, 0x70, 0x0C, 0x01,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x38,
  0x00, 0xC0, 0x38, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00,
  0x0C, 0x07, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x00,
  0xC0, 0xE0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x1C, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x00, 0xC1,
  0x80, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x31, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0xC7, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x33, 0x80, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xDC, 0x00, 0x03,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x60,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xE0,
  0x0E, 0x00, 0x18, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x31, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x07, 0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x00, 0x07, 0xF0, 0x30, 0x01,
  0xFF, 0x87, 0x00, 0x3E, 0x3C, 0x60, 0x07, 0x00, 0xE6, 0x00, 0xE0, 0x06,
  0x60, 0x1C, 0x00, 0x36, 0x03, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0xD8, 0x07, 0x00, 0x19, 0x80, 0x38, 0x03, 0x38, 0x03, 0xC0, 0xF3,
  0x80, 0x1F, 0xFC, 0x30, 0x00, 0xFF, 0x83, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xFE, 0x00,
  0x0C, 0x3F, 0xF0, 0x01, 0xC7, 0x87, 0x80, 0x1C, 0xE0, 0x1C, 0x01, 0xDC,
  0x01, 0xE0, 0x1B, 0x80, 0x0E, 0x01, 0xB0, 0x00, 0xE0, 0x3E, 0x00, 0x06,
  0x03, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xC0,
  0x6C, 0x00, 0x1C, 0x06, 0xC0, 0x03, 0x80, 0x66, 0x00, 0x70, 0x0E, 0x70,
  0x1E, 0x00, 0xC3, 0xFF, 0xC0, 0x0C, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xC1, 0x80, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x30, 0x00, 0x1F, 0xFC,
  0x70, 0x00, 0x3E, 0x1E, 0x70, 0x00, 0x70, 0x06, 0x70, 0x00, 0xE0, 0x07,
  0x60, 0x01, 0xC0, 0x03, 0x60, 0x03, 0x80, 0x03, 0xE0, 0x03, 0x80, 0x01,
  0xE0, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0xD8, 0x00, 0x70, 0x01, 0x98, 0x00, 0x38, 0x03, 0x98,
  0x00, 0x3C, 0x0F, 0x18, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x0F, 0xF8, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0xC1, 0xC0,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x86, 0x00, 0x0F, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0xF0, 0x60, 0x07, 0xC0, 0xC0, 0x7E, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x02, 0x01, 0xE0, 0x1C,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x1F, 0xFC, 0x30, 0x00,
  0xF8, 0x78, 0xC0, 0x07, 0x80, 0x67, 0x00, 0x38, 0x01, 0xD8, 0x01, 0xC0,
  0x03, 0x60, 0x0E, 0x00, 0x0D, 0x80, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x7C, 0x01, 0x80, 0x01, 0xF0, 0x07,
  0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x76, 0x00, 0x70, 0x01, 0x98, 0x00, 0xE0,
  0x0E, 0xE0, 0x03, 0xC0, 0xF3, 0x80, 0x07, 0xFF, 0x8E, 0x00, 0x0F, 0xF8,
  0x30, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x08, 0x00,
  0x3C, 0x00, 0x30, 0x01, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0xFE, 0x00, 0x30, 0xFF, 0xE0, 0x1C, 0xF8, 0x78, 0x07, 0x70, 0x07, 0x01,
  0xD8, 0x01, 0xC0, 0x6C, 0x00, 0x30, 0x1E, 0x00, 0x0C, 0x0F, 0x80, 0x03,
  0x03, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x67, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x0F, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xCF, 0x80, 0x00,
  0x3B, 0xB8, 0x00, 0x06, 0xE7, 0x00, 0x00, 0xD8, 0xE0, 0x00, 0x3E, 0x0C,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xC1, 0xFC, 0x01, 0xFE,
  0x00, 0x31, 0xFF, 0xC0, 0xFF, 0xC0, 0x1C, 0xF0, 0xF0, 0xF0, 0xF8, 0x06,
  0x70, 0x0E, 0x70, 0x0F, 0x01, 0xB8, 0x03, 0x98, 0x01, 0xC0, 0x6C, 0x00,
  0x6C, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0xC1, 0xFE, 0x00, 0x30, 0xFF, 0xE0, 0x1C, 0xF8,
  0x78, 0x06, 0x78, 0x07, 0x01, 0x98, 0x01, 0xC0, 0x6C, 0x00, 0x30, 0x1E,
  0x00, 0x0C, 0x0F, 0x80, 0x03, 0x03, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xE1, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x06, 0x07, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x1F, 0xC0, 0x00, 0x30, 0xFF, 0xC0, 0x00, 0xE3,
  0xC3, 0xC0, 0x01, 0xCE, 0x01, 0xC0, 0x03, 0x38, 0x03, 0xC0, 0x06, 0xE0,
  0x03, 0x80, 0x0D, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x03, 0x80, 0x1B, 0x00,
  0x0E, 0x00, 0x33, 0x00, 0x78, 0x00, 0xE7, 0x01, 0xE0, 0x01, 0xC7, 0xFF,
  0x80, 0x03, 0x87, 0xFE, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x30,
  0x01, 0xFF, 0xC3, 0x00, 0x7E, 0x3E, 0x30, 0x0F, 0x00, 0xE7, 0x00, 0xE0,
  0x07, 0x60, 0x1C, 0x00, 0x36, 0x03, 0x80, 0x03, 0x60, 0x38, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0xC0,
  0x70, 0x00, 0xDC, 0x07, 0x00, 0x1D, 0x80, 0x38, 0x03, 0xB8, 0x03, 0xC0,
  0xF3, 0x80, 0x1F, 0xFE, 0x38, 0x00, 0xFF, 0x83, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC1, 0xFC,
  0x03, 0x0F, 0xF0, 0x1C, 0xFC, 0x80, 0x67, 0x80, 0x01, 0x98, 0x00, 0x06,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x02, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x80, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFE, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x01, 0xB0, 0x0C, 0x00, 0x76, 0x01, 0xC0, 0x1C,
  0xC0, 0x3C, 0x07, 0x38, 0x03, 0xFF, 0xC6, 0x00, 0x3F, 0xE0, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x00, 0xE0,
  0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x01, 0xB8, 0x00, 0x1C, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00, 0xEE,
  0x00, 0x0F, 0x00, 0x0E, 0x70, 0x00, 0xF8, 0x00, 0x73, 0x80, 0x06, 0xC0,
  0x03, 0x1C, 0x00, 0x76, 0x00, 0x38, 0xE0, 0x03, 0x30, 0x01, 0x87, 0x00,
  0x39, 0x80, 0x1C, 0x38, 0x01, 0xCC, 0x00, 0xE1, 0xC0, 0x0C, 0x60, 0x06,
  0x0E, 0x00, 0xE3, 0x00, 0x70, 0x70, 0x06, 0x18, 0x03, 0x03, 0x80, 0x70,
  0xC0, 0x38, 0x1C, 0x03, 0x06, 0x01, 0xC0, 0xE0, 0x38, 0x30, 0x0C, 0x07,
  0x01, 0x81, 0x80, 0xE0, 0x38, 0x0C, 0x0C, 0x06, 0x01, 0xC0, 0xE0, 0x60,
  0x70, 0x0E, 0x06, 0x03, 0x03, 0x00, 0x30, 0x70, 0x18, 0x38, 0x01, 0x83,
  0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x30, 0xE0,
  0x03, 0x1C, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x0E, 0x70, 0x00, 0xC6, 0x00,
  0x73, 0x80, 0x06, 0x70, 0x03, 0x98, 0x00, 0x33, 0x00, 0x1D, 0xC0, 0x01,
  0xB8, 0x00, 0xEC, 0x00, 0x0D, 0x80, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x27, 0xFF, 0x80, 0x05, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0xFD, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 51, 15, 1, -51 },
  { 97, 16, 19, 21, 7, -51 },
  { 135, 32, 51, 32, 1, -51 },
  { 339, 28, 58, 29, 1, -54 },
  { 542, 36, 52, 43, 4, -51 },
  { 776, 30, 52, 32, 0, -51 },
  { 971, 6, 19, 11, 7, -51 },
  { 986, 20, 62, 17, 2, -51 },
  { 1141, 20, 62, 18, -5, -51 },
  { 1296, 22, 23, 28, 8, -54 },
  { 1360, 27, 32, 32, 3, -41 },
  { 1468, 10, 16, 12, -3, -7 },
  { 1488, 16, 3, 20, 2, -21 },
  { 1494, 5, 5, 13, 1, -5 },
  { 1498, 30, 51, 22, -3, -51 },
  { 1690, 27, 52, 29, 2, -51 },
  { 1866, 15, 51, 29, 9, -51 },
  { 1962, 30, 51, 29, -2, -51 },
  { 2154, 30, 52, 29, -1, -51 },
  { 2349, 30, 51, 29, -1, -51 },
  { 2541, 29, 52, 29, 0, -51 },
  { 2730, 27, 52, 29, 3, -51 },
  { 2906, 27, 51, 29, 4, -51 },
  { 3079, 29, 52, 29, 0, -51 },
  { 3268, 27, 52, 29, 1, -51 },
  { 3444, 11, 38, 13, 1, -38 },
  { 3497, 15, 47, 13, -3, -38 },
  { 3586, 27, 31, 32, 3, -41 },
  { 3691, 27, 18, 32, 3, -34 },
  { 3752, 27, 31, 32, 3, -41 },
  { 3857, 22, 51, 21, 2, -51 },
  { 3998, 41, 57, 44, 2, -51 },
  { 4291, 28, 51, 29, -4, -51 },
  { 4470, 31, 51, 32, 1, -51 },
  { 4668, 31, 52, 30, 4, -51 },
  { 4870, 33, 51, 35, 1, -51 },
  { 5081, 30, 51, 28, 1, -51 },
  { 5273, 30, 51, 26, 1, -51 },
  { 5465, 34, 52, 37, 4, -51 },
  { 5686, 36, 51, 37, 1, -51 },
  { 5916, 23, 51, 15, -3, -51 },
  { 6063, 26, 64, 13, -11, -51 },
  { 6271, 34, 51, 29, 1, -51 },
  { 6488, 19, 51, 26, 1, -51 },
  { 6610, 47, 51, 47, 1, -51 },
  { 6910, 38, 51, 38, 1, -51 },
  { 7153, 33, 52, 38, 3, -51 },
  { 7368, 30, 51, 30, 1, -51 },
  { 7560, 33, 63, 38, 3, -51 },
  { 7820, 30, 51, 30, 1, -51 },
  { 8012, 31, 52, 28, -1, -51 },
  { 8214, 25, 51, 25, 6, -51 },
  { 8374, 34, 52, 36, 3, -51 },
  { 8595, 29, 51, 29, 6, -51 },
  { 8780, 46, 51, 48, 7, -51 },
  { 9074, 35, 51, 26, -4, -51 },
  { 9298, 26, 51, 25, 6, -51 },
  { 9464, 33, 51, 27, -2, -51 },
  { 9675, 26, 62, 20, -1, -51 },
  { 9877, 10, 51, 23, 7, -51 },
  { 9941, 26, 62, 20, -5, -51 },
  { 10143, 28, 27, 31, 2, -51 },
  { 10238, 22, 2, 21, -6, 7 },
  { 10244, 8, 11, 16, 10, -54 },
  { 10255, 28, 39, 31, 2, -38 },
  { 10392, 28, 55, 31, 1, -54 },
  { 10585, 22, 39, 24, 3, -38 },
  { 10693, 32, 55, 31, 2, -54 },
  { 10913, 23, 39, 27, 3, -38 },
  { 11026, 33, 71, 15, -9, -54 },
  { 11319, 30, 55, 31, 0, -38 },
  { 11526, 26, 54, 30, 1, -54 },
  { 11702, 14, 51, 13, 1, -51 },
  { 11792, 25, 68, 13, -10, -51 },
  { 12005, 27, 54, 25, 1, -54 },
  { 12188, 14, 54, 12, 1, -54 },
  { 12283, 42, 38, 46, 1, -38 },
  { 12483, 26, 38, 30, 1, -38 },
  { 12607, 26, 39, 30, 2, -38 },
  { 12734, 31, 54, 31, -2, -38 },
  { 12944, 28, 55, 31, 2, -38 },
  { 13137, 22, 38, 20, 1, -38 },
  { 13242, 24, 39, 23, -1, -38 },
  { 13359, 16, 48, 16, 2, -47 },
  { 13455, 27, 39, 30, 2, -38 },
  { 13587, 23, 38, 23, 4, -38 },
  { 13697, 37, 38, 38, 4, -38 },
  { 13873, 30, 38, 25, -3, -38 },
  { 14016, 36, 55, 24, -8, -38 },
  { 14264, 25, 38, 21, -2, -38 },
  { 14383, 25, 62, 23, 2, -51 },
  { 14577, 2, 71, 29, 14, -54 },
  { 14595, 24, 62, 23, -4, -51 },
  { 14781, 27, 6, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC71PT7B_H_
