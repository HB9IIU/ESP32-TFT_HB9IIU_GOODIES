#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x00, 0x08, 0xC0,
  0x6D, 0x24, 0x92, 0x4A, 0x40, 0x02, 0x60, 0x88, 0x11, 0x02, 0x20, 0x88,
  0x7F, 0xC2, 0x20, 0x48, 0x11, 0x02, 0x20, 0x48, 0x7F, 0xE2, 0x20, 0x44,
  0x11, 0x02, 0x20, 0x44, 0x00, 0x01, 0x00, 0x80, 0xFC, 0x48, 0x22, 0x08,
  0x82, 0x40, 0x50, 0x0C, 0x01, 0x00, 0xA0, 0x24, 0x09, 0x02, 0x40, 0x92,
  0x48, 0x7C, 0x04, 0x01, 0x00, 0x1C, 0x11, 0x21, 0x11, 0x10, 0x88, 0x84,
  0x48, 0x42, 0x42, 0x14, 0x91, 0x2A, 0x8A, 0x8B, 0xA4, 0x41, 0x42, 0x12,
  0x20, 0x91, 0x08, 0x88, 0x44, 0x44, 0x24, 0x41, 0xC0, 0x07, 0x02, 0x20,
  0x88, 0x42, 0x11, 0x04, 0x40, 0xA0, 0x30, 0x14, 0x09, 0x14, 0x45, 0x0A,
  0x82, 0xA0, 0x48, 0x12, 0x0C, 0x7C, 0x80, 0x69, 0x25, 0x00, 0x04, 0x21,
  0x04, 0x20, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x40, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82, 0x0C, 0x00, 0x18, 0x23, 0x41,
  0xF3, 0x09, 0x22, 0x06, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x25, 0x28, 0xF8, 0x70, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x08, 0x88, 0x24, 0x14,
  0x0A, 0x05, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x12, 0x11,
  0x18, 0x78, 0x00, 0x19, 0x55, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x80, 0x0F, 0xC1, 0x08, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0x00, 0x1F, 0x84, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20, 0x18, 0x18,
  0x1E, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0xFC, 0x00,
  0x00, 0xC0, 0x60, 0x18, 0x0A, 0x04, 0x82, 0x20, 0x90, 0x44, 0x21, 0x08,
  0x44, 0x22, 0x08, 0xFF, 0x80, 0x80, 0x20, 0x10, 0x04, 0x00, 0x0F, 0xC4,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0xF8, 0x01, 0x00, 0x40, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00, 0x07, 0x8C, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x30, 0xE4, 0xC1, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x12,
  0x09, 0x08, 0x78, 0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0xC0, 0x00, 0x0F, 0x84, 0x11, 0x04, 0x41, 0x10, 0x44, 0x21, 0x10, 0x38,
  0x1C, 0x08, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x11, 0x0C, 0x7C, 0x00,
  0x0F, 0x84, 0x21, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x21, 0x8F,
  0xA0, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0xF8, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x00, 0x04, 0xC0, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x44, 0x21, 0x10, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x20, 0x00, 0x7C,
  0x04, 0x08, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02, 0x04, 0x00, 0x00,
  0x40, 0x80, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x40, 0x12, 0x00, 0xA1, 0xE5,
  0x11, 0x29, 0x11, 0x88, 0x8C, 0x44, 0x64, 0x23, 0x22, 0x29, 0x11, 0x47,
  0x72, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x30,
  0x14, 0x05, 0x02, 0x40, 0x90, 0x44, 0x11, 0x08, 0x42, 0x11, 0xFC, 0x41,
  0x10, 0x48, 0x12, 0x05, 0x01, 0xC0, 0x40, 0x0F, 0x81, 0x08, 0x40, 0x88,
  0x11, 0x02, 0x20, 0x84, 0x11, 0x1C, 0x3F, 0x04, 0x10, 0x82, 0x10, 0x44,
  0x08, 0x81, 0x10, 0x22, 0x18, 0xFC, 0x00, 0x07, 0xE1, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0x08, 0x40, 0x88,
  0x11, 0x02, 0x20, 0x44, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x24,
  0x04, 0x81, 0x10, 0x42, 0x10, 0xFC, 0x00, 0x0F, 0xC2, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xFE, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xFE, 0x00, 0x0F, 0xE1, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x3F, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x81, 0xE8, 0x24, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x08, 0x40, 0x84, 0x08, 0x3F, 0x80, 0x08, 0x08, 0x40, 0x84, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x84, 0x04, 0x3F, 0xE1, 0x01, 0x08,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x10, 0x80, 0x80, 0x0F,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0xF0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0x00, 0x08, 0x30, 0x84, 0x10, 0xC1, 0x08, 0x11, 0x01,
  0x20, 0x14, 0x02, 0xC0, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04,
  0x20, 0x41, 0x04, 0x10, 0x81, 0x00, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0xFE, 0x08, 0x03, 0x08,
  0x03, 0x14, 0x05, 0x14, 0x06, 0x14, 0x0A, 0x14, 0x0A, 0x14, 0x12, 0x24,
  0x12, 0x24, 0x24, 0x24, 0x24, 0x24, 0x44, 0x44, 0x44, 0x44, 0x84, 0x42,
  0x88, 0x43, 0x08, 0x43, 0x08, 0x82, 0x08, 0x08, 0x08, 0x40, 0x45, 0x02,
  0x28, 0x21, 0x41, 0x0A, 0x08, 0x48, 0x44, 0x44, 0x22, 0x21, 0x11, 0x08,
  0x48, 0x82, 0x44, 0x14, 0x20, 0x61, 0x03, 0x08, 0x18, 0x80, 0xC0, 0x07,
  0xC3, 0x0C, 0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0x0F,
  0x82, 0x11, 0x04, 0x41, 0x10, 0x44, 0x11, 0x04, 0x82, 0x21, 0x0F, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x00, 0x07, 0xC3, 0x0C,
  0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x0F, 0x82, 0x11, 0x04, 0x41, 0x10, 0x44, 0x11, 0x04, 0x82,
  0x23, 0x0F, 0x02, 0x20, 0x88, 0x42, 0x10, 0x84, 0x11, 0x04, 0x81, 0x00,
  0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00, 0xFF, 0x84,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x00, 0x10, 0x12, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x22, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x88, 0x08,
  0x80, 0x88, 0x08, 0x81, 0x04, 0x20, 0x7C, 0x00, 0x80, 0xE0, 0x28, 0x0A,
  0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x22, 0x08, 0x81, 0x40, 0x50,
  0x14, 0x06, 0x01, 0x80, 0x40, 0x00, 0x81, 0x81, 0x81, 0x82, 0x81, 0x82,
  0x82, 0x84, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88, 0x90,
  0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xA0, 0xC0,
  0xC0, 0x80, 0xC0, 0x80, 0x08, 0x30, 0x82, 0x08, 0x40, 0x88, 0x04, 0x80,
  0x50, 0x06, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x20, 0x22, 0x02,
  0x10, 0x41, 0x04, 0x10, 0x81, 0x00, 0x81, 0xC0, 0xA0, 0x88, 0x44, 0x42,
  0x41, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x00, 0x0F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xFF, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x84,
  0x44, 0x44, 0x42, 0x22, 0x22, 0x22, 0x11, 0x10, 0x07, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x04, 0x06, 0x04, 0x82,
  0x42, 0x21, 0x09, 0x04, 0x81, 0x80, 0x80, 0xFE, 0xC8, 0x80, 0x0E, 0x98,
  0xC8, 0x68, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x90, 0xC7,
  0xA0, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x05, 0xC1, 0x88, 0x41, 0x30,
  0x48, 0x12, 0x04, 0x82, 0x40, 0x90, 0x24, 0x09, 0x04, 0x62, 0x2F, 0x00,
  0x0E, 0x60, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x83, 0xA3, 0x18, 0x86, 0x41, 0x90,
  0x48, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x18, 0x86, 0x1E, 0x80, 0x0E,
  0x31, 0x21, 0x41, 0x42, 0x84, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C,
  0x00, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x20, 0x1F, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x06, 0x00, 0x07, 0x46, 0x31,
  0x0C, 0x83, 0x20, 0x90, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x31, 0x0C,
  0x3D, 0x00, 0x80, 0x20, 0x08, 0x04, 0x23, 0x07, 0x00, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0xB8, 0x62, 0x21, 0x30, 0x90, 0x48, 0x24, 0x14, 0x12,
  0x09, 0x04, 0x82, 0x41, 0x41, 0x00, 0x08, 0x40, 0x01, 0x08, 0x84, 0x21,
  0x08, 0x84, 0x21, 0x08, 0x80, 0x01, 0x01, 0x00, 0x00, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x84, 0x44,
  0x44, 0x22, 0x12, 0x0A, 0x07, 0x06, 0x42, 0x21, 0x10, 0x88, 0x42, 0x41,
  0x00, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x00, 0x17, 0x3C, 0x31, 0x88, 0xC3, 0x09, 0x04, 0x12, 0x08, 0x44, 0x10,
  0x88, 0x41, 0x20, 0x82, 0x41, 0x08, 0x82, 0x11, 0x08, 0x22, 0x10, 0x48,
  0x20, 0x80, 0x17, 0x0C, 0x4C, 0x26, 0x12, 0x09, 0x04, 0x82, 0x82, 0x41,
  0x20, 0x90, 0x48, 0x28, 0x20, 0x0E, 0x31, 0x21, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x0B, 0x81, 0x88, 0x60, 0x8C, 0x11,
  0x02, 0x20, 0x44, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x18, 0x85, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x00, 0x0E, 0x98, 0xC8,
  0x68, 0x34, 0x14, 0x0A, 0x05, 0x02, 0x83, 0x41, 0x21, 0x90, 0xC7, 0xA0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x17, 0x18, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1E, 0x21, 0x20, 0x40,
  0x20, 0x20, 0x18, 0x08, 0x04, 0x04, 0x04, 0x04, 0xF8, 0x11, 0x09, 0xF2,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x1C, 0x20, 0x90, 0x50, 0x48, 0x24,
  0x12, 0x09, 0x05, 0x04, 0x82, 0x41, 0x21, 0x91, 0x4F, 0x40, 0x81, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x48, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x82,
  0x0C, 0x10, 0xA1, 0x85, 0x0C, 0x28, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x48,
  0x92, 0x85, 0x14, 0x28, 0xA0, 0x82, 0x04, 0x10, 0x00, 0x10, 0x44, 0x21,
  0x10, 0x24, 0x0A, 0x03, 0x00, 0x40, 0x30, 0x14, 0x08, 0x82, 0x21, 0x08,
  0x82, 0x00, 0x04, 0x10, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04,
  0x80, 0x48, 0x05, 0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0F, 0xC0, 0x07, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x0C, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0x0C, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x30, 0x66, 0x60, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 17, 5, 0, -17 },
  { 12, 6, 6, 7, 2, -17 },
  { 17, 11, 17, 11, 0, -17 },
  { 41, 10, 19, 10, 0, -18 },
  { 65, 13, 17, 15, 1, -17 },
  { 93, 10, 17, 11, 0, -17 },
  { 115, 3, 6, 4, 2, -17 },
  { 118, 6, 21, 6, 1, -17 },
  { 134, 7, 21, 6, -2, -17 },
  { 153, 7, 8, 9, 3, -18 },
  { 160, 9, 11, 11, 1, -14 },
  { 173, 3, 5, 4, -1, -2 },
  { 175, 5, 1, 7, 1, -7 },
  { 176, 2, 2, 4, 0, -2 },
  { 177, 10, 17, 7, -1, -17 },
  { 199, 9, 17, 10, 1, -17 },
  { 219, 5, 17, 10, 3, -17 },
  { 230, 11, 17, 10, -1, -17 },
  { 254, 10, 17, 10, 0, -17 },
  { 276, 10, 17, 10, 0, -17 },
  { 298, 10, 17, 10, 0, -17 },
  { 320, 9, 17, 10, 1, -17 },
  { 340, 10, 17, 10, 1, -17 },
  { 362, 10, 17, 10, 0, -17 },
  { 384, 10, 17, 10, 0, -17 },
  { 406, 4, 13, 4, 0, -13 },
  { 413, 5, 16, 4, -1, -13 },
  { 423, 9, 11, 11, 1, -14 },
  { 436, 9, 5, 11, 1, -11 },
  { 442, 9, 11, 11, 1, -14 },
  { 455, 7, 17, 7, 1, -17 },
  { 470, 13, 19, 15, 1, -17 },
  { 501, 10, 17, 10, -2, -17 },
  { 523, 11, 17, 11, 0, -17 },
  { 547, 11, 17, 10, 1, -17 },
  { 571, 11, 17, 12, 0, -17 },
  { 595, 10, 17, 10, 0, -17 },
  { 617, 11, 17, 9, 0, -17 },
  { 641, 12, 17, 13, 1, -17 },
  { 667, 13, 17, 12, 0, -17 },
  { 695, 8, 17, 5, -1, -17 },
  { 712, 9, 21, 4, -4, -17 },
  { 736, 12, 17, 10, 0, -17 },
  { 762, 7, 17, 9, 0, -17 },
  { 777, 16, 17, 16, 0, -17 },
  { 811, 13, 17, 13, 0, -17 },
  { 839, 11, 17, 13, 1, -17 },
  { 863, 10, 17, 10, 0, -17 },
  { 885, 11, 21, 13, 1, -17 },
  { 914, 10, 17, 10, 0, -17 },
  { 936, 10, 17, 9, 0, -17 },
  { 958, 9, 17, 9, 2, -17 },
  { 978, 12, 17, 12, 1, -17 },
  { 1004, 10, 17, 10, 2, -17 },
  { 1026, 16, 17, 16, 2, -17 },
  { 1060, 12, 17, 9, -1, -17 },
  { 1086, 9, 17, 9, 2, -17 },
  { 1106, 11, 17, 9, -1, -17 },
  { 1130, 8, 21, 7, 0, -17 },
  { 1151, 4, 17, 8, 2, -17 },
  { 1160, 9, 21, 7, -2, -17 },
  { 1184, 9, 9, 11, 1, -17 },
  { 1195, 7, 1, 7, -2, 2 },
  { 1196, 3, 3, 5, 3, -18 },
  { 1198, 9, 13, 10, 1, -13 },
  { 1213, 10, 18, 11, 0, -18 },
  { 1236, 7, 13, 8, 1, -13 },
  { 1248, 10, 18, 11, 1, -18 },
  { 1271, 8, 13, 9, 1, -13 },
  { 1284, 11, 24, 5, -3, -18 },
  { 1317, 10, 19, 11, 0, -13 },
  { 1341, 9, 18, 10, 0, -18 },
  { 1362, 5, 17, 4, 0, -17 },
  { 1373, 8, 23, 4, -3, -17 },
  { 1396, 9, 18, 8, 0, -18 },
  { 1417, 5, 18, 4, 0, -18 },
  { 1429, 15, 13, 16, 0, -13 },
  { 1454, 9, 13, 10, 0, -13 },
  { 1469, 8, 13, 10, 1, -13 },
  { 1482, 11, 19, 11, -1, -13 },
  { 1509, 9, 19, 11, 1, -13 },
  { 1531, 8, 13, 7, 0, -13 },
  { 1544, 8, 13, 8, 0, -13 },
  { 1557, 5, 16, 6, 1, -16 },
  { 1567, 9, 13, 10, 1, -13 },
  { 1582, 8, 13, 8, 1, -13 },
  { 1595, 13, 13, 13, 1, -13 },
  { 1617, 10, 13, 8, -1, -13 },
  { 1634, 12, 19, 8, -3, -13 },
  { 1663, 9, 13, 7, -1, -13 },
  { 1678, 8, 21, 8, 1, -17 },
  { 1699, 1, 24, 10, 5, -18 },
  { 1702, 8, 21, 8, -1, -17 },
  { 1723, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC24PT7B_H_
