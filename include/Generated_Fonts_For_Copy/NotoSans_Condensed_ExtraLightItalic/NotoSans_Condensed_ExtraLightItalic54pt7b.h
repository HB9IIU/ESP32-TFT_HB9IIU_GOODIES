#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x31, 0x83, 0x18, 0x33,
  0x06, 0x30, 0x63, 0x06, 0x30, 0x63, 0x04, 0x60, 0xC6, 0x0C, 0x60, 0xC6,
  0x0C, 0x40, 0x8C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x20, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x80, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xB3, 0xC0, 0x70, 0xC1, 0x01,
  0x82, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04,
  0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x0E, 0x20, 0x00, 0x1C, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x05, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x03, 0x07, 0x00, 0x0C,
  0x18, 0x20, 0x30, 0xC0, 0xF8, 0x9E, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x7F, 0x00, 0x18, 0x0E, 0x18, 0x01,
  0x80, 0xC1, 0x80, 0x30, 0x18, 0x18, 0x02, 0x01, 0x81, 0x80, 0x60, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x18, 0x30, 0x06, 0x01, 0x83, 0x00, 0x60, 0x30, 0x60, 0x0C,
  0x03, 0x0C, 0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x03, 0x18, 0x10, 0xC0, 0x61,
  0x8F, 0xCC, 0x06, 0x31, 0xCE, 0xC0, 0x63, 0x38, 0x6C, 0x0C, 0x63, 0x02,
  0xC1, 0x8C, 0x60, 0x26, 0x18, 0xC6, 0x03, 0x7F, 0x18, 0xC0, 0x23, 0xE1,
  0x8C, 0x02, 0x00, 0x30, 0xC0, 0x60, 0x03, 0x18, 0x06, 0x00, 0x61, 0x80,
  0x60, 0x0C, 0x18, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x18, 0x0C, 0x01,
  0x81, 0x80, 0xC0, 0x30, 0x10, 0x0C, 0x03, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x18, 0x0C, 0x01, 0x01, 0x80, 0xC0, 0x10, 0x30, 0x18, 0x01, 0x87, 0x01,
  0x80, 0x1C, 0xE0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x80, 0x06, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x73, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x39, 0x80, 0x00, 0xE3,
  0x00, 0x03, 0x86, 0x01, 0x8E, 0x06, 0x06, 0x18, 0x0C, 0x0C, 0x60, 0x0C,
  0x31, 0xC0, 0x18, 0x63, 0x00, 0x31, 0xC6, 0x00, 0x33, 0x0C, 0x00, 0x6E,
  0x30, 0x00, 0x78, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x81,
  0x80, 0x0F, 0x03, 0x00, 0x33, 0x07, 0x01, 0xC6, 0x07, 0x8F, 0x0E, 0x07,
  0xF8, 0x0C, 0x00, 0x80, 0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x23, 0x18,
  0xC4, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x04, 0x0C, 0x07, 0x06, 0x00, 0xE3, 0x00, 0x1D, 0x07, 0x03, 0xFF,
  0x80, 0xC0, 0x00, 0xF0, 0x00, 0xC8, 0x01, 0xC6, 0x01, 0xC1, 0x01, 0xC0,
  0xC0, 0x40, 0x20, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x06,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00,
  0xE0, 0xC0, 0x1C, 0x06, 0x03, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x33, 0x00, 0x07, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x80,
  0x70, 0x70, 0x03, 0xDE, 0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x1C, 0x0F, 0x03, 0xE0, 0xEC, 0x71, 0x9C, 0x37, 0x0C, 0x41, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xC0,
  0xE0, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x80, 0x1E, 0x07, 0x00, 0xE0, 0x06, 0x01, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x80, 0x1E, 0x03, 0xC1, 0xF0, 0x07, 0xFF, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x27, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0D, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x40, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x80, 0x1E, 0x03, 0xC3, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x0F, 0x00,
  0x31, 0xFE, 0x01, 0xBC, 0x38, 0x1B, 0x00, 0xE0, 0xD0, 0x03, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x18,
  0x01, 0x80, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x1E, 0x7C, 0x00, 0x7F, 0x80,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0x03, 0x80, 0x30, 0x06, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0x30, 0x38, 0x00, 0xE3, 0x80, 0x01, 0xDC, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xCE, 0x00, 0x1C, 0x1C, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0x60, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00,
  0x60, 0x38, 0x07, 0x00, 0x7C, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x78, 0x38, 0x03, 0x00, 0xC0, 0x30,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x86,
  0x00, 0x3C, 0x30, 0x01, 0x41, 0xC0, 0x1E, 0x07, 0x03, 0xB0, 0x1F, 0xF9,
  0x80, 0x7F, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x63, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x02, 0x07, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0xE0, 0xC0, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1C,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x1C, 0x03, 0x0C, 0x03,
  0xFE, 0x0C, 0x60, 0x1C, 0x10, 0x31, 0x80, 0xC0, 0xC0, 0xCC, 0x07, 0x03,
  0x03, 0x30, 0x18, 0x0C, 0x0C, 0xC0, 0xC0, 0x20, 0x36, 0x03, 0x01, 0x80,
  0xD8, 0x18, 0x06, 0x03, 0x60, 0x60, 0x18, 0x0D, 0x81, 0x00, 0xC0, 0x64,
  0x0C, 0x03, 0x01, 0xB0, 0x30, 0x0C, 0x06, 0xC0, 0xC0, 0x30, 0x33, 0x03,
  0x01, 0x80, 0xCC, 0x0C, 0x06, 0x03, 0x30, 0x30, 0x38, 0x18, 0xC0, 0xC0,
  0xA0, 0x63, 0x03, 0x06, 0x83, 0x0C, 0x0C, 0x33, 0x18, 0x30, 0x1F, 0x8F,
  0xC0, 0xC0, 0x3C, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x40, 0x07, 0x02, 0x00, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x3F,
  0xFF, 0x03, 0x80, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30,
  0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0x03, 0xE0, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x18, 0x07, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x1C,
  0x0C, 0x00, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x18, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x30, 0x7E, 0x00, 0x30, 0x07, 0x80, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x01, 0xE0, 0x0C, 0x03, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x02, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0xFE, 0x30, 0x00, 0xFF, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0xE3, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x07, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x33, 0xC0, 0x07, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x36, 0xC0, 0x00, 0x0F, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x1C,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x34, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x68,
  0x00, 0x01, 0xB0, 0x0D, 0x80, 0x00, 0x36, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x66, 0x00, 0x01, 0xB0, 0x0C, 0xC0, 0x00, 0x66, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x63, 0x00, 0x03, 0x18, 0x0C, 0x60, 0x00, 0x63, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x31, 0x80, 0x07, 0x18, 0x06, 0x30, 0x00, 0xC3, 0x01, 0x86,
  0x00, 0x38, 0x60, 0x30, 0x40, 0x06, 0x1C, 0x06, 0x0C, 0x01, 0xC3, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x18, 0x30, 0x0E, 0x0C, 0x06, 0x06, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x18, 0x06, 0x03, 0x01,
  0x83, 0x01, 0x80, 0x60, 0x30, 0xC0, 0x30, 0x0C, 0x02, 0x18, 0x06, 0x03,
  0x00, 0x66, 0x00, 0xC0, 0x60, 0x0C, 0xC0, 0x18, 0x0C, 0x01, 0xB0, 0x06,
  0x01, 0x80, 0x36, 0x00, 0xC0, 0x30, 0x07, 0x80, 0x18, 0x0C, 0x00, 0xF0,
  0x03, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x1E, 0x00,
  0x03, 0x01, 0xE0, 0x00, 0x30, 0x1B, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x60,
  0x1B, 0x00, 0x06, 0x03, 0x30, 0x00, 0x60, 0x31, 0x80, 0x0C, 0x03, 0x18,
  0x00, 0xC0, 0x31, 0x80, 0x0C, 0x06, 0x18, 0x00, 0xC0, 0x60, 0xC0, 0x0C,
  0x06, 0x0C, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x06, 0x0C, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x30, 0x18, 0x03, 0x03, 0x01, 0x80, 0x30, 0x70, 0x18,
  0x03, 0x06, 0x01, 0x80, 0x18, 0x60, 0x38, 0x01, 0x86, 0x03, 0x00, 0x18,
  0x60, 0x30, 0x01, 0x8C, 0x03, 0x00, 0x0C, 0xC0, 0x30, 0x00, 0xCC, 0x06,
  0x00, 0x0C, 0xC0, 0x60, 0x00, 0xCC, 0x06, 0x00, 0x07, 0x80, 0x60, 0x00,
  0x78, 0x06, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x06, 0x03, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0C, 0x3F,
  0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06, 0x00, 0x70, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x70, 0x0C,
  0x07, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x06, 0x03, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0C, 0x3F,
  0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0x81, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x78,
  0x0E, 0x00, 0xE0, 0x02, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x1C, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x98, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0xC0,
  0xC0, 0x0C, 0x02, 0x00, 0xE0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0D, 0x80,
  0x03, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x18,
  0xC0, 0x06, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0xE3, 0x00, 0x19, 0x80,
  0x18, 0x60, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0x30,
  0xC0, 0x18, 0x30, 0x06, 0x18, 0x07, 0x06, 0x00, 0xC3, 0x00, 0xC0, 0xC0,
  0x30, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x30, 0x30, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x61, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0x61,
  0x80, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0xCC, 0x00, 0x39, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x60,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x1C, 0x03, 0x03, 0x00, 0x60,
  0xE0, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCE,
  0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60,
  0xC1, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x18, 0x1C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x0C,
  0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x00, 0x7E, 0x18, 0x0F,
  0xF8, 0xC0, 0xE0, 0x64, 0x0E, 0x01, 0x60, 0x60, 0x0F, 0x06, 0x00, 0x78,
  0x70, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07,
  0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xE0, 0xC0,
  0x0B, 0x03, 0x00, 0xD0, 0x1C, 0x0D, 0x80, 0x7B, 0xCC, 0x01, 0xFC, 0x60,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0xF8, 0x03, 0x1F, 0xF0, 0x19, 0xC1, 0x80, 0xD8, 0x06, 0x07, 0x80, 0x30,
  0x38, 0x01, 0xC3, 0xC0, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x05, 0x00, 0x30, 0x6C, 0x03, 0x83, 0x60, 0x38, 0x19, 0xE7, 0x80,
  0x87, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xE0,
  0x20, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x8E, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7E,
  0x18, 0x01, 0xFF, 0x18, 0x03, 0x81, 0x98, 0x07, 0x00, 0xF0, 0x06, 0x00,
  0xF0, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x38, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03,
  0x80, 0xC0, 0x07, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x0F,
  0x00, 0x60, 0x1B, 0x00, 0x70, 0x33, 0x00, 0x3C, 0xE2, 0x00, 0x1F, 0xC6,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C,
  0x06, 0x06, 0x01, 0x83, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x38, 0x60, 0x3C, 0x18, 0x7C, 0x0F,
  0xFC, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x40, 0xF9, 0xE0, 0x1F, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x86, 0x00,
  0xFF, 0x8C, 0x03, 0x81, 0x98, 0x0E, 0x01, 0xA0, 0x18, 0x03, 0xC0, 0x60,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x3C, 0x0C,
  0x00, 0x70, 0x18, 0x01, 0xE0, 0x30, 0x03, 0xC0, 0x30, 0x0D, 0x80, 0x60,
  0x32, 0x00, 0x79, 0xCC, 0x00, 0x7F, 0x18, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x20, 0x06, 0x00,
  0x60, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x0F, 0x80, 0x23, 0xFE, 0x06, 0x60, 0x60, 0x6C,
  0x07, 0x07, 0x80, 0x30, 0x70, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x70,
  0x06, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x60, 0x70, 0x0C,
  0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x01,
  0x8E, 0x00, 0x19, 0xC0, 0x01, 0x9E, 0x00, 0x1B, 0x60, 0x01, 0x66, 0x00,
  0x3C, 0x60, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x02, 0x1F, 0x80, 0xF8, 0x06, 0x3F, 0xC3, 0xFE, 0x06, 0x60, 0xC6,
  0x0E, 0x06, 0x80, 0x6C, 0x07, 0x07, 0x80, 0x78, 0x03, 0x07, 0x00, 0x70,
  0x03, 0x0E, 0x00, 0x70, 0x03, 0x0E, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60,
  0x06, 0x0C, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x06, 0x1C, 0x00, 0xC0,
  0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x18, 0x01, 0xC0,
  0x0C, 0x18, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80,
  0x0C, 0x30, 0x01, 0x80, 0x18, 0x30, 0x03, 0x00, 0x18, 0x70, 0x03, 0x00,
  0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x30, 0x60, 0x03, 0x00,
  0x30, 0x60, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00,
  0x30, 0xC0, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0x60, 0x02, 0x1F, 0x80,
  0x63, 0xFE, 0x06, 0x60, 0x60, 0x6C, 0x07, 0x07, 0x80, 0x30, 0x70, 0x03,
  0x0F, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xC3, 0x80,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x70,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x80, 0x60, 0xE0, 0x0E, 0x18, 0x00,
  0xC7, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x01, 0x81,
  0xC0, 0x70, 0x1E, 0x78, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x41,
  0xF0, 0x00, 0x47, 0xFC, 0x00, 0xCE, 0x0C, 0x00, 0xD8, 0x06, 0x00, 0xF0,
  0x06, 0x00, 0xF0, 0x07, 0x01, 0xE0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00,
  0x70, 0x1B, 0x00, 0xE0, 0x1B, 0x01, 0xC0, 0x19, 0xC7, 0x80, 0x18, 0xFE,
  0x00, 0x18, 0x38, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x18, 0x0F, 0xF8, 0xC0, 0xE0, 0x66, 0x0E, 0x01, 0xA0,
  0x60, 0x0F, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x03, 0xC3, 0x00,
  0x1C, 0x18, 0x01, 0xE0, 0xC0, 0x0F, 0x03, 0x00, 0xD8, 0x18, 0x0C, 0xC0,
  0x79, 0xCC, 0x01, 0xFC, 0x60, 0x02, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x1F, 0x06, 0x3F, 0x06, 0x60, 0x06, 0xC0,
  0x07, 0x80, 0x05, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x70, 0x18, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x08, 0x03, 0x83, 0xC3, 0xC0, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xE7, 0xFE, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x88, 0x0F, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x1E, 0x0C,
  0x03, 0x60, 0xE0, 0x76, 0x07, 0x1C, 0x40, 0x3F, 0x8C, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x08,
  0x06, 0x06, 0x06, 0x03, 0x03, 0x01, 0x83, 0x80, 0xC1, 0x80, 0x61, 0xC0,
  0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00,
  0x6C, 0x00, 0xE0, 0x06, 0xC0, 0x0A, 0x00, 0xCC, 0x01, 0xA0, 0x0C, 0xC0,
  0x1A, 0x01, 0xCC, 0x03, 0x20, 0x18, 0xC0, 0x32, 0x01, 0x8C, 0x06, 0x20,
  0x30, 0xC0, 0x62, 0x03, 0x0C, 0x0C, 0x30, 0x60, 0xC0, 0xC3, 0x06, 0x0C,
  0x08, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x0C, 0x18, 0x30, 0xC0, 0xC3, 0x03,
  0x18, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x00,
  0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xCC, 0x03, 0x60, 0x05, 0x80,
  0x34, 0x00, 0x58, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x60, 0x18, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x03,
  0x80, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0x60, 0x03,
  0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0xC0, 0x03, 0x80, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x20, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x40, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x00,
  0x5C, 0x7C, 0x07, 0x80, 0x7D, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 39, 11, 1, -39 },
  { 55, 12, 14, 16, 5, -39 },
  { 76, 24, 39, 24, 1, -39 },
  { 193, 22, 44, 22, 0, -41 },
  { 314, 28, 40, 33, 3, -39 },
  { 454, 23, 40, 24, 0, -39 },
  { 569, 5, 14, 9, 5, -39 },
  { 578, 16, 47, 13, 1, -38 },
  { 672, 15, 47, 13, -4, -38 },
  { 761, 17, 18, 21, 6, -41 },
  { 800, 21, 25, 25, 2, -32 },
  { 866, 7, 12, 9, -2, -5 },
  { 877, 12, 2, 15, 1, -16 },
  { 880, 3, 4, 10, 1, -4 },
  { 882, 22, 39, 16, -2, -39 },
  { 990, 20, 40, 22, 2, -39 },
  { 1090, 11, 39, 22, 7, -39 },
  { 1144, 23, 39, 22, -1, -39 },
  { 1257, 22, 40, 22, 0, -39 },
  { 1367, 23, 39, 22, -1, -39 },
  { 1480, 22, 40, 22, 0, -39 },
  { 1590, 21, 40, 22, 2, -39 },
  { 1695, 21, 39, 22, 3, -39 },
  { 1798, 22, 40, 22, 0, -39 },
  { 1908, 21, 40, 22, 1, -39 },
  { 2013, 8, 29, 10, 1, -29 },
  { 2042, 11, 36, 10, -2, -29 },
  { 2092, 21, 23, 25, 2, -31 },
  { 2153, 21, 14, 25, 2, -26 },
  { 2190, 21, 23, 25, 2, -31 },
  { 2251, 16, 39, 16, 2, -39 },
  { 2329, 30, 44, 33, 2, -39 },
  { 2494, 21, 39, 22, -3, -39 },
  { 2597, 23, 39, 24, 1, -39 },
  { 2710, 23, 40, 23, 3, -39 },
  { 2825, 25, 39, 27, 1, -39 },
  { 2947, 23, 39, 22, 1, -39 },
  { 3060, 23, 39, 20, 1, -39 },
  { 3173, 26, 40, 29, 3, -39 },
  { 3303, 28, 39, 28, 1, -39 },
  { 3440, 17, 39, 12, -2, -39 },
  { 3523, 19, 49, 10, -8, -39 },
  { 3640, 26, 39, 22, 1, -39 },
  { 3767, 14, 39, 20, 1, -39 },
  { 3836, 35, 39, 36, 1, -39 },
  { 4007, 28, 39, 29, 1, -39 },
  { 4144, 24, 40, 29, 3, -39 },
  { 4264, 22, 39, 23, 1, -39 },
  { 4372, 24, 48, 29, 3, -39 },
  { 4516, 22, 39, 23, 1, -39 },
  { 4624, 24, 40, 21, -1, -39 },
  { 4744, 19, 39, 19, 5, -39 },
  { 4837, 25, 40, 28, 3, -39 },
  { 4962, 21, 39, 22, 5, -39 },
  { 5065, 35, 39, 37, 5, -39 },
  { 5236, 27, 39, 20, -3, -39 },
  { 5368, 19, 39, 19, 5, -39 },
  { 5461, 25, 39, 20, -2, -39 },
  { 5583, 20, 48, 15, -1, -39 },
  { 5703, 7, 39, 17, 6, -39 },
  { 5738, 20, 48, 15, -4, -39 },
  { 5858, 21, 21, 24, 2, -39 },
  { 5914, 16, 2, 16, -4, 5 },
  { 5918, 6, 8, 12, 8, -41 },
  { 5924, 21, 30, 24, 2, -29 },
  { 6003, 21, 42, 24, 1, -41 },
  { 6114, 17, 30, 18, 2, -29 },
  { 6178, 24, 42, 24, 2, -41 },
  { 6304, 18, 30, 21, 2, -29 },
  { 6372, 26, 54, 12, -7, -41 },
  { 6548, 23, 42, 24, 0, -29 },
  { 6669, 20, 41, 23, 1, -41 },
  { 6772, 10, 39, 10, 1, -39 },
  { 6821, 18, 52, 10, -7, -39 },
  { 6938, 20, 41, 19, 1, -41 },
  { 7041, 10, 41, 9, 1, -41 },
  { 7093, 32, 29, 35, 1, -29 },
  { 7209, 20, 29, 23, 1, -29 },
  { 7282, 19, 30, 23, 2, -29 },
  { 7354, 24, 41, 24, -2, -29 },
  { 7477, 21, 42, 24, 2, -29 },
  { 7588, 16, 29, 15, 1, -29 },
  { 7646, 18, 30, 18, 0, -29 },
  { 7714, 13, 36, 12, 1, -35 },
  { 7773, 20, 30, 23, 2, -29 },
  { 7848, 17, 29, 18, 3, -29 },
  { 7910, 28, 29, 29, 3, -29 },
  { 8012, 22, 29, 19, -2, -29 },
  { 8092, 27, 42, 18, -6, -29 },
  { 8234, 19, 29, 16, -2, -29 },
  { 8303, 18, 48, 17, 2, -39 },
  { 8411, 2, 54, 22, 10, -41 },
  { 8425, 19, 48, 17, -3, -39 },
  { 8539, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC54PT7B_H_
