#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC69PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x31, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x38, 0xE0, 0x71, 0x80, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x38, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x78, 0x60, 0xE0, 0x0F, 0x06, 0x02, 0x01, 0xC0,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0x7B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0xF0, 0x00,
  0x00, 0xC7, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x70,
  0x0C, 0x06, 0x1E, 0x00, 0xFC, 0x6F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x60,
  0x0F, 0x3C, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x03, 0x00, 0x60, 0x30, 0x00,
  0xE0, 0x1C, 0x06, 0x00, 0x18, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x70, 0x07, 0x00, 0x30, 0x0C, 0x00,
  0xE0, 0x06, 0x03, 0x80, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0x38, 0x18,
  0x00, 0x60, 0x07, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0x18,
  0x38, 0x00, 0x70, 0x07, 0x06, 0x00, 0x0C, 0x00, 0xE1, 0xC1, 0xF1, 0x80,
  0x18, 0x70, 0xFF, 0x30, 0x07, 0x0C, 0x3C, 0x76, 0x00, 0xC3, 0x86, 0x06,
  0xC0, 0x38, 0x61, 0xC0, 0xFC, 0x06, 0x1C, 0x70, 0x0F, 0x81, 0xC3, 0x0C,
  0x01, 0xB0, 0x70, 0xE3, 0x80, 0x37, 0x9C, 0x38, 0x60, 0x06, 0x7F, 0x06,
  0x0C, 0x00, 0xC7, 0xC1, 0xC3, 0x80, 0x38, 0x00, 0x30, 0x60, 0x07, 0x00,
  0x0E, 0x0C, 0x00, 0xE0, 0x01, 0x83, 0x80, 0x18, 0x00, 0x70, 0x70, 0x03,
  0x00, 0x1C, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0x18, 0x06, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x1C, 0x03, 0x80, 0x70, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x30, 0x1C,
  0x03, 0x80, 0x06, 0x07, 0x00, 0x60, 0x00, 0xE0, 0xC0, 0x1C, 0x00, 0x1F,
  0xF8, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x38, 0x03, 0x83, 0x80, 0xC0, 0x1C,
  0x38, 0x07, 0x00, 0xC3, 0x80, 0x38, 0x0E, 0x1C, 0x00, 0xE0, 0x71, 0xC0,
  0x07, 0x03, 0x0C, 0x00, 0x18, 0x38, 0xE0, 0x00, 0xE1, 0x87, 0x00, 0x07,
  0x1C, 0x30, 0x00, 0x1D, 0xC1, 0x80, 0x00, 0xEE, 0x1C, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0x7C, 0x07, 0x00, 0x07, 0x70, 0x38, 0x00, 0x73, 0x81, 0xE0, 0x07,
  0x0C, 0x07, 0x80, 0xF0, 0x70, 0x1F, 0xFF, 0x03, 0x80, 0x7F, 0xE0, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC6,
  0x18, 0x61, 0x86, 0x30, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x20, 0x18, 0x03, 0xC0, 0xC0, 0x0F, 0x06, 0x00, 0x1E, 0x30, 0x08, 0x3D,
  0x07, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00,
  0x1C, 0x60, 0x01, 0xC3, 0x00, 0x1C, 0x0C, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0x80, 0x40, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x06,
  0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0xF6,
  0x07, 0xB8, 0x3C, 0xE3, 0xC3, 0x1E, 0x0C, 0xF0, 0x73, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF1, 0xF0, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x10, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x02, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x60, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE7, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0x30,
  0xFF, 0xE0, 0x06, 0x7C, 0x1E, 0x01, 0xDC, 0x01, 0xE0, 0x3B, 0x00, 0x1C,
  0x06, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x38, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38,
  0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x3B, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07,
  0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x83, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xB0,
  0x1C, 0x00, 0x6E, 0x03, 0xC0, 0x3D, 0xC0, 0x3E, 0x3E, 0x30, 0x03, 0xFF,
  0x86, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x04, 0x01,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0C, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x03,
  0xFE, 0x01, 0x83, 0x80, 0x1F, 0xFE, 0x03, 0x06, 0x00, 0x78, 0x18, 0x06,
  0x1C, 0x01, 0xC0, 0x30, 0x0C, 0x30, 0x07, 0x00, 0xE0, 0x18, 0xE0, 0x0C,
  0x01, 0x80, 0x31, 0xC0, 0x38, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0E, 0x00,
  0xCE, 0x01, 0xC0, 0x1C, 0x03, 0x9C, 0x03, 0x00, 0x30, 0x07, 0x30, 0x0E,
  0x00, 0x60, 0x0C, 0x60, 0x18, 0x01, 0xC0, 0x19, 0xC0, 0x30, 0x03, 0x80,
  0x33, 0x80, 0xE0, 0x06, 0x00, 0xE6, 0x01, 0x80, 0x0C, 0x01, 0x8C, 0x03,
  0x00, 0x38, 0x03, 0x18, 0x06, 0x00, 0x70, 0x0E, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x60, 0x38, 0x03, 0x80, 0x31, 0xC0, 0x70, 0x07, 0x00, 0xE3, 0x80,
  0xE0, 0x1E, 0x01, 0x87, 0x01, 0xC0, 0x3C, 0x07, 0x0E, 0x01, 0x80, 0xD8,
  0x1C, 0x1C, 0x03, 0x03, 0xB0, 0x30, 0x38, 0x07, 0x0E, 0x71, 0xC0, 0x70,
  0x07, 0xF8, 0x7F, 0x80, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x10, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0xE0, 0x06, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3E, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x30, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x60, 0x03, 0xE0, 0x00,
  0x60, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x07, 0x00,
  0x01, 0xFF, 0xC1, 0xC0, 0x00, 0xFF, 0xF0, 0x60, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0xC3, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x06, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x60, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0C, 0xF8, 0x00,
  0x00, 0x0E, 0x7C, 0x00, 0x00, 0x07, 0x77, 0x00, 0x00, 0x03, 0xF3, 0x80,
  0x00, 0x01, 0xF0, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xD8, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x66, 0x00, 0x00, 0x07,
  0x70, 0x07, 0x30, 0x00, 0x00, 0x73, 0x00, 0x39, 0x80, 0x00, 0x03, 0x98,
  0x01, 0xCC, 0x00, 0x00, 0x39, 0xC0, 0x0C, 0x60, 0x00, 0x01, 0xCE, 0x00,
  0x63, 0x00, 0x00, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x0C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x60, 0x07, 0x0E, 0x00,
  0x03, 0x83, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x01,
  0xC1, 0xC0, 0x0C, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0xE0, 0x60, 0x00, 0xE0,
  0x60, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0x70, 0x38,
  0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x38, 0x01, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x00, 0x38,
  0x0E, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x0C, 0x01,
  0x80, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x60, 0x07, 0x00, 0x60,
  0x30, 0x07, 0x00, 0x30, 0x03, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x30, 0x01, 0xC6, 0x00, 0x38,
  0x01, 0x80, 0x0E, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x73, 0x00, 0x0C, 0x00,
  0xE0, 0x01, 0xB8, 0x00, 0x60, 0x07, 0x00, 0x0D, 0x80, 0x07, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0x38, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0x00, 0x30, 0x01, 0xD8, 0x00, 0x01, 0x80, 0x0C, 0xC0, 0x00, 0x1C, 0x00,
  0x67, 0x00, 0x00, 0xE0, 0x07, 0x38, 0x00, 0x06, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0x01, 0xC6, 0x00, 0x03, 0x80, 0x0C, 0x38, 0x00, 0x1C, 0x00, 0x61,
  0xC0, 0x00, 0xE0, 0x07, 0x06, 0x00, 0x06, 0x00, 0x38, 0x30, 0x00, 0x30,
  0x01, 0xC1, 0xC0, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x30,
  0x00, 0xE0, 0x07, 0x01, 0x80, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x70, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03, 0x80, 0x30, 0x01, 0x80,
  0x0C, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0xC0,
  0x07, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x00, 0x60, 0x70, 0x01, 0x80, 0x03,
  0x03, 0x80, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0xC0, 0x07,
  0x00, 0x03, 0x06, 0x00, 0x38, 0x00, 0x18, 0x70, 0x01, 0x80, 0x00, 0xE3,
  0x80, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0xE0, 0x00, 0x18, 0xC0, 0x07, 0x00,
  0x00, 0xC6, 0x00, 0x30, 0x00, 0x07, 0x70, 0x01, 0x80, 0x00, 0x3B, 0x80,
  0x1C, 0x00, 0x00, 0xDC, 0x00, 0xE0, 0x00, 0x06, 0xC0, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x60, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0E,
  0x03, 0xF0, 0x00, 0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x08, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x76, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x39, 0x80, 0x01,
  0xC1, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xE3, 0x00, 0x07, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x70, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x00, 0x60, 0x06, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x70, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0xC0,
  0x1C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x0C, 0x07, 0x00,
  0x0C, 0x06, 0x00, 0x60, 0x38, 0x00, 0x60, 0x70, 0x03, 0x01, 0x80, 0x03,
  0x03, 0x80, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x00, 0xC1,
  0xC0, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x70, 0x00, 0x30, 0xE0,
  0x01, 0x87, 0x00, 0x01, 0x87, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x70,
  0x00, 0x06, 0xE0, 0x00, 0x33, 0x00, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC6, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x38, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x19, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x04,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0C,
  0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x30,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0xE0, 0x70, 0x70, 0x30, 0x38,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x0F, 0xE0, 0x60, 0x03, 0xFF, 0x0C,
  0x01, 0xF0, 0xF3, 0x80, 0x78, 0x06, 0x60, 0x1E, 0x00, 0x6C, 0x07, 0x80,
  0x0D, 0x80, 0xE0, 0x01, 0xB0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00,
  0x3E, 0x03, 0x80, 0x0D, 0xC0, 0x70, 0x01, 0xB0, 0x07, 0x00, 0xE6, 0x00,
  0xF0, 0x38, 0xC0, 0x0F, 0xFE, 0x18, 0x00, 0xFF, 0x87, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x07, 0xE0, 0x01, 0xC3, 0xFF, 0x00,
  0x39, 0xF1, 0xF0, 0x06, 0x70, 0x0E, 0x00, 0xCC, 0x00, 0xE0, 0x1B, 0x00,
  0x1C, 0x07, 0xC0, 0x01, 0x80, 0xF8, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x06, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00,
  0x38, 0x1B, 0x00, 0x0E, 0x03, 0x60, 0x03, 0x80, 0x6E, 0x00, 0xF0, 0x1C,
  0xE0, 0x3C, 0x03, 0x0F, 0xFE, 0x00, 0x60, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xC1, 0xC0, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x10, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x30,
  0x00, 0x1F, 0xF8, 0x60, 0x00, 0xFC, 0x79, 0xC0, 0x03, 0xC0, 0x3B, 0x80,
  0x0F, 0x00, 0x37, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x70, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0,
  0x06, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x7E, 0x00,
  0x38, 0x01, 0xDC, 0x00, 0x38, 0x07, 0x30, 0x00, 0x78, 0x1C, 0x60, 0x00,
  0x7F, 0xF0, 0xC0, 0x00, 0x7F, 0xC1, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0xE0,
  0x1E, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x06,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x18, 0x00, 0xF0, 0x30, 0x0F,
  0xC0, 0xE7, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x80, 0x78, 0x07, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x18, 0x00, 0x3F, 0xF0, 0xC0, 0x07,
  0xE3, 0xC6, 0x00, 0x78, 0x07, 0x30, 0x07, 0x80, 0x1B, 0x80, 0x38, 0x00,
  0xD8, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0,
  0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xD8, 0x03, 0x80, 0x0F, 0xC0, 0x1C,
  0x00, 0xEE, 0x00, 0x70, 0x0E, 0x60, 0x03, 0xC0, 0xE3, 0x00, 0x0F, 0xFE,
  0x38, 0x00, 0x3F, 0xE1, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x07, 0xF0, 0x01,
  0xC7, 0xFF, 0x00, 0x73, 0xE3, 0xE0, 0x19, 0xC0, 0x38, 0x06, 0xE0, 0x06,
  0x01, 0xB0, 0x01, 0xC0, 0xF8, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x03, 0x80, 0x01, 0x81, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x10, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x03,
  0x80, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x39, 0xF0, 0x00, 0x0C, 0xFC, 0x00, 0x03, 0x33, 0x00, 0x00, 0xD8, 0xC0,
  0x00, 0x7C, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0x81, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x07, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00,
  0x30, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0x00, 0xC1, 0xF8, 0x01, 0xF8, 0x00, 0xE3, 0xFF, 0x03,
  0xFF, 0x00, 0x63, 0xC7, 0xC7, 0x87, 0xC0, 0x33, 0x00, 0xE7, 0x00, 0xE0,
  0x1B, 0x00, 0x33, 0x00, 0x38, 0x0F, 0x00, 0x1B, 0x00, 0x1C, 0x0F, 0x80,
  0x0F, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x70, 0x00, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x07, 0x00, 0x07, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x30, 0x00, 0x38, 0x00, 0x38, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0x80, 0x01,
  0x81, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x30, 0x00, 0x30, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0xC1, 0xFC, 0x00, 0x71, 0xFF, 0xC0, 0x18, 0xF8, 0xF8, 0x06,
  0x70, 0x0E, 0x01, 0xB8, 0x01, 0x80, 0xFC, 0x00, 0x70, 0x3E, 0x00, 0x1C,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x78, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x0C,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x07, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x1F, 0x80, 0x00, 0xE1, 0xFF, 0x80, 0x03, 0x1E, 0x1F,
  0x00, 0x0C, 0xE0, 0x1C, 0x00, 0x33, 0x00, 0x38, 0x00, 0xD8, 0x00, 0xE0,
  0x07, 0xE0, 0x01, 0x80, 0x1F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x60, 0x01,
  0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x37, 0x00, 0x78, 0x01, 0xCE, 0x03, 0xC0,
  0x07, 0x1F, 0xFE, 0x00, 0x1C, 0x3F, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x60,
  0x07, 0xFF, 0x0C, 0x01, 0xF0, 0xF1, 0x80, 0x78, 0x07, 0x30, 0x1E, 0x00,
  0x6E, 0x07, 0x80, 0x0D, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0xC0, 0xC0, 0x00,
  0xF0, 0x18, 0x00, 0x36, 0x03, 0x80, 0x0F, 0xC0, 0x70, 0x03, 0xB8, 0x07,
  0x00, 0xE6, 0x00, 0xF0, 0x38, 0xC0, 0x0F, 0xFE, 0x38, 0x00, 0xFF, 0x87,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xF8, 0x0C, 0x3F,
  0xC0, 0x63, 0xE6, 0x03, 0x38, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x0F,
  0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0xF0, 0x03, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x82, 0x00, 0x1C, 0x0E, 0x01, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF8, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x30, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0xC0, 0x60, 0x03, 0x60, 0x1C, 0x01, 0xD8, 0x07,
  0x81, 0xE6, 0x00, 0xFF, 0xE1, 0x80, 0x1F, 0xF0, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x01, 0x81,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x7E,
  0x00, 0x0E, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x00,
  0x0C, 0xE0, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x1F, 0x00, 0x1C, 0xE0, 0x03,
  0xF0, 0x01, 0x8E, 0x00, 0x37, 0x00, 0x38, 0xE0, 0x07, 0x70, 0x03, 0x0E,
  0x00, 0x67, 0x00, 0x70, 0xE0, 0x0E, 0x70, 0x07, 0x0E, 0x00, 0xC7, 0x00,
  0x60, 0xE0, 0x0C, 0x70, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0xC0, 0xE0, 0x18,
  0x70, 0x1C, 0x0E, 0x03, 0x87, 0x01, 0x80, 0xE0, 0x30, 0x70, 0x38, 0x0E,
  0x07, 0x07, 0x03, 0x80, 0xE0, 0x60, 0x70, 0x30, 0x0E, 0x06, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x70, 0x60, 0x0E, 0x0C, 0x03, 0x0E, 0x00, 0xE1, 0xC0,
  0x30, 0xE0, 0x0E, 0x18, 0x03, 0x0C, 0x00, 0xE3, 0x80, 0x31, 0xC0, 0x0E,
  0x30, 0x03, 0x18, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x0E, 0x60, 0x03, 0x30,
  0x00, 0xE6, 0x00, 0x33, 0x00, 0x0E, 0xE0, 0x03, 0x70, 0x00, 0xEC, 0x00,
  0x36, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x07, 0xC0, 0xFC,
  0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC8, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 49, 15, 1, -49 },
  { 87, 15, 18, 20, 7, -49 },
  { 121, 31, 49, 31, 1, -49 },
  { 311, 28, 56, 28, 1, -52 },
  { 507, 35, 51, 42, 4, -50 },
  { 731, 29, 51, 31, 0, -50 },
  { 916, 6, 18, 11, 7, -49 },
  { 930, 19, 60, 17, 2, -49 },
  { 1073, 20, 60, 17, -5, -49 },
  { 1223, 21, 22, 27, 8, -52 },
  { 1281, 26, 32, 31, 3, -40 },
  { 1385, 9, 16, 12, -3, -7 },
  { 1403, 15, 3, 19, 2, -20 },
  { 1409, 5, 5, 12, 1, -5 },
  { 1413, 29, 49, 21, -3, -49 },
  { 1591, 26, 51, 28, 2, -50 },
  { 1757, 14, 49, 28, 9, -49 },
  { 1843, 30, 50, 28, -2, -50 },
  { 2031, 29, 51, 28, -1, -50 },
  { 2216, 29, 50, 28, -1, -50 },
  { 2398, 29, 50, 28, 0, -49 },
  { 2580, 27, 51, 28, 2, -50 },
  { 2753, 27, 49, 28, 4, -49 },
  { 2919, 29, 51, 28, 0, -50 },
  { 3104, 27, 51, 28, 1, -50 },
  { 3277, 11, 37, 12, 1, -37 },
  { 3328, 15, 46, 13, -3, -37 },
  { 3415, 26, 29, 31, 3, -39 },
  { 3510, 26, 17, 31, 3, -33 },
  { 3566, 26, 29, 31, 3, -39 },
  { 3661, 21, 50, 21, 2, -50 },
  { 3793, 39, 55, 43, 2, -49 },
  { 4062, 28, 49, 28, -4, -49 },
  { 4234, 30, 49, 31, 1, -49 },
  { 4418, 31, 51, 29, 3, -50 },
  { 4616, 32, 49, 34, 1, -49 },
  { 4812, 29, 49, 28, 1, -49 },
  { 4990, 29, 49, 25, 1, -49 },
  { 5168, 34, 51, 36, 3, -50 },
  { 5385, 35, 49, 36, 1, -49 },
  { 5600, 22, 49, 15, -3, -49 },
  { 5735, 24, 61, 13, -10, -49 },
  { 5918, 33, 49, 29, 1, -49 },
  { 6121, 19, 49, 25, 1, -49 },
  { 6238, 45, 49, 46, 1, -49 },
  { 6514, 37, 49, 37, 1, -49 },
  { 6741, 32, 51, 37, 3, -50 },
  { 6945, 29, 49, 29, 1, -49 },
  { 7123, 32, 62, 37, 3, -50 },
  { 7371, 29, 49, 30, 1, -49 },
  { 7549, 30, 51, 27, -1, -50 },
  { 7741, 24, 49, 25, 6, -49 },
  { 7888, 33, 50, 35, 3, -49 },
  { 8095, 28, 49, 28, 6, -49 },
  { 8267, 45, 49, 47, 7, -49 },
  { 8543, 35, 49, 26, -4, -49 },
  { 8758, 25, 49, 25, 6, -49 },
  { 8912, 32, 49, 26, -2, -49 },
  { 9108, 25, 60, 20, -1, -49 },
  { 9296, 10, 49, 22, 7, -49 },
  { 9358, 25, 60, 20, -4, -49 },
  { 9546, 27, 26, 30, 2, -49 },
  { 9634, 21, 3, 21, -6, 6 },
  { 9642, 8, 11, 15, 10, -53 },
  { 9653, 27, 38, 30, 2, -37 },
  { 9782, 27, 53, 30, 1, -52 },
  { 9961, 22, 38, 23, 2, -37 },
  { 10066, 31, 53, 31, 2, -52 },
  { 10272, 23, 38, 27, 2, -37 },
  { 10382, 33, 70, 15, -9, -53 },
  { 10671, 29, 54, 31, 0, -37 },
  { 10867, 26, 52, 29, 1, -52 },
  { 11036, 13, 50, 12, 1, -50 },
  { 11118, 23, 67, 13, -9, -50 },
  { 11311, 26, 52, 24, 1, -52 },
  { 11480, 14, 52, 12, 1, -52 },
  { 11571, 41, 37, 45, 1, -37 },
  { 11761, 26, 37, 29, 1, -37 },
  { 11882, 25, 38, 30, 2, -37 },
  { 12001, 30, 53, 30, -2, -37 },
  { 12200, 27, 53, 31, 2, -37 },
  { 12379, 21, 37, 19, 1, -37 },
  { 12477, 22, 38, 22, 0, -37 },
  { 12582, 15, 46, 16, 2, -45 },
  { 12669, 26, 38, 29, 2, -37 },
  { 12793, 22, 37, 22, 4, -37 },
  { 12895, 36, 37, 37, 4, -37 },
  { 13062, 29, 37, 24, -3, -37 },
  { 13197, 35, 54, 23, -8, -37 },
  { 13434, 24, 37, 21, -2, -37 },
  { 13545, 24, 60, 22, 2, -49 },
  { 13725, 3, 70, 28, 13, -53 },
  { 13752, 24, 60, 22, -4, -49 },
  { 13932, 26, 7, 31, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC69PT7B_H_
