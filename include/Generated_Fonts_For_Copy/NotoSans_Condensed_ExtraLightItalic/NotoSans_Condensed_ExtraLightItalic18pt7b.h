#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x00, 0x80, 0x99, 0xAA, 0xA0, 0x09,
  0x09, 0x0A, 0x12, 0x7F, 0x12, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x50,
  0x04, 0x08, 0x69, 0x42, 0x85, 0x0A, 0x0C, 0x14, 0x28, 0x50, 0xAF, 0x84,
  0x08, 0x00, 0x30, 0xA4, 0xA2, 0x92, 0x49, 0x44, 0xAE, 0x6B, 0xD9, 0x14,
  0x92, 0x49, 0x28, 0xA4, 0x70, 0x0C, 0x12, 0x22, 0x24, 0x24, 0x18, 0x30,
  0x49, 0x4A, 0x8A, 0x84, 0x8C, 0x72, 0xF8, 0x0C, 0x21, 0x08, 0x21, 0x04,
  0x10, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x10, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x84, 0x22, 0x21, 0x10, 0x10, 0x4E, 0x4E, 0x52, 0x40, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x29, 0x40, 0xF0, 0x80, 0x01, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1C,
  0x94, 0x51, 0x86, 0x18, 0x61, 0x86, 0x28, 0xA4, 0xE0, 0x17, 0x92, 0x22,
  0x22, 0x44, 0x44, 0x40, 0x3C, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x41, 0x04, 0x0F, 0x80, 0x1E, 0x44, 0x08, 0x10, 0x20, 0x8E, 0x02, 0x04,
  0x08, 0x10, 0x2F, 0x80, 0x02, 0x0C, 0x28, 0x51, 0x44, 0x89, 0x22, 0x85,
  0xFC, 0x20, 0x40, 0x80, 0x1E, 0x40, 0x81, 0x02, 0x0F, 0x01, 0x02, 0x02,
  0x08, 0x10, 0x2F, 0x80, 0x1E, 0x41, 0x02, 0x08, 0x17, 0x31, 0x42, 0x85,
  0x0A, 0x24, 0x4F, 0x00, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x00, 0x1E, 0x44, 0x89, 0x12, 0x22, 0x86, 0x32, 0x85,
  0x0A, 0x14, 0x27, 0x80, 0x1C, 0x44, 0x8A, 0x14, 0x28, 0x51, 0x9D, 0x04,
  0x08, 0x10, 0x4F, 0x00, 0x24, 0x00, 0x00, 0x10, 0x11, 0x00, 0x00, 0x00,
  0x24, 0x48, 0x06, 0x31, 0x84, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0xC0, 0x60, 0x30, 0x10, 0xC6, 0x30, 0x00, 0x70, 0x42, 0x11,
  0x08, 0x88, 0x84, 0x00, 0x08, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x4E,
  0x64, 0x99, 0x26, 0x89, 0xA4, 0xA9, 0x29, 0xB2, 0x00, 0x80, 0x11, 0x03,
  0x80, 0x02, 0x0C, 0x18, 0x50, 0xA2, 0x44, 0x9F, 0x22, 0x85, 0x0C, 0x18,
  0x20, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x42, 0x42, 0x42, 0x42,
  0x84, 0xF8, 0x0F, 0x30, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x78, 0x1E, 0x08, 0x88, 0x44, 0x12, 0x09, 0x05, 0x04, 0x82,
  0x41, 0x21, 0x10, 0x90, 0x8F, 0x80, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF8, 0x1F, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0F, 0x98, 0x08, 0x08,
  0x08, 0x04, 0x02, 0x19, 0x02, 0x82, 0x41, 0x20, 0x90, 0x47, 0xC0, 0x10,
  0x44, 0x22, 0x08, 0x82, 0x20, 0x88, 0x23, 0xF1, 0x04, 0x41, 0x10, 0x44,
  0x22, 0x08, 0x82, 0x00, 0x1C, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x08, 0xE0, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x70, 0x10, 0x88, 0x88, 0x84, 0x82, 0x81, 0x81, 0x40,
  0xD0, 0x48, 0x24, 0x11, 0x10, 0x88, 0x40, 0x10, 0x88, 0x42, 0x11, 0x08,
  0x42, 0x11, 0x0F, 0x80, 0x10, 0x11, 0x03, 0x30, 0x33, 0x05, 0x28, 0x62,
  0x8A, 0x48, 0xA4, 0x92, 0x49, 0x24, 0xA4, 0x4A, 0x48, 0xC4, 0x88, 0x40,
  0x10, 0x44, 0x12, 0x88, 0xA2, 0x28, 0x8A, 0x24, 0x49, 0x14, 0x45, 0x11,
  0x44, 0x32, 0x08, 0x82, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x22,
  0x44, 0x78, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x21, 0x41, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x10, 0x08, 0x08, 0x1E,
  0x11, 0x21, 0x21, 0x21, 0x22, 0x44, 0x78, 0x48, 0x48, 0x44, 0x84, 0x84,
  0x1F, 0x20, 0x20, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04,
  0xF8, 0xFC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x21,
  0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78,
  0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x48, 0xA1, 0x43, 0x06, 0x08, 0x00,
  0x84, 0x30, 0x86, 0x30, 0xC6, 0x29, 0x45, 0x29, 0x29, 0x25, 0x24, 0xA5,
  0x18, 0xA3, 0x18, 0x43, 0x08, 0x40, 0x10, 0x88, 0x84, 0x41, 0x40, 0xC0,
  0x60, 0x20, 0x30, 0x14, 0x12, 0x11, 0x08, 0x88, 0x40, 0x86, 0x28, 0xA4,
  0x92, 0x8C, 0x10, 0x42, 0x08, 0x20, 0x80, 0x1F, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x0F, 0xC0, 0x1C, 0x42,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x38, 0xAA, 0xA5,
  0x55, 0x40, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x42, 0x38, 0x10, 0x30, 0xA2, 0x44, 0x50, 0xA0, 0x80, 0xF8, 0xA4, 0x3A,
  0x89, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x99, 0xD0, 0x10, 0x20, 0x81, 0x02,
  0xC6, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x24, 0x57, 0x00, 0x1B, 0x11, 0x08,
  0x42, 0x10, 0x87, 0x80, 0x01, 0x02, 0x02, 0x02, 0x3A, 0x44, 0x44, 0x84,
  0x84, 0x84, 0x88, 0x88, 0x98, 0xE8, 0x39, 0x14, 0x62, 0x93, 0x88, 0x20,
  0x83, 0xC0, 0x03, 0x04, 0x04, 0x08, 0x1E, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1D, 0x22, 0x22, 0x42,
  0x42, 0x42, 0x84, 0x84, 0x4C, 0x74, 0x04, 0x08, 0x08, 0xF0, 0x10, 0x20,
  0x81, 0x02, 0xC6, 0x48, 0xA1, 0x42, 0x85, 0x12, 0x28, 0x50, 0x80, 0x10,
  0x02, 0x22, 0x44, 0x44, 0x48, 0x80, 0x04, 0x00, 0x02, 0x08, 0x21, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0xC0, 0x10, 0x20, 0x81, 0x02, 0x24,
  0x8A, 0x24, 0x50, 0xE1, 0x42, 0x48, 0x91, 0x00, 0x11, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x88, 0x2C, 0xC6, 0x64, 0x88, 0xA1, 0x14, 0x42, 0x88, 0x91,
  0x12, 0x22, 0x84, 0x51, 0x08, 0x2C, 0x64, 0x8A, 0x14, 0x28, 0x51, 0x22,
  0x85, 0x08, 0x39, 0x14, 0x61, 0x86, 0x18, 0x62, 0x8B, 0xC0, 0x16, 0x19,
  0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x22, 0x5C, 0x40, 0x40, 0x40, 0x80,
  0x3A, 0x89, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x99, 0xD0, 0x20, 0x41, 0x02,
  0x00, 0x2C, 0xC2, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x39, 0x14, 0x10,
  0x20, 0x40, 0x82, 0x0B, 0xC0, 0x21, 0x1E, 0x42, 0x21, 0x08, 0x44, 0x20,
  0xC0, 0x45, 0x14, 0x61, 0x86, 0x28, 0xA2, 0x9B, 0xA0, 0x86, 0x28, 0xA4,
  0x92, 0x8A, 0x28, 0xC2, 0x00, 0x88, 0xC4, 0x66, 0x33, 0x2A, 0x95, 0x52,
  0xA9, 0x94, 0xC4, 0x42, 0x00, 0x21, 0x12, 0x14, 0x14, 0x08, 0x18, 0x18,
  0x28, 0x44, 0x84, 0x10, 0x88, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x28,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x07, 0x00, 0x1E, 0x04, 0x10, 0x40, 0x82,
  0x08, 0x10, 0x41, 0xF0, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x10, 0xC1, 0x04,
  0x20, 0x82, 0x08, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x0C, 0x41, 0x04, 0x20, 0x82, 0x30, 0xFE,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 5, 2, -13 },
  { 11, 8, 13, 8, 0, -13 },
  { 24, 7, 15, 7, 0, -14 },
  { 38, 9, 13, 11, 1, -13 },
  { 53, 8, 13, 8, 0, -13 },
  { 66, 1, 5, 3, 2, -13 },
  { 67, 6, 16, 4, 0, -13 },
  { 79, 5, 16, 4, -1, -13 },
  { 89, 6, 6, 7, 2, -14 },
  { 94, 7, 9, 8, 1, -11 },
  { 102, 3, 4, 3, -1, -2 },
  { 104, 4, 1, 5, 0, -5 },
  { 105, 1, 1, 3, 0, -1 },
  { 106, 8, 13, 5, -1, -13 },
  { 119, 6, 13, 7, 1, -13 },
  { 129, 4, 13, 7, 2, -13 },
  { 136, 7, 13, 7, 0, -13 },
  { 148, 7, 13, 7, 0, -13 },
  { 160, 7, 13, 7, 0, -13 },
  { 172, 7, 13, 7, 0, -13 },
  { 184, 7, 13, 7, 1, -13 },
  { 196, 7, 13, 7, 1, -13 },
  { 208, 7, 13, 7, 0, -13 },
  { 220, 7, 13, 7, 0, -13 },
  { 232, 3, 10, 3, 0, -10 },
  { 236, 4, 12, 3, -1, -10 },
  { 242, 7, 7, 8, 1, -10 },
  { 249, 7, 5, 8, 1, -9 },
  { 254, 7, 7, 8, 1, -10 },
  { 261, 5, 13, 5, 1, -13 },
  { 270, 10, 15, 11, 1, -13 },
  { 289, 7, 13, 7, -1, -13 },
  { 301, 8, 13, 8, 0, -13 },
  { 314, 8, 13, 8, 1, -13 },
  { 327, 9, 13, 9, 0, -13 },
  { 342, 8, 13, 7, 0, -13 },
  { 355, 8, 13, 7, 0, -13 },
  { 368, 9, 13, 10, 1, -13 },
  { 383, 10, 13, 9, 0, -13 },
  { 400, 6, 13, 4, -1, -13 },
  { 410, 7, 16, 3, -3, -13 },
  { 424, 9, 13, 7, 0, -13 },
  { 439, 5, 13, 7, 0, -13 },
  { 448, 12, 13, 12, 0, -13 },
  { 468, 10, 13, 10, 0, -13 },
  { 485, 8, 13, 10, 1, -13 },
  { 498, 8, 13, 8, 0, -13 },
  { 511, 8, 16, 10, 1, -13 },
  { 527, 8, 13, 8, 0, -13 },
  { 540, 8, 13, 7, 0, -13 },
  { 553, 6, 13, 6, 2, -13 },
  { 563, 8, 13, 9, 1, -13 },
  { 576, 7, 13, 7, 2, -13 },
  { 588, 11, 13, 12, 2, -13 },
  { 606, 9, 13, 7, -1, -13 },
  { 621, 6, 13, 6, 2, -13 },
  { 631, 9, 13, 7, -1, -13 },
  { 646, 6, 16, 5, 0, -13 },
  { 658, 2, 13, 6, 2, -13 },
  { 662, 6, 16, 5, -1, -13 },
  { 674, 7, 7, 8, 1, -13 },
  { 681, 5, 1, 5, -1, 1 },
  { 682, 2, 3, 4, 3, -14 },
  { 683, 7, 10, 8, 1, -10 },
  { 692, 7, 14, 8, 0, -14 },
  { 705, 5, 10, 6, 1, -10 },
  { 712, 8, 14, 8, 1, -14 },
  { 726, 6, 10, 7, 1, -10 },
  { 734, 8, 18, 4, -2, -14 },
  { 752, 8, 14, 8, 0, -10 },
  { 766, 7, 14, 8, 0, -14 },
  { 779, 4, 13, 3, 0, -13 },
  { 786, 6, 17, 3, -2, -13 },
  { 799, 7, 14, 6, 0, -14 },
  { 812, 4, 14, 3, 0, -14 },
  { 819, 11, 10, 12, 0, -10 },
  { 833, 7, 10, 8, 0, -10 },
  { 842, 6, 10, 8, 1, -10 },
  { 850, 8, 14, 8, -1, -10 },
  { 864, 7, 14, 8, 1, -10 },
  { 877, 6, 10, 5, 0, -10 },
  { 885, 6, 10, 6, 0, -10 },
  { 893, 5, 12, 4, 0, -12 },
  { 901, 6, 10, 8, 1, -10 },
  { 909, 6, 10, 6, 1, -10 },
  { 917, 9, 10, 10, 1, -10 },
  { 929, 8, 10, 6, -1, -10 },
  { 939, 9, 14, 6, -2, -10 },
  { 955, 7, 10, 5, -1, -10 },
  { 964, 6, 16, 6, 1, -13 },
  { 976, 1, 18, 7, 3, -14 },
  { 979, 6, 16, 6, -1, -13 },
  { 991, 7, 1, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC18PT7B_H_
