#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x61, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x23, 0x22, 0x62, 0x62, 0x46,
  0x44, 0x44, 0x44, 0x84, 0x00, 0x86, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20,
  0x10, 0x80, 0x21, 0x00, 0xC2, 0x0F, 0xFF, 0x02, 0x10, 0x0C, 0x20, 0x10,
  0xC0, 0x21, 0x00, 0x42, 0x01, 0x0C, 0x02, 0x10, 0x7F, 0xFC, 0x10, 0x40,
  0x21, 0x00, 0x42, 0x01, 0x84, 0x02, 0x18, 0x04, 0x20, 0x08, 0x40, 0x21,
  0x80, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0xFF, 0x0C, 0x48, 0x22, 0x01,
  0x88, 0x04, 0x20, 0x10, 0x80, 0x64, 0x00, 0x90, 0x03, 0x40, 0x07, 0x00,
  0x06, 0x00, 0x2C, 0x00, 0x98, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08,
  0x04, 0x62, 0x13, 0x0F, 0xF8, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x0E, 0x03, 0x09, 0x81, 0x08, 0xC1, 0x0C, 0x20, 0x84, 0x10, 0x82,
  0x08, 0x43, 0x0C, 0x41, 0x04, 0x60, 0x82, 0x20, 0x41, 0x20, 0x21, 0x93,
  0xD0, 0x92, 0x28, 0xCB, 0x1E, 0x49, 0x0D, 0xCC, 0x86, 0x04, 0xC2, 0x04,
  0x41, 0x02, 0x20, 0x82, 0x10, 0x41, 0x08, 0x61, 0x04, 0x21, 0x82, 0x10,
  0x81, 0x10, 0x80, 0xF0, 0x01, 0xE0, 0x0C, 0xC0, 0x61, 0x01, 0x04, 0x04,
  0x10, 0x10, 0x40, 0x43, 0x01, 0x08, 0x04, 0x40, 0x12, 0x00, 0x70, 0x01,
  0x80, 0x0F, 0x00, 0x64, 0x03, 0x10, 0xD8, 0x22, 0x40, 0x8B, 0x03, 0x4C,
  0x07, 0x20, 0x18, 0xC0, 0x63, 0x03, 0x84, 0x1B, 0x0F, 0x84, 0x24, 0xB4,
  0x92, 0x80, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x02, 0x00, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x00, 0x04, 0x01, 0x08, 0x43,
  0x10, 0x38, 0xC3, 0xC1, 0x40, 0x90, 0xC2, 0x10, 0x80, 0x30, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x33,
  0x26, 0x4C, 0x80, 0xFF, 0xFC, 0xE0, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x66,
  0x0C, 0x10, 0x81, 0x18, 0x11, 0x01, 0x30, 0x12, 0x01, 0x20, 0x16, 0x01,
  0x40, 0x14, 0x03, 0x40, 0x34, 0x02, 0xC0, 0x2C, 0x02, 0x80, 0x68, 0x04,
  0x80, 0x48, 0x08, 0xC0, 0x8C, 0x10, 0x43, 0x03, 0xC0, 0x02, 0x1C, 0x79,
  0xAC, 0x50, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30,
  0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x00, 0xF0, 0x1C, 0x60, 0x40, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xF8,
  0x01, 0xE0, 0x71, 0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x1F, 0x00, 0x3C, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x62,
  0x06, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0xF0, 0x05, 0x00,
  0x48, 0x06, 0x40, 0x22, 0x02, 0x30, 0x31, 0x01, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x30, 0x81, 0x08, 0x08, 0xC0, 0x47, 0xFF, 0xC0, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x07, 0xFC, 0x1F, 0xE0, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0xF8, 0x04, 0x30, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x08, 0x18, 0x3F, 0x80,
  0x00, 0xF8, 0x1C, 0x41, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x1B, 0xF0, 0xA0, 0x86, 0x02, 0x20, 0x13, 0x00,
  0x98, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00, 0x8C, 0x0C, 0x20, 0x41,
  0x84, 0x07, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x1C, 0xE0, 0x40, 0x82,
  0x03, 0x08, 0x0C, 0x20, 0x30, 0x80, 0x82, 0x02, 0x08, 0x10, 0x10, 0xC0,
  0x6C, 0x00, 0xE0, 0x0F, 0x80, 0x63, 0x02, 0x06, 0x18, 0x08, 0x40, 0x23,
  0x00, 0xC8, 0x03, 0x20, 0x08, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x0F, 0xE0,
  0x01, 0xE0, 0x31, 0x83, 0x06, 0x10, 0x11, 0x80, 0x88, 0x04, 0x40, 0x26,
  0x01, 0x30, 0x09, 0x00, 0xC8, 0x06, 0x60, 0x31, 0x03, 0x0C, 0x68, 0x1C,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x1F, 0x80, 0x08, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x02, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x20,
  0x20, 0x40, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x00, 0x0F, 0x0C, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xE0, 0x0C, 0x02, 0x03, 0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0x84, 0x00,
  0x08, 0x81, 0xE1, 0x20, 0xC4, 0x24, 0x30, 0x85, 0x84, 0x21, 0xA1, 0x04,
  0x34, 0x20, 0x84, 0x8C, 0x30, 0xB1, 0x04, 0x14, 0x20, 0x84, 0x84, 0x30,
  0x90, 0x86, 0x32, 0x11, 0x44, 0x41, 0xCF, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x04, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00, 0x6C, 0x02,
  0x60, 0x13, 0x01, 0x18, 0x08, 0xC0, 0x82, 0x04, 0x10, 0x60, 0x82, 0x04,
  0x3F, 0xE1, 0x01, 0x18, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x00, 0xA0,
  0x05, 0x00, 0x38, 0x01, 0x0F, 0x80, 0x3F, 0xC0, 0x81, 0x82, 0x03, 0x08,
  0x0C, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x43, 0x06, 0x0F,
  0xF0, 0x20, 0xC0, 0x80, 0x82, 0x03, 0x18, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x03, 0x30, 0x08, 0xC0, 0x62, 0x03, 0x08, 0x18, 0x3F, 0x80, 0x00, 0xF8,
  0x0E, 0x30, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x04, 0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xE0, 0x20, 0x60, 0x40, 0x60,
  0x80, 0x43, 0x00, 0x86, 0x01, 0x88, 0x03, 0x10, 0x06, 0x20, 0x0C, 0xC0,
  0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x03, 0x30, 0x04, 0x40, 0x08,
  0x80, 0x31, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x10, 0x18, 0x20, 0xC0, 0x7E,
  0x00, 0x0F, 0xF8, 0x7F, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xC2, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC2, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x03,
  0xFE, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x03, 0x8F, 0x06,
  0x01, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0xFC, 0x80, 0x0C, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0xC0,
  0x10, 0x40, 0x10, 0x30, 0x30, 0x1F, 0xE0, 0x0C, 0x01, 0x0C, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x03, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x06, 0x10, 0x06, 0x30, 0x04, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x0C, 0x20,
  0x08, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x10, 0xC0,
  0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x07, 0xC0, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x03,
  0xE0, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x98, 0x0F, 0x00, 0x0C, 0x02,
  0x18, 0x08, 0x20, 0x30, 0x40, 0xC0, 0x83, 0x03, 0x0C, 0x04, 0x10, 0x08,
  0x40, 0x11, 0x00, 0x26, 0x00, 0xD8, 0x01, 0x70, 0x02, 0xA0, 0x06, 0x40,
  0x08, 0xC0, 0x30, 0x80, 0x41, 0x00, 0x83, 0x01, 0x02, 0x06, 0x04, 0x0C,
  0x0C, 0x10, 0x18, 0x20, 0x10, 0x40, 0x30, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0xFF, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0D, 0x00, 0x28, 0x48,
  0x02, 0x42, 0x40, 0x16, 0x12, 0x01, 0x30, 0x90, 0x09, 0x0C, 0x80, 0x88,
  0x44, 0x04, 0x42, 0x20, 0x46, 0x11, 0x02, 0x20, 0x88, 0x21, 0x0C, 0x61,
  0x08, 0x43, 0x10, 0x42, 0x08, 0x86, 0x10, 0x48, 0x21, 0x82, 0x41, 0x08,
  0x14, 0x08, 0x40, 0xA0, 0xC2, 0x06, 0x06, 0x10, 0x30, 0x20, 0x0C, 0x00,
  0x86, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x20, 0xA0, 0x10, 0xD0, 0x08, 0x48,
  0x0C, 0x26, 0x04, 0x11, 0x02, 0x08, 0x81, 0x0C, 0x40, 0x84, 0x30, 0xC2,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0xC1, 0x88, 0x40, 0x4C, 0x20, 0x24,
  0x10, 0x12, 0x18, 0x0D, 0x0C, 0x03, 0x84, 0x01, 0xC2, 0x00, 0xC1, 0x00,
  0x60, 0x01, 0xF0, 0x0E, 0x70, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00,
  0xC8, 0x01, 0xB0, 0x03, 0x40, 0x06, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xA0, 0x03, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00,
  0x44, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x18, 0x30, 0x1F, 0x80, 0x0F, 0x80,
  0x7F, 0x82, 0x04, 0x10, 0x10, 0x80, 0x8C, 0x04, 0x60, 0x22, 0x01, 0x10,
  0x08, 0x80, 0xCC, 0x04, 0x40, 0x42, 0x0C, 0x1F, 0xC0, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x01, 0xF0, 0x0E, 0x70, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00,
  0xC8, 0x01, 0xB0, 0x03, 0x40, 0x06, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xA0, 0x03, 0x40, 0x06, 0x80, 0x09, 0x00, 0x32, 0x00,
  0x44, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x18, 0x30, 0x1F, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x0F, 0x00,
  0x7F, 0x82, 0x04, 0x10, 0x10, 0x80, 0x8C, 0x04, 0x60, 0x22, 0x01, 0x10,
  0x18, 0x80, 0x8C, 0x0C, 0x40, 0xC3, 0xFC, 0x1F, 0x80, 0x84, 0x0C, 0x20,
  0x41, 0x02, 0x0C, 0x10, 0x21, 0x81, 0x0C, 0x08, 0x40, 0x62, 0x01, 0x10,
  0x08, 0x01, 0xF0, 0x1C, 0x70, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x08, 0x18, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x33, 0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C,
  0xC0, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x88, 0x03, 0x30, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10, 0x18,
  0x30, 0x60, 0x3F, 0x80, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00, 0x68, 0x02,
  0x40, 0x32, 0x01, 0x10, 0x08, 0x80, 0x86, 0x04, 0x30, 0x61, 0x82, 0x0C,
  0x30, 0x61, 0x03, 0x18, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x00, 0xA0,
  0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x30, 0x0E, 0x00, 0xC0,
  0x28, 0x07, 0x01, 0xA0, 0x1C, 0x04, 0x80, 0x70, 0x12, 0x02, 0xC0, 0xC8,
  0x0B, 0x02, 0x20, 0x6C, 0x18, 0x81, 0x30, 0x42, 0x04, 0xC1, 0x08, 0x23,
  0x08, 0x20, 0x8C, 0x20, 0x86, 0x31, 0x82, 0x10, 0xC4, 0x08, 0xC3, 0x10,
  0x22, 0x0C, 0x80, 0x88, 0x32, 0x02, 0x40, 0xD8, 0x09, 0x02, 0x40, 0x2C,
  0x0B, 0x00, 0xA0, 0x28, 0x02, 0x80, 0xA0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x10, 0x40,
  0x08, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0xB0, 0x00, 0x50, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x04,
  0x40, 0x06, 0x30, 0x02, 0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x01,
  0x00, 0xC1, 0x80, 0x60, 0x80, 0x38, 0x02, 0x80, 0x6C, 0x04, 0xC0, 0x84,
  0x18, 0x41, 0x04, 0x30, 0x42, 0x04, 0x60, 0x64, 0x02, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x3F, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFE, 0x00, 0xC2, 0x10, 0x84,
  0x21, 0x0C, 0x21, 0x08, 0x42, 0x18, 0xC2, 0x10, 0x84, 0x21, 0x84, 0x21,
  0x03, 0xF0, 0x3F, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0xA0, 0x0D, 0x00, 0x4C, 0x06, 0x20, 0x21, 0x82, 0x04, 0x30, 0x21, 0x01,
  0x98, 0x04, 0x80, 0x2C, 0x00, 0x80, 0xFF, 0xC0, 0x89, 0x12, 0x03, 0x80,
  0x76, 0x46, 0x0C, 0x20, 0x63, 0x03, 0x10, 0x19, 0x80, 0xC8, 0x04, 0x40,
  0x26, 0x01, 0x30, 0x09, 0x00, 0xC8, 0x04, 0x40, 0x63, 0x03, 0x18, 0x28,
  0x42, 0xC1, 0xE4, 0x00, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x1C, 0x0B, 0x30, 0x70, 0xC7, 0x02, 0x30, 0x11,
  0x80, 0x88, 0x04, 0x40, 0x26, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x04, 0x40,
  0x26, 0x03, 0x30, 0x11, 0x81, 0x8A, 0x18, 0xDF, 0x80, 0x03, 0xE1, 0xC8,
  0x60, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x61, 0x07, 0xE0, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x01,
  0xC4, 0x0E, 0xC8, 0x30, 0x70, 0x40, 0xC1, 0x80, 0x82, 0x01, 0x0C, 0x06,
  0x10, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x80, 0x42, 0x01, 0x84, 0x03, 0x08,
  0x0C, 0x10, 0x18, 0x30, 0x50, 0x21, 0xA0, 0x3C, 0x80, 0x03, 0x81, 0xC8,
  0x61, 0x88, 0x12, 0x02, 0x40, 0xD0, 0x12, 0x0C, 0x47, 0x1E, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x87, 0xE0, 0x00, 0x1E,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x03, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1D, 0x90, 0xC1, 0x42, 0x06, 0x18, 0x08, 0x40, 0x23, 0x01,
  0x88, 0x06, 0x20, 0x11, 0x80, 0x46, 0x01, 0x10, 0x0C, 0x40, 0x31, 0x01,
  0x86, 0x06, 0x18, 0x28, 0x21, 0xE0, 0x7D, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0xC7, 0x01, 0xF0, 0x00, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x1C, 0x0B,
  0x30, 0x70, 0xC7, 0x02, 0x30, 0x31, 0x81, 0x88, 0x08, 0x40, 0x46, 0x02,
  0x20, 0x31, 0x01, 0x88, 0x08, 0x40, 0x46, 0x02, 0x20, 0x31, 0x01, 0x08,
  0x08, 0xC0, 0x40, 0x06, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x04, 0x08, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x07, 0x00, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x01, 0x08, 0x10, 0x41,
  0x06, 0x10, 0x21, 0x81, 0x18, 0x09, 0x80, 0x58, 0x06, 0xC0, 0x2A, 0x01,
  0x98, 0x08, 0x40, 0x42, 0x06, 0x10, 0x20, 0xC1, 0x02, 0x08, 0x10, 0xC0,
  0xC0, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0xC0, 0x00,
  0xE0, 0xC0, 0xB3, 0x37, 0x0C, 0x14, 0x11, 0xC1, 0x81, 0x18, 0x18, 0x11,
  0x81, 0x01, 0x10, 0x10, 0x31, 0x03, 0x02, 0x30, 0x20, 0x22, 0x02, 0x02,
  0x20, 0x20, 0x22, 0x02, 0x06, 0x20, 0x60, 0x46, 0x04, 0x04, 0x40, 0x40,
  0x44, 0x04, 0x0C, 0x40, 0xC0, 0x8C, 0x0C, 0x08, 0x00, 0xE0, 0x59, 0x83,
  0x86, 0x38, 0x11, 0x81, 0x8C, 0x0C, 0x40, 0x42, 0x02, 0x30, 0x11, 0x01,
  0x88, 0x0C, 0x40, 0x42, 0x02, 0x30, 0x11, 0x01, 0x88, 0x08, 0x40, 0x46,
  0x02, 0x00, 0x03, 0x80, 0xEE, 0x18, 0x21, 0x03, 0x20, 0x12, 0x01, 0x60,
  0x14, 0x01, 0x40, 0x3C, 0x03, 0xC0, 0x28, 0x02, 0x80, 0x68, 0x04, 0xC0,
  0xC4, 0x08, 0x61, 0x03, 0xE0, 0x00, 0x30, 0x16, 0x60, 0x50, 0xC3, 0x81,
  0x0C, 0x04, 0x30, 0x10, 0x80, 0x42, 0x01, 0x18, 0x04, 0x40, 0x11, 0x00,
  0xC4, 0x02, 0x10, 0x08, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x28, 0x60, 0xBF,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x76, 0x46, 0x0A, 0x20, 0x63, 0x01, 0x10,
  0x09, 0x80, 0xC8, 0x06, 0x40, 0x26, 0x01, 0x30, 0x09, 0x00, 0xC8, 0x06,
  0x40, 0x62, 0x03, 0x18, 0x28, 0x43, 0xC1, 0xE6, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0xE1,
  0x74, 0x38, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x07,
  0x83, 0x9C, 0x40, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x40, 0x08, 0x83, 0x1F, 0xC0,
  0x08, 0x10, 0x20, 0x81, 0x0F, 0xC4, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08,
  0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x1E, 0x00, 0x10, 0x11, 0x01, 0x30,
  0x12, 0x03, 0x20, 0x22, 0x02, 0x20, 0x26, 0x02, 0x40, 0x64, 0x04, 0x40,
  0x4C, 0x04, 0xC0, 0xC8, 0x0C, 0x81, 0x8C, 0x28, 0x7C, 0x80, 0x80, 0x60,
  0x28, 0x0A, 0x06, 0x81, 0x20, 0xC8, 0x22, 0x18, 0x84, 0x23, 0x0C, 0x83,
  0x60, 0xD0, 0x3C, 0x06, 0x01, 0x80, 0x40, 0x00, 0x80, 0x81, 0xC0, 0xC0,
  0xA0, 0x60, 0xD0, 0x50, 0x48, 0x28, 0x24, 0x34, 0x32, 0x12, 0x11, 0x19,
  0x18, 0x88, 0x88, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12, 0x0A, 0x0B, 0x05,
  0x05, 0x03, 0x82, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0x08, 0x18, 0x40,
  0x83, 0x08, 0x08, 0xC0, 0x44, 0x02, 0x40, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x28, 0x03, 0x40, 0x32, 0x01, 0x18, 0x10, 0x41, 0x82, 0x08, 0x10, 0x80,
  0xC0, 0x03, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x40,
  0x08, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x4C,
  0x00, 0x24, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x20, 0x3C,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x20, 0x38, 0x07, 0x00, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x80, 0x10, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x08, 0x00, 0x70, 0x0E, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0xF0, 0x00, 0x7C, 0x0E, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 8, 9, 10, 3, -24 },
  { 28, 15, 24, 15, 0, -24 },
  { 73, 14, 27, 14, 0, -25 },
  { 121, 17, 24, 20, 2, -24 },
  { 172, 14, 24, 15, 0, -24 },
  { 214, 3, 9, 5, 3, -24 },
  { 218, 9, 29, 8, 1, -24 },
  { 251, 9, 29, 8, -2, -24 },
  { 284, 10, 11, 13, 4, -25 },
  { 298, 13, 15, 15, 1, -19 },
  { 323, 4, 7, 6, -1, -3 },
  { 327, 7, 2, 9, 1, -10 },
  { 329, 2, 2, 6, 1, -2 },
  { 330, 13, 24, 10, -1, -24 },
  { 369, 12, 24, 14, 1, -24 },
  { 405, 7, 24, 14, 4, -24 },
  { 426, 14, 24, 14, -1, -24 },
  { 468, 13, 24, 14, 0, -24 },
  { 507, 13, 24, 14, 0, -24 },
  { 546, 14, 24, 14, 0, -24 },
  { 588, 13, 24, 14, 1, -24 },
  { 627, 13, 24, 14, 2, -24 },
  { 666, 14, 24, 14, 0, -24 },
  { 708, 13, 24, 14, 0, -24 },
  { 747, 6, 18, 6, 0, -18 },
  { 761, 8, 22, 6, -2, -18 },
  { 783, 13, 14, 15, 1, -19 },
  { 806, 13, 8, 15, 1, -16 },
  { 819, 13, 14, 15, 1, -19 },
  { 842, 10, 24, 10, 1, -24 },
  { 872, 19, 27, 20, 1, -24 },
  { 937, 13, 24, 13, -2, -24 },
  { 976, 14, 24, 15, 1, -24 },
  { 1018, 14, 24, 14, 2, -24 },
  { 1060, 15, 24, 16, 1, -24 },
  { 1105, 13, 24, 13, 1, -24 },
  { 1144, 13, 24, 12, 1, -24 },
  { 1183, 16, 24, 17, 2, -24 },
  { 1231, 16, 24, 17, 1, -24 },
  { 1279, 10, 24, 7, -1, -24 },
  { 1309, 12, 30, 6, -5, -24 },
  { 1354, 15, 24, 14, 1, -24 },
  { 1399, 8, 24, 12, 1, -24 },
  { 1423, 21, 24, 22, 1, -24 },
  { 1486, 17, 24, 18, 1, -24 },
  { 1537, 15, 24, 18, 2, -24 },
  { 1582, 13, 24, 14, 1, -24 },
  { 1621, 15, 30, 18, 2, -24 },
  { 1678, 13, 24, 14, 1, -24 },
  { 1717, 14, 24, 13, 0, -24 },
  { 1759, 12, 24, 12, 3, -24 },
  { 1795, 15, 24, 17, 2, -24 },
  { 1840, 13, 24, 14, 3, -24 },
  { 1879, 22, 24, 22, 3, -24 },
  { 1945, 17, 24, 12, -2, -24 },
  { 1996, 12, 24, 12, 3, -24 },
  { 2032, 15, 24, 13, -1, -24 },
  { 2077, 12, 29, 9, -1, -24 },
  { 2121, 5, 24, 11, 3, -24 },
  { 2136, 12, 29, 9, -2, -24 },
  { 2180, 13, 13, 15, 1, -24 },
  { 2202, 10, 1, 10, -3, 3 },
  { 2204, 3, 5, 7, 5, -25 },
  { 2206, 13, 18, 14, 1, -18 },
  { 2236, 13, 25, 14, 0, -25 },
  { 2277, 11, 18, 11, 1, -18 },
  { 2302, 15, 25, 15, 1, -25 },
  { 2349, 11, 18, 13, 1, -18 },
  { 2374, 15, 33, 7, -4, -25 },
  { 2436, 14, 26, 15, 0, -18 },
  { 2482, 13, 25, 14, 0, -25 },
  { 2523, 7, 24, 6, 0, -24 },
  { 2544, 11, 32, 6, -4, -24 },
  { 2588, 13, 25, 12, 0, -25 },
  { 2629, 7, 25, 6, 0, -25 },
  { 2651, 20, 18, 21, 0, -18 },
  { 2696, 13, 18, 14, 0, -18 },
  { 2726, 12, 18, 14, 1, -18 },
  { 2753, 14, 26, 14, -1, -18 },
  { 2799, 13, 26, 15, 1, -18 },
  { 2842, 11, 18, 9, 0, -18 },
  { 2867, 11, 18, 11, 0, -18 },
  { 2892, 7, 22, 8, 1, -22 },
  { 2912, 12, 17, 14, 1, -17 },
  { 2938, 10, 17, 11, 2, -17 },
  { 2960, 17, 17, 18, 2, -17 },
  { 2997, 13, 17, 11, -1, -17 },
  { 3025, 17, 25, 11, -4, -17 },
  { 3079, 12, 17, 10, -1, -17 },
  { 3105, 11, 29, 11, 1, -24 },
  { 3145, 1, 33, 13, 6, -25 },
  { 3150, 12, 29, 11, -2, -24 },
  { 3194, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC33PT7B_H_
