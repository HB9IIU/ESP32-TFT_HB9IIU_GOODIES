#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x30, 0xCC, 0x32, 0x0D,
  0x82, 0x61, 0x98, 0x64, 0x19, 0x04, 0xC1, 0x30, 0xC8, 0x32, 0x08, 0x00,
  0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x08, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x04, 0x07, 0xFF, 0xFE, 0x03, 0x03, 0x00, 0x18, 0x10, 0x00, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x01,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x10, 0x00, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x40, 0x02, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x1E, 0x4F, 0x03, 0x8C, 0x10, 0x30,
  0xC0, 0x06, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0x41, 0x80, 0x06,
  0x10, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x06, 0xE0,
  0x00, 0x47, 0x00, 0x04, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0xC1,
  0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x08, 0x30, 0x01, 0x86, 0x0C, 0x11,
  0xC0, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x02, 0x07, 0xC0,
  0x0C, 0x0C, 0x60, 0x0C, 0x18, 0x60, 0x18, 0x30, 0x20, 0x10, 0x30, 0x20,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x20, 0x60, 0x60, 0x60, 0xC0, 0x40, 0x60,
  0xC0, 0xC0, 0x61, 0x80, 0xC0, 0x61, 0x00, 0xC0, 0x43, 0x00, 0xC0, 0xC2,
  0x00, 0xC0, 0xC6, 0x1C, 0x80, 0xCC, 0x7E, 0x81, 0x8C, 0xC3, 0x81, 0x98,
  0x83, 0xC3, 0x11, 0x83, 0xC6, 0x31, 0x03, 0x7E, 0x23, 0x03, 0x38, 0x63,
  0x03, 0x00, 0xC2, 0x03, 0x00, 0xC6, 0x03, 0x01, 0x86, 0x03, 0x01, 0x86,
  0x02, 0x03, 0x04, 0x06, 0x02, 0x04, 0x06, 0x06, 0x04, 0x06, 0x0C, 0x04,
  0x0C, 0x0C, 0x04, 0x0C, 0x18, 0x04, 0x08, 0x18, 0x06, 0x18, 0x30, 0x06,
  0x30, 0x60, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xF0,
  0x00, 0x61, 0x80, 0x0C, 0x08, 0x00, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x08, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x18,
  0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x31,
  0x81, 0x03, 0x30, 0x18, 0x66, 0x01, 0x86, 0x60, 0x0C, 0x46, 0x00, 0xCC,
  0xC0, 0x04, 0x8C, 0x00, 0x78, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07,
  0x06, 0x00, 0xD0, 0x60, 0x19, 0x83, 0x87, 0x18, 0x1F, 0xC0, 0xC0, 0x33,
  0x26, 0x66, 0x44, 0xCC, 0xC8, 0x00, 0x1C, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x20, 0x40, 0xC1,
  0x01, 0xCC, 0x01, 0xF3, 0xC1, 0xFC, 0x07, 0x00, 0x34, 0x01, 0x98, 0x1C,
  0x20, 0xE0, 0xC1, 0x01, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x18, 0x30,
  0xC1, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x00, 0xFF, 0xFF, 0xFC, 0x5F, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x70, 0xC0, 0x60, 0x30, 0x60, 0x18,
  0x30, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xA0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x06, 0x20, 0x03, 0x10, 0x01,
  0x88, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xE0, 0x38,
  0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x68, 0x76, 0x39, 0xB8, 0x64,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0xE0, 0x08, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xC1, 0xC0, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x80,
  0x18, 0x0E, 0x0F, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x04, 0x80,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0xC2, 0x00,
  0x30, 0xC0, 0x04, 0x18, 0x01, 0x83, 0x00, 0x60, 0x40, 0x08, 0x18, 0x03,
  0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x60, 0x60,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x04, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x0F, 0xF8, 0x00, 0xC1,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x08, 0x01, 0x80, 0xE0, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xF0, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x1F, 0x01, 0x9F, 0xF0, 0x6C, 0x0E,
  0x1E, 0x01, 0x87, 0x00, 0x63, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x60, 0x30,
  0x0E, 0x38, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xF8, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x60, 0x20, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x83, 0x00,
  0x0C, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x98, 0x00, 0x60, 0xC0,
  0x1C, 0x06, 0x03, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x18, 0x60, 0x01,
  0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x30, 0x0E, 0x03, 0xC3, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x18, 0x38, 0x0C, 0x06, 0x06,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x07, 0x30, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x78, 0x30, 0x76, 0x0F,
  0xF9, 0x00, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x20, 0xE0, 0x0F, 0xF0, 0x00, 0x02, 0x07, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x60, 0xE0, 0x60, 0x00,
  0x40, 0x30, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xC0, 0x7F, 0xC1, 0x83, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x30, 0x0C,
  0x60, 0x3F, 0xC1, 0x88, 0x0E, 0x18, 0x33, 0x03, 0x02, 0x06, 0x40, 0x60,
  0xC0, 0xD8, 0x18, 0x18, 0x1B, 0x06, 0x03, 0x02, 0x60, 0xC0, 0x40, 0x48,
  0x10, 0x18, 0x1B, 0x06, 0x03, 0x03, 0x60, 0xC0, 0x60, 0x6C, 0x18, 0x08,
  0x09, 0x82, 0x03, 0x03, 0x20, 0x40, 0x60, 0x44, 0x08, 0x1C, 0x18, 0x81,
  0x03, 0x83, 0x10, 0x30, 0xF0, 0xC2, 0x06, 0x32, 0x30, 0x40, 0x7C, 0x7C,
  0x08, 0x06, 0x02, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x24, 0x00,
  0x0C, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x03, 0x08, 0x00,
  0x61, 0x00, 0x18, 0x20, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xFF, 0xF0, 0x3F,
  0xFE, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x38, 0x00, 0x04, 0x01, 0xFF, 0x80, 0x08,
  0x3F, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x08,
  0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x0E, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x38,
  0x30, 0x01, 0x81, 0x00, 0x18, 0x18, 0x03, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x1E, 0x06, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x60, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x04, 0x1F, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38,
  0x0C, 0x00, 0x60, 0x20, 0x01, 0x81, 0x80, 0x02, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x30,
  0x1E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x02, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x07, 0xF8, 0x60, 0x07, 0xF8, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x1C, 0x00,
  0xC0, 0x0F, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x03, 0x01, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x08, 0x0C, 0x00, 0x18, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01,
  0x80, 0x01, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x8E, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0x80, 0x0E, 0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x0E, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x21, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x60, 0x00,
  0x3C, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x40,
  0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06,
  0x00, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xB0, 0x3C, 0x00, 0x03, 0x40, 0x78, 0x00, 0x05, 0x80, 0xB0, 0x00, 0x1B,
  0x03, 0x20, 0x00, 0x26, 0x06, 0x40, 0x00, 0xC8, 0x0C, 0x80, 0x03, 0x30,
  0x19, 0x80, 0x06, 0x60, 0x23, 0x00, 0x18, 0xC0, 0xC6, 0x00, 0x31, 0x81,
  0x8C, 0x00, 0xC2, 0x03, 0x18, 0x01, 0x8C, 0x04, 0x30, 0x06, 0x18, 0x18,
  0x60, 0x0C, 0x30, 0x30, 0xC0, 0x30, 0x60, 0x60, 0x80, 0x60, 0x80, 0xC1,
  0x01, 0x83, 0x01, 0x02, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x60, 0x60, 0x30, 0x30, 0xC0, 0xC0, 0x40, 0x63,
  0x01, 0x81, 0x80, 0xC6, 0x03, 0x03, 0x01, 0x98, 0x04, 0x06, 0x03, 0x30,
  0x18, 0x08, 0x06, 0xC0, 0x30, 0x30, 0x05, 0x80, 0x60, 0x60, 0x0E, 0x00,
  0xC0, 0xC0, 0x1C, 0x01, 0x01, 0x80, 0x30, 0x06, 0x00, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x60, 0x78, 0x00, 0x20, 0x3C, 0x00,
  0x30, 0x1A, 0x00, 0x18, 0x09, 0x80, 0x0C, 0x0C, 0xC0, 0x04, 0x06, 0x60,
  0x06, 0x03, 0x10, 0x03, 0x01, 0x8C, 0x01, 0x80, 0x86, 0x00, 0xC0, 0xC3,
  0x00, 0x40, 0x60, 0xC0, 0x60, 0x30, 0x60, 0x30, 0x10, 0x30, 0x18, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x04, 0x06, 0x03, 0x06, 0x03, 0x01, 0x83, 0x01,
  0x00, 0xC1, 0x81, 0x80, 0x30, 0xC0, 0xC0, 0x18, 0xC0, 0x60, 0x0C, 0x60,
  0x30, 0x06, 0x30, 0x10, 0x01, 0x98, 0x18, 0x00, 0xC8, 0x0C, 0x00, 0x6C,
  0x06, 0x00, 0x36, 0x03, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x81, 0x80, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00,
  0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x11,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x18, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0x70, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x10, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x03,
  0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x20, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x03, 0x01, 0x81, 0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x06, 0x03, 0x80, 0x18,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60,
  0x00, 0x11, 0x80, 0x00, 0x46, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0x70, 0x70, 0x00, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x10, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x03,
  0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0,
  0x38, 0x18, 0x07, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0x83, 0x00, 0x10,
  0x30, 0x03, 0x01, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x02,
  0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0,
  0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x10, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x0E,
  0x07, 0xC3, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0xC0, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x03, 0x00, 0x06, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0,
  0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x84, 0x00, 0x18,
  0x40, 0x03, 0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x60, 0x40, 0x06,
  0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x68, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x1C, 0x00, 0x34, 0x00, 0x28,
  0x00, 0xC8, 0x00, 0xD0, 0x01, 0x90, 0x01, 0xA0, 0x03, 0x20, 0x02, 0x40,
  0x0C, 0x40, 0x0C, 0x80, 0x18, 0x80, 0x19, 0x00, 0x61, 0x00, 0x62, 0x00,
  0xC2, 0x00, 0xCC, 0x01, 0x04, 0x01, 0x18, 0x06, 0x08, 0x06, 0x30, 0x0C,
  0x10, 0x08, 0x60, 0x30, 0x20, 0x30, 0xC0, 0x60, 0x40, 0x61, 0x81, 0x80,
  0x81, 0x83, 0x03, 0x01, 0x03, 0x06, 0x06, 0x02, 0x04, 0x0C, 0x18, 0x04,
  0x18, 0x18, 0x30, 0x08, 0x30, 0x30, 0xC0, 0x10, 0xC0, 0x61, 0x80, 0x21,
  0x80, 0xC2, 0x00, 0x46, 0x01, 0x8C, 0x00, 0x8C, 0x03, 0x18, 0x01, 0x10,
  0x06, 0x60, 0x02, 0x60, 0x0C, 0xC0, 0x04, 0xC0, 0x19, 0x00, 0x0B, 0x00,
  0x36, 0x00, 0x16, 0x00, 0x68, 0x00, 0x28, 0x00, 0xF0, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x18, 0x00, 0x20, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x26, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x82, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x18, 0x01, 0x00, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01,
  0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0xE0, 0x01, 0x90, 0x00, 0xCC, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x20, 0x30, 0x10,
  0x18, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x26, 0x00, 0x13, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xC1, 0x83, 0x06, 0x04, 0x08, 0x18,
  0x30, 0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1,
  0x83, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C,
  0x00, 0x7F, 0x80, 0x40, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xA0, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x18,
  0x10, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x06, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x02, 0x60, 0x00, 0x7C, 0x00,
  0x0C, 0xFF, 0xFE, 0xC6, 0x18, 0xC3, 0x08, 0x61, 0x00, 0xF8, 0x00, 0xFF,
  0x10, 0x70, 0x6C, 0x38, 0x0B, 0x0C, 0x02, 0x86, 0x00, 0xE3, 0x80, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x02, 0xC1,
  0x81, 0xA0, 0x71, 0xC8, 0x0F, 0xC6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x61, 0xE0, 0x19, 0xFC, 0x04, 0xC1,
  0x83, 0x60, 0x30, 0xF0, 0x0C, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x11,
  0xC0, 0x04, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0xF0, 0x0C, 0x34, 0x06, 0x09,
  0xC7, 0x02, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xFC, 0x1C, 0x08, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x78, 0x60, 0x3F, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3E, 0x10, 0x07, 0xF9,
  0x80, 0x70, 0x6C, 0x07, 0x01, 0x60, 0x30, 0x0F, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x03,
  0x00, 0x70, 0x18, 0x07, 0x80, 0xC0, 0x3C, 0x03, 0x03, 0x60, 0x1C, 0x72,
  0x00, 0x7E, 0x10, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x1C, 0x18, 0x70, 0x30,
  0xC0, 0x23, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x20, 0x06, 0xC0, 0x19, 0x80,
  0x62, 0x03, 0x8F, 0xFC, 0x1F, 0xC0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x08, 0x38, 0x70, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x08,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xF1, 0x01, 0xC1, 0x90, 0x38, 0x0B, 0x03, 0x00, 0xF0, 0x60, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC1,
  0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18,
  0x30, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00, 0x30, 0x30, 0x07,
  0x03, 0x00, 0xF0, 0x30, 0x0F, 0x03, 0x81, 0xB0, 0x1C, 0x72, 0x00, 0xFE,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x80, 0x30, 0x0E,
  0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x61, 0xE0, 0x19, 0xFC, 0x04, 0xC1,
  0x83, 0x40, 0x60, 0xE0, 0x0C, 0x38, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x21,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x01, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x02, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x9C, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x04, 0x18, 0x06, 0x04, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x19, 0x80, 0x04, 0xE0, 0x03, 0x68, 0x00, 0xDB, 0x00,
  0x3C, 0xC0, 0x0E, 0x30, 0x03, 0x04, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x18, 0x06, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01,
  0x82, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x4F, 0xF1, 0xFE, 0x05, 0x83, 0x30, 0x70, 0xD0, 0x1A, 0x03, 0x0E, 0x01,
  0xC0, 0x30, 0xE0, 0x1C, 0x03, 0x0C, 0x01, 0x80, 0x31, 0xC0, 0x18, 0x03,
  0x18, 0x01, 0x80, 0x31, 0x80, 0x30, 0x02, 0x18, 0x03, 0x00, 0x61, 0x00,
  0x30, 0x06, 0x30, 0x03, 0x00, 0x63, 0x00, 0x20, 0x06, 0x30, 0x06, 0x00,
  0x43, 0x00, 0x60, 0x0C, 0x20, 0x06, 0x00, 0xC6, 0x00, 0x60, 0x0C, 0x60,
  0x04, 0x00, 0xC6, 0x00, 0xC0, 0x08, 0x60, 0x0C, 0x01, 0x84, 0x00, 0xC0,
  0x18, 0xC0, 0x08, 0x01, 0x8C, 0x01, 0x80, 0x10, 0xC0, 0x18, 0x03, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x1E, 0x01, 0x1F, 0xC0, 0x4C, 0x18, 0x34, 0x06,
  0x0F, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x08, 0x70, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x0C, 0x20, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x06, 0x10, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x03, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0x81, 0xC0, 0x60, 0xC0,
  0x30, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x3C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6, 0x00,
  0xC3, 0x00, 0x60, 0xC0, 0x60, 0x70, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x04, 0x7F, 0x00, 0x26, 0x0C, 0x03, 0x60, 0x30, 0x1E, 0x01, 0x80,
  0xE0, 0x0C, 0x07, 0x00, 0x20, 0x30, 0x01, 0x03, 0x80, 0x08, 0x18, 0x00,
  0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x78, 0x06, 0x03, 0x40,
  0x60, 0x1B, 0x8E, 0x00, 0xCF, 0xE0, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0x10, 0x70, 0x64, 0x38, 0x0B, 0x0C, 0x03, 0xC6,
  0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x11, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30,
  0x07, 0x0C, 0x03, 0xC3, 0x81, 0xB0, 0x71, 0xC8, 0x0F, 0xE6, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x11, 0xF0, 0x4C, 0x03, 0x60, 0x0F, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0x0E, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x80, 0x60, 0xE1, 0xE0,
  0xFF, 0x80, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x81,
  0xFF, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x83, 0xF0, 0x0C, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x43,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0x80, 0x38, 0x30, 0x1E, 0x0C,
  0x0D, 0x83, 0x86, 0x60, 0x7F, 0x10, 0x00, 0x80, 0x07, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61,
  0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x30, 0xC0, 0x61,
  0x00, 0xC6, 0x00, 0x88, 0x01, 0x30, 0x02, 0x60, 0x05, 0x80, 0x0B, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x0C, 0x01,
  0xB0, 0x0E, 0x00, 0x98, 0x05, 0x00, 0xCC, 0x06, 0x80, 0x66, 0x03, 0x40,
  0x63, 0x03, 0x20, 0x31, 0x81, 0x90, 0x10, 0xC0, 0x88, 0x18, 0x60, 0xC4,
  0x08, 0x30, 0x42, 0x0C, 0x18, 0x61, 0x06, 0x0C, 0x30, 0xC6, 0x06, 0x30,
  0x63, 0x03, 0x18, 0x31, 0x01, 0x88, 0x19, 0x80, 0xCC, 0x0C, 0xC0, 0x64,
  0x06, 0xC0, 0x36, 0x03, 0x60, 0x1B, 0x01, 0xA0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x70, 0x30, 0x06, 0x01, 0x00, 0xC0, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00,
  0x05, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x01, 0xB0, 0x00, 0x19, 0x00, 0x03, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0xC0, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00,
  0x40, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x40, 0x18, 0x00, 0x40,
  0x10, 0x00, 0x40, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x8E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00,
  0x5D, 0xF0, 0x1C, 0x0F, 0x9E, 0x00, 0xFE,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 34, 10, 1, -34 },
  { 44, 10, 12, 14, 5, -34 },
  { 59, 21, 34, 22, 1, -34 },
  { 149, 20, 39, 20, 0, -36 },
  { 247, 24, 36, 29, 3, -35 },
  { 355, 20, 35, 21, 0, -35 },
  { 443, 4, 12, 8, 5, -34 },
  { 449, 14, 42, 12, 1, -34 },
  { 523, 13, 42, 12, -3, -34 },
  { 592, 14, 15, 19, 6, -36 },
  { 619, 18, 22, 22, 2, -28 },
  { 669, 7, 11, 8, -2, -5 },
  { 679, 11, 2, 13, 1, -14 },
  { 682, 3, 4, 9, 1, -4 },
  { 684, 20, 34, 15, -2, -34 },
  { 769, 17, 35, 20, 2, -35 },
  { 844, 10, 34, 20, 6, -34 },
  { 887, 20, 35, 20, -1, -35 },
  { 975, 20, 36, 20, 0, -35 },
  { 1065, 19, 35, 20, 0, -35 },
  { 1149, 20, 34, 20, 0, -34 },
  { 1234, 18, 35, 20, 2, -35 },
  { 1313, 18, 34, 20, 3, -34 },
  { 1390, 20, 35, 20, 0, -35 },
  { 1478, 18, 35, 20, 1, -35 },
  { 1557, 8, 26, 9, 0, -26 },
  { 1583, 10, 32, 9, -2, -26 },
  { 1623, 18, 20, 22, 2, -27 },
  { 1668, 18, 12, 22, 2, -23 },
  { 1695, 18, 20, 22, 2, -27 },
  { 1740, 14, 35, 14, 2, -35 },
  { 1802, 27, 38, 30, 2, -34 },
  { 1931, 19, 34, 19, -3, -34 },
  { 2012, 21, 34, 22, 1, -34 },
  { 2102, 21, 35, 20, 2, -35 },
  { 2194, 22, 34, 24, 1, -34 },
  { 2288, 20, 34, 19, 1, -34 },
  { 2373, 20, 34, 18, 1, -34 },
  { 2458, 24, 35, 25, 2, -35 },
  { 2563, 24, 34, 25, 1, -34 },
  { 2665, 15, 34, 10, -2, -34 },
  { 2729, 17, 42, 9, -7, -34 },
  { 2819, 23, 34, 20, 1, -34 },
  { 2917, 13, 34, 17, 1, -34 },
  { 2973, 31, 34, 32, 1, -34 },
  { 3105, 25, 34, 26, 1, -34 },
  { 3212, 22, 35, 26, 2, -35 },
  { 3309, 20, 34, 20, 1, -34 },
  { 3394, 22, 43, 26, 2, -35 },
  { 3513, 20, 34, 21, 1, -34 },
  { 3598, 21, 35, 19, -1, -35 },
  { 3690, 17, 34, 17, 4, -34 },
  { 3763, 23, 34, 24, 2, -34 },
  { 3861, 20, 34, 20, 4, -34 },
  { 3946, 31, 34, 32, 5, -34 },
  { 4078, 24, 34, 18, -3, -34 },
  { 4180, 17, 34, 17, 4, -34 },
  { 4253, 23, 34, 18, -2, -34 },
  { 4351, 18, 42, 14, -1, -34 },
  { 4446, 7, 34, 15, 5, -34 },
  { 4476, 17, 42, 14, -3, -34 },
  { 4566, 19, 18, 21, 1, -34 },
  { 4609, 15, 1, 14, -4, 5 },
  { 4611, 5, 8, 11, 7, -37 },
  { 4616, 18, 26, 21, 2, -26 },
  { 4675, 18, 36, 21, 1, -36 },
  { 4756, 15, 26, 16, 2, -26 },
  { 4805, 21, 36, 21, 2, -36 },
  { 4900, 15, 26, 18, 2, -26 },
  { 4949, 22, 49, 10, -6, -37 },
  { 5084, 20, 38, 21, 0, -26 },
  { 5179, 18, 36, 20, 1, -36 },
  { 5260, 9, 35, 9, 1, -35 },
  { 5300, 16, 47, 9, -6, -35 },
  { 5394, 18, 36, 17, 1, -36 },
  { 5475, 9, 36, 8, 1, -36 },
  { 5516, 28, 26, 31, 1, -26 },
  { 5607, 18, 26, 20, 1, -26 },
  { 5666, 17, 26, 21, 2, -26 },
  { 5722, 21, 37, 21, -2, -26 },
  { 5820, 18, 37, 21, 2, -26 },
  { 5904, 14, 26, 14, 1, -26 },
  { 5950, 16, 26, 16, 0, -26 },
  { 6002, 11, 32, 11, 1, -32 },
  { 6046, 18, 25, 20, 2, -25 },
  { 6103, 15, 25, 16, 3, -25 },
  { 6150, 25, 25, 26, 3, -25 },
  { 6229, 20, 25, 17, -2, -25 },
  { 6292, 24, 37, 16, -5, -25 },
  { 6403, 16, 25, 14, -1, -25 },
  { 6453, 17, 42, 15, 1, -34 },
  { 6543, 2, 49, 19, 9, -37 },
  { 6556, 17, 42, 15, -3, -34 },
  { 6646, 18, 4, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC48PT7B_H_
