#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x52, 0xBB, 0x00, 0x29, 0x5E, 0xA5, 0x7A, 0x94, 0x1B, 0x18,
  0x42, 0x19, 0x5C, 0x40, 0xCD, 0xB5, 0xFA, 0xB5, 0xB7, 0x32, 0x94, 0x46,
  0x56, 0x5E, 0xE0, 0x25, 0x29, 0x24, 0x88, 0x24, 0x92, 0x49, 0x50, 0xA7,
  0xA0, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xE0, 0x80, 0x08, 0x44, 0x22, 0x11,
  0x10, 0x35, 0x59, 0x99, 0x9E, 0x75, 0x24, 0x94, 0x71, 0x11, 0x24, 0x4E,
  0x71, 0x17, 0x11, 0x1E, 0x11, 0x35, 0x5D, 0x22, 0x3A, 0x10, 0xC1, 0x08,
  0x5C, 0x3A, 0x11, 0xE9, 0x4A, 0x5C, 0xF1, 0x22, 0x44, 0x88, 0x32, 0x52,
  0x65, 0x4A, 0x5C, 0x35, 0x59, 0x71, 0x1E, 0x40, 0x20, 0x20, 0x00, 0xB0,
  0x1B, 0x30, 0x70, 0xFF, 0xC0, 0xE0, 0x87, 0xC0, 0x71, 0x12, 0x44, 0x08,
  0x1C, 0x45, 0x6D, 0x5A, 0xB5, 0xAE, 0x40, 0x70, 0x08, 0x86, 0x53, 0xA5,
  0x31, 0x32, 0x52, 0xE5, 0x46, 0x5C, 0x78, 0x88, 0x88, 0x8E, 0x32, 0x52,
  0x94, 0xC6, 0x5C, 0x3A, 0x10, 0xE4, 0x42, 0x1C, 0x3A, 0x10, 0x87, 0x42,
  0x10, 0x7C, 0x21, 0x0B, 0x4A, 0x5E, 0x45, 0x14, 0x5E, 0x4A, 0x28, 0xA2,
  0x69, 0x24, 0xA4, 0x11, 0x11, 0x12, 0x22, 0x2C, 0x4A, 0x54, 0xC6, 0x52,
  0x52, 0x49, 0x25, 0x27, 0x22, 0x45, 0x9B, 0x36, 0xB5, 0x6D, 0x4A, 0x24,
  0x96, 0x59, 0x5A, 0x69, 0xA2, 0x74, 0x63, 0x18, 0xCA, 0x5C, 0x32, 0x52,
  0x97, 0x42, 0x10, 0x74, 0x63, 0x18, 0xCA, 0x54, 0x41, 0x00, 0x32, 0x52,
  0x97, 0x52, 0x52, 0x3A, 0x10, 0x82, 0x08, 0x5C, 0xF4, 0x44, 0x48, 0x88,
  0x8C, 0x63, 0x29, 0x4A, 0x5C, 0x99, 0x9A, 0xAC, 0x88, 0x93, 0x26, 0xCD,
  0xAD, 0x5B, 0x26, 0x48, 0x24, 0xA2, 0x84, 0x10, 0xC5, 0x24, 0x9A, 0xAC,
  0x48, 0x88, 0x78, 0x84, 0x44, 0x22, 0x1C, 0x74, 0x44, 0x48, 0x88, 0x8C,
  0xAA, 0x95, 0x31, 0x11, 0x12, 0x22, 0x2C, 0x21, 0x95, 0x10, 0xE0, 0x80,
  0x3A, 0x65, 0x29, 0x78, 0x44, 0x75, 0x59, 0x9E, 0x34, 0x88, 0x8E, 0x08,
  0x4E, 0x99, 0x4A, 0x5E, 0x35, 0xBC, 0x8F, 0x19, 0x0C, 0x42, 0x21, 0x08,
  0x42, 0x20, 0x3A, 0x65, 0x29, 0x78, 0x44, 0xC0, 0x44, 0x75, 0x59, 0x99,
  0x45, 0x6A, 0x20, 0x92, 0x92, 0x4A, 0x00, 0x44, 0x56, 0x46, 0xAA, 0x55,
  0x6A, 0x7E, 0xA5, 0x4C, 0x99, 0x52, 0x80, 0x75, 0x59, 0x99, 0x35, 0x99,
  0x9E, 0x75, 0x59, 0x9E, 0x88, 0x80, 0x3A, 0x65, 0x29, 0x78, 0x44, 0x20,
  0x74, 0x48, 0x88, 0x78, 0x42, 0x2E, 0x4D, 0x29, 0x30, 0x55, 0x59, 0x9E,
  0xB7, 0x69, 0x00, 0xAD, 0x7B, 0x6B, 0x50, 0x56, 0x24, 0xAA, 0x49, 0x4C,
  0x62, 0x10, 0x88, 0x80, 0x72, 0x44, 0x8C, 0x12, 0x24, 0xC4, 0x44, 0x84,
  0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22, 0x2C, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 3, 3, 3, 1, -8 },
  { 5, 5, 8, 5, 0, -8 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 5, 8, 7, 1, -8 },
  { 21, 5, 8, 5, 0, -8 },
  { 26, 1, 3, 2, 1, -8 },
  { 27, 3, 10, 3, 0, -8 },
  { 31, 3, 10, 3, -1, -8 },
  { 35, 4, 3, 4, 1, -8 },
  { 37, 5, 5, 5, 0, -6 },
  { 41, 1, 2, 2, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 1, 1, 2, 0, -1 },
  { 44, 5, 8, 3, -1, -8 },
  { 49, 4, 8, 5, 0, -8 },
  { 53, 3, 8, 5, 1, -8 },
  { 56, 4, 8, 5, 0, -8 },
  { 60, 4, 8, 5, 0, -8 },
  { 64, 4, 8, 5, 0, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 4, 8, 5, 1, -8 },
  { 82, 5, 8, 5, 0, -8 },
  { 87, 4, 8, 5, 0, -8 },
  { 91, 2, 6, 2, 0, -6 },
  { 93, 3, 7, 2, -1, -6 },
  { 96, 5, 4, 5, 0, -6 },
  { 99, 5, 2, 5, 0, -5 },
  { 101, 5, 4, 5, 0, -6 },
  { 104, 4, 8, 3, 0, -8 },
  { 108, 7, 9, 7, 0, -8 },
  { 116, 5, 8, 4, -1, -8 },
  { 121, 5, 8, 5, 0, -8 },
  { 126, 4, 8, 5, 1, -8 },
  { 130, 5, 8, 5, 0, -8 },
  { 135, 5, 8, 4, 0, -8 },
  { 140, 5, 8, 4, 0, -8 },
  { 145, 5, 8, 6, 1, -8 },
  { 150, 6, 8, 6, 0, -8 },
  { 156, 3, 8, 2, 0, -8 },
  { 159, 4, 10, 2, -2, -8 },
  { 164, 5, 8, 5, 0, -8 },
  { 169, 3, 8, 4, 0, -8 },
  { 172, 7, 8, 7, 0, -8 },
  { 179, 6, 8, 6, 0, -8 },
  { 185, 5, 8, 6, 1, -8 },
  { 190, 5, 8, 5, 0, -8 },
  { 195, 5, 10, 6, 1, -8 },
  { 202, 5, 8, 5, 0, -8 },
  { 207, 5, 8, 4, 0, -8 },
  { 212, 4, 8, 4, 1, -8 },
  { 216, 5, 8, 6, 1, -8 },
  { 221, 4, 8, 5, 1, -8 },
  { 225, 7, 8, 7, 1, -8 },
  { 232, 6, 8, 4, -1, -8 },
  { 238, 4, 8, 4, 1, -8 },
  { 242, 5, 8, 4, 0, -8 },
  { 247, 4, 10, 3, 0, -8 },
  { 252, 2, 8, 4, 1, -8 },
  { 254, 4, 10, 3, -1, -8 },
  { 259, 5, 4, 5, 0, -8 },
  { 262, 3, 1, 3, -1, 1 },
  { 263, 1, 1, 2, 2, -8 },
  { 264, 5, 6, 5, 0, -6 },
  { 268, 4, 8, 5, 0, -8 },
  { 272, 4, 6, 4, 0, -6 },
  { 275, 5, 8, 5, 0, -8 },
  { 280, 4, 6, 4, 0, -6 },
  { 283, 5, 11, 2, -1, -8 },
  { 290, 5, 9, 5, 0, -6 },
  { 296, 4, 8, 5, 0, -8 },
  { 300, 2, 8, 2, 0, -8 },
  { 302, 3, 11, 2, -1, -8 },
  { 307, 4, 8, 4, 0, -8 },
  { 311, 2, 8, 2, 0, -8 },
  { 313, 7, 6, 7, 0, -6 },
  { 319, 4, 6, 5, 0, -6 },
  { 322, 4, 6, 5, 0, -6 },
  { 325, 4, 9, 5, 0, -6 },
  { 330, 5, 9, 5, 0, -6 },
  { 336, 4, 6, 3, 0, -6 },
  { 339, 4, 6, 4, 0, -6 },
  { 342, 3, 7, 3, 0, -7 },
  { 345, 4, 6, 5, 0, -6 },
  { 348, 3, 6, 4, 1, -6 },
  { 351, 5, 6, 6, 1, -6 },
  { 355, 4, 6, 4, 0, -6 },
  { 358, 5, 9, 4, -1, -6 },
  { 364, 4, 6, 3, 0, -6 },
  { 367, 4, 10, 4, 0, -8 },
  { 372, 1, 11, 4, 2, -8 },
  { 374, 4, 10, 4, -1, -8 },
  { 379, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC11PT7B_H_
