#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x80,
  0x00, 0x43, 0x00, 0x25, 0x14, 0x92, 0x49, 0x28, 0x80, 0x02, 0x20, 0x22,
  0x04, 0x40, 0x44, 0x04, 0x43, 0xFF, 0x08, 0x80, 0x88, 0x08, 0x81, 0x10,
  0x11, 0x0F, 0xFC, 0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x44, 0x04, 0x40,
  0x01, 0x00, 0x40, 0x78, 0x69, 0x12, 0x08, 0x82, 0x20, 0x50, 0x14, 0x03,
  0x00, 0x60, 0x14, 0x09, 0x02, 0x20, 0x90, 0x24, 0x8A, 0x1F, 0x01, 0x00,
  0x40, 0x1C, 0x11, 0x20, 0x88, 0x88, 0x88, 0x84, 0x44, 0x22, 0x42, 0x12,
  0x10, 0xA6, 0x89, 0x4A, 0x54, 0x5D, 0x22, 0x09, 0x10, 0x90, 0x84, 0x84,
  0x44, 0x42, 0x22, 0x21, 0x12, 0x07, 0x00, 0x07, 0x01, 0x10, 0x22, 0x04,
  0x41, 0x08, 0x12, 0x02, 0xC0, 0x70, 0x0C, 0x02, 0x80, 0x91, 0xA1, 0x24,
  0x25, 0x07, 0x20, 0x64, 0x08, 0xC2, 0x8F, 0x90, 0x6A, 0xA8, 0x06, 0x08,
  0x20, 0x83, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x04, 0x08, 0x00, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x41, 0x04,
  0x18, 0x00, 0x08, 0x08, 0x90, 0x77, 0x18, 0x28, 0xC8, 0x04, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x24, 0xA5, 0x00, 0xF8, 0x70, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x08, 0x44, 0x24, 0x12, 0x0A, 0x05,
  0x02, 0x81, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x84,
  0x3C, 0x00, 0x08, 0xDB, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x00, 0x07, 0xC1, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x1F, 0xF0, 0x0F, 0x84, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x04, 0x1E, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x3F, 0x00, 0x00, 0xC0, 0x30, 0x14, 0x0A, 0x02, 0x81, 0x20, 0x88, 0x22,
  0x11, 0x08, 0x42, 0x11, 0x04, 0x82, 0x7F, 0xE0, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0xF0, 0x23,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x82, 0x3F, 0x00,
  0x07, 0xC2, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x78, 0x63, 0x30,
  0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x84, 0x1E, 0x00, 0x3F,
  0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x00, 0x07, 0x82,
  0x11, 0x04, 0x41, 0x10, 0x44, 0x11, 0x08, 0x24, 0x06, 0x06, 0x82, 0x11,
  0x04, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x07, 0x82, 0x21,
  0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x61, 0xE8, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x3E, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x00, 0x04, 0xC0, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x46, 0x21,
  0x10, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x20, 0x30, 0x30, 0x30, 0x00, 0x3C,
  0x84, 0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x40, 0x82, 0x04, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x01, 0xE0, 0x18, 0x60, 0x80, 0x84, 0x01, 0x20, 0x04,
  0x87, 0x14, 0x24, 0x51, 0x11, 0x48, 0x46, 0x21, 0x18, 0x88, 0xA4, 0x22,
  0x90, 0x8A, 0x26, 0x48, 0xEE, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x0F, 0xC0, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90,
  0x22, 0x04, 0x41, 0x08, 0x3F, 0x08, 0x21, 0x04, 0x60, 0x88, 0x11, 0x02,
  0x40, 0x38, 0x04, 0x0F, 0x81, 0x0C, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44,
  0x10, 0x86, 0x3F, 0x04, 0x30, 0x83, 0x10, 0x22, 0x04, 0x80, 0x90, 0x22,
  0x04, 0x41, 0x1F, 0xC0, 0x03, 0xE1, 0x80, 0x60, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x84, 0x08, 0x21, 0x01, 0x10,
  0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20,
  0x64, 0x04, 0x40, 0x84, 0x18, 0x43, 0x0F, 0xC0, 0x0F, 0xE1, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x3F, 0x84, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xC0, 0x0F, 0xE1, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x07, 0xF0, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x00, 0x03, 0xF0,
  0xC1, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x1E, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x44, 0x04, 0x60, 0x83,
  0xF8, 0x08, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x40,
  0x42, 0x02, 0x3F, 0xE1, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x20, 0x21,
  0x01, 0x08, 0x08, 0x40, 0x44, 0x06, 0x00, 0x0F, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0xF0, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x87, 0x80, 0x08, 0x10, 0x82, 0x08, 0x41, 0x08, 0x11, 0x81, 0x10, 0x12,
  0x01, 0x40, 0x2C, 0x03, 0x40, 0x24, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41,
  0x04, 0x10, 0x41, 0x08, 0x08, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0xFC, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0xC2, 0x80, 0x61, 0x40, 0x50, 0xA0, 0x28, 0x50, 0x24,
  0x28, 0x14, 0x24, 0x12, 0x12, 0x09, 0x09, 0x08, 0x84, 0x44, 0x82, 0x24,
  0x42, 0x12, 0x21, 0x0A, 0x10, 0x85, 0x08, 0x43, 0x08, 0x41, 0x04, 0x00,
  0x08, 0x04, 0x30, 0x20, 0xC0, 0x85, 0x02, 0x14, 0x08, 0x48, 0x41, 0x21,
  0x04, 0x84, 0x22, 0x10, 0x84, 0x42, 0x12, 0x08, 0x48, 0x21, 0x21, 0x02,
  0x84, 0x0A, 0x10, 0x30, 0x40, 0xC2, 0x01, 0x00, 0x07, 0xC0, 0x82, 0x10,
  0x23, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x08, 0x41, 0x03, 0xE0, 0x0F,
  0x01, 0x08, 0x21, 0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x20, 0x84,
  0x60, 0xF0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x00,
  0x07, 0xC0, 0x82, 0x10, 0x23, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x08,
  0x41, 0x03, 0xE0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x0F, 0x81, 0x08,
  0x21, 0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x20, 0x87, 0xE0, 0x88,
  0x11, 0x02, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x10, 0x30, 0x07, 0xC6,
  0x11, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x82, 0x3F, 0x00, 0xFF, 0x84, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x00, 0x10, 0x11, 0x01, 0x10, 0x12, 0x02,
  0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04,
  0x80, 0x88, 0x08, 0x80, 0x88, 0x10, 0x41, 0x07, 0xE0, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x81, 0x20, 0x48, 0x22, 0x08, 0x44, 0x11, 0x04, 0xC1, 0x20,
  0x48, 0x14, 0x05, 0x01, 0x80, 0x60, 0x10, 0x00, 0x80, 0x80, 0xC0, 0x40,
  0xA0, 0x60, 0x50, 0x30, 0x48, 0x28, 0x24, 0x14, 0x22, 0x12, 0x11, 0x09,
  0x08, 0x84, 0x88, 0x44, 0x44, 0x22, 0x24, 0x12, 0x12, 0x09, 0x09, 0x04,
  0x85, 0x02, 0x82, 0x81, 0x41, 0x80, 0xC0, 0xC0, 0x60, 0x40, 0x00, 0x08,
  0x10, 0x82, 0x08, 0x20, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x60, 0x02,
  0x00, 0x60, 0x0A, 0x00, 0xA0, 0x12, 0x02, 0x10, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x10, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x22, 0x21, 0x20, 0x90, 0x50,
  0x18, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x00, 0x0F,
  0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0F, 0xF0, 0x0F, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x07, 0x80, 0x92, 0x49, 0x22, 0x49, 0x24, 0x49, 0x24, 0x07, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x87, 0xC0, 0x04,
  0x03, 0x00, 0xA0, 0x48, 0x11, 0x08, 0x42, 0x11, 0x02, 0x80, 0xA0, 0x10,
  0xFF, 0xA5, 0x1F, 0xC8, 0x66, 0x09, 0x02, 0x40, 0xA0, 0x48, 0x12, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x18, 0x7A, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x78, 0x61, 0x10, 0x4C, 0x12, 0x04, 0x81, 0x20, 0x50,
  0x14, 0x09, 0x02, 0x41, 0x18, 0xCB, 0xE0, 0x1F, 0x20, 0x60, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x08, 0x86, 0xD1, 0x0C, 0x60, 0x88, 0x11, 0x02, 0x40,
  0x88, 0x11, 0x02, 0x20, 0x44, 0x18, 0x82, 0x10, 0xC1, 0xE8, 0x00, 0x1F,
  0x21, 0x41, 0x41, 0x42, 0x8C, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C,
  0x00, 0xF0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x0F, 0x80, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0xC0, 0x00, 0x0F, 0xA2, 0x18, 0xC1, 0x10, 0x22, 0x04, 0x81, 0x10, 0x22,
  0x04, 0x40, 0x88, 0x31, 0x04, 0x21, 0x83, 0xD0, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x10, 0x83, 0xE0, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x78, 0x61, 0x10, 0x48, 0x12, 0x08, 0x82, 0x20, 0x90, 0x24, 0x09,
  0x04, 0x41, 0x10, 0x48, 0x10, 0x08, 0x40, 0x00, 0x08, 0x42, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x11, 0x08, 0x44, 0x22, 0x09, 0x82, 0x40, 0xA0, 0x34, 0x19, 0x04, 0x41,
  0x10, 0x42, 0x10, 0x88, 0x20, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x20, 0x17, 0xBE, 0x31, 0x84, 0x43, 0x09, 0x04,
  0x12, 0x08, 0x24, 0x10, 0x48, 0x21, 0x20, 0x82, 0x41, 0x04, 0x82, 0x09,
  0x04, 0x12, 0x10, 0x48, 0x20, 0x80, 0x17, 0x86, 0x11, 0x04, 0x81, 0x20,
  0x88, 0x22, 0x09, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0x00, 0x1F,
  0x10, 0x98, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x90,
  0x87, 0x80, 0x0B, 0xC1, 0x84, 0x20, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x09,
  0x01, 0x20, 0x44, 0x08, 0x82, 0x18, 0xC5, 0xF0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x48, 0x62, 0x09, 0x02, 0x40, 0xA0,
  0x48, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x18, 0x7A, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x17, 0x18, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0xF8, 0x11, 0x09, 0xF2, 0x21, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x1C, 0x20, 0x90, 0x50, 0x28, 0x24, 0x12, 0x09,
  0x05, 0x02, 0x82, 0x41, 0x21, 0x90, 0xCF, 0xA0, 0x81, 0x81, 0x82, 0x42,
  0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x83, 0x0C, 0x18,
  0x61, 0x45, 0x0A, 0x28, 0x92, 0x24, 0x91, 0x24, 0x8A, 0x28, 0x51, 0x43,
  0x0C, 0x18, 0x60, 0x83, 0x04, 0x10, 0x00, 0x10, 0x44, 0x20, 0x90, 0x24,
  0x0A, 0x01, 0x00, 0xC0, 0x30, 0x12, 0x08, 0x82, 0x21, 0x08, 0x81, 0x00,
  0x04, 0x18, 0x20, 0x81, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x38, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x0F, 0xE0, 0x03, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x60, 0xC0, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x70, 0x60, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x07,
  0x00, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 18, 5, 0, -18 },
  { 15, 6, 7, 7, 2, -18 },
  { 21, 12, 18, 11, 0, -18 },
  { 48, 10, 20, 10, 0, -19 },
  { 73, 13, 18, 15, 1, -18 },
  { 103, 11, 18, 11, 0, -18 },
  { 128, 2, 7, 4, 3, -18 },
  { 130, 7, 22, 6, 1, -18 },
  { 150, 7, 22, 6, -2, -18 },
  { 170, 8, 8, 10, 3, -19 },
  { 178, 10, 12, 11, 1, -15 },
  { 193, 3, 6, 4, -1, -3 },
  { 196, 5, 1, 7, 1, -7 },
  { 197, 2, 2, 5, 0, -2 },
  { 198, 10, 18, 8, -1, -18 },
  { 221, 9, 18, 10, 1, -18 },
  { 242, 5, 18, 10, 3, -18 },
  { 254, 11, 18, 10, -1, -18 },
  { 279, 10, 18, 10, 0, -18 },
  { 302, 10, 18, 10, 0, -18 },
  { 325, 10, 18, 10, 0, -18 },
  { 348, 10, 18, 10, 1, -18 },
  { 371, 10, 18, 10, 1, -18 },
  { 394, 10, 18, 10, 0, -18 },
  { 417, 10, 18, 10, 0, -18 },
  { 440, 4, 13, 5, 0, -13 },
  { 447, 5, 16, 5, -1, -13 },
  { 457, 10, 10, 11, 1, -14 },
  { 470, 10, 6, 11, 1, -12 },
  { 478, 10, 10, 11, 1, -14 },
  { 491, 7, 18, 7, 1, -18 },
  { 507, 14, 20, 15, 1, -18 },
  { 542, 11, 18, 10, -2, -18 },
  { 567, 11, 18, 11, 0, -18 },
  { 592, 11, 18, 11, 1, -18 },
  { 617, 12, 18, 12, 0, -18 },
  { 644, 11, 18, 10, 0, -18 },
  { 669, 11, 18, 9, 0, -18 },
  { 694, 12, 18, 13, 1, -18 },
  { 721, 13, 18, 13, 0, -18 },
  { 751, 8, 18, 5, -1, -18 },
  { 769, 9, 22, 5, -4, -18 },
  { 794, 12, 18, 10, 0, -18 },
  { 821, 7, 18, 9, 0, -18 },
  { 837, 17, 18, 17, 0, -18 },
  { 876, 14, 18, 13, 0, -18 },
  { 908, 12, 18, 13, 1, -18 },
  { 935, 11, 18, 11, 0, -18 },
  { 960, 12, 22, 13, 1, -18 },
  { 993, 11, 18, 11, 0, -18 },
  { 1018, 10, 18, 10, 0, -18 },
  { 1041, 9, 18, 9, 2, -18 },
  { 1062, 12, 18, 13, 1, -18 },
  { 1089, 10, 18, 10, 2, -18 },
  { 1112, 17, 18, 17, 2, -18 },
  { 1151, 12, 18, 9, -1, -18 },
  { 1178, 9, 18, 9, 2, -18 },
  { 1199, 12, 18, 9, -1, -18 },
  { 1226, 9, 22, 7, 0, -18 },
  { 1251, 3, 18, 8, 3, -18 },
  { 1258, 9, 22, 7, -2, -18 },
  { 1283, 10, 10, 11, 1, -18 },
  { 1296, 8, 1, 8, -2, 2 },
  { 1297, 2, 4, 6, 4, -19 },
  { 1298, 10, 13, 11, 1, -13 },
  { 1315, 10, 19, 11, 0, -19 },
  { 1339, 8, 13, 8, 1, -13 },
  { 1352, 11, 19, 11, 1, -19 },
  { 1379, 8, 13, 10, 1, -13 },
  { 1392, 12, 25, 5, -3, -19 },
  { 1430, 11, 19, 11, 0, -13 },
  { 1457, 10, 19, 11, 0, -19 },
  { 1481, 5, 18, 4, 0, -18 },
  { 1493, 8, 24, 5, -3, -18 },
  { 1517, 10, 19, 9, 0, -19 },
  { 1541, 5, 19, 4, 0, -19 },
  { 1553, 15, 13, 16, 0, -13 },
  { 1578, 10, 13, 11, 0, -13 },
  { 1595, 9, 13, 11, 1, -13 },
  { 1610, 11, 19, 11, -1, -13 },
  { 1637, 10, 19, 11, 1, -13 },
  { 1661, 8, 13, 7, 0, -13 },
  { 1674, 8, 13, 8, 0, -13 },
  { 1687, 5, 16, 6, 1, -16 },
  { 1697, 9, 13, 11, 1, -13 },
  { 1712, 8, 13, 8, 1, -13 },
  { 1725, 13, 13, 13, 1, -13 },
  { 1747, 10, 13, 9, -1, -13 },
  { 1764, 13, 19, 8, -3, -13 },
  { 1795, 9, 13, 8, -1, -13 },
  { 1810, 8, 22, 8, 1, -18 },
  { 1832, 1, 25, 10, 5, -19 },
  { 1836, 9, 22, 8, -2, -18 },
  { 1861, 10, 2, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC25PT7B_H_
