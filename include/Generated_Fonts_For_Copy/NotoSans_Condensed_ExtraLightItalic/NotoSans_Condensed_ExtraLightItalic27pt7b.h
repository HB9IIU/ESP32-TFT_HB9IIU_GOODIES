#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x20, 0x00, 0x04,
  0x20, 0x4D, 0x28, 0xA2, 0x8A, 0x49, 0x00, 0x03, 0x10, 0x11, 0x00, 0x88,
  0x04, 0x40, 0x42, 0x1F, 0xFC, 0x11, 0x01, 0x08, 0x08, 0x80, 0x44, 0x04,
  0x20, 0x22, 0x0F, 0xFE, 0x08, 0x80, 0x84, 0x04, 0x40, 0x22, 0x02, 0x10,
  0x11, 0x00, 0x00, 0x80, 0x20, 0x04, 0x03, 0xF1, 0x90, 0x22, 0x04, 0x80,
  0x90, 0x12, 0x03, 0x40, 0x30, 0x03, 0x00, 0x50, 0x09, 0x01, 0x20, 0x44,
  0x08, 0x81, 0x12, 0x2C, 0x3E, 0x01, 0x00, 0x20, 0x04, 0x00, 0x18, 0x01,
  0x60, 0x91, 0x08, 0x88, 0x48, 0x44, 0x42, 0x22, 0x12, 0x10, 0x90, 0x89,
  0x34, 0x52, 0x64, 0xA3, 0x69, 0x14, 0x50, 0x84, 0x84, 0x24, 0x22, 0x21,
  0x21, 0x11, 0x08, 0x90, 0x49, 0x83, 0xC0, 0x01, 0x00, 0xD0, 0x31, 0x04,
  0x20, 0x84, 0x11, 0x82, 0x20, 0x48, 0x0A, 0x00, 0x80, 0x70, 0x19, 0x06,
  0x22, 0x84, 0x60, 0x54, 0x0A, 0x80, 0x90, 0x33, 0x0A, 0x3E, 0x20, 0x5A,
  0xA8, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x02,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x08, 0xC8,
  0x3F, 0x18, 0x28, 0xC4, 0x06, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x0F, 0xFC, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x32, 0x24,
  0x48, 0xFC, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x02, 0x03, 0x61, 0x8C, 0x41, 0x20,
  0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x38, 0x0A, 0x02, 0x80, 0xA0, 0x28,
  0x12, 0x04, 0x82, 0x20, 0x8C, 0x41, 0xE0, 0x0C, 0x56, 0xB2, 0x08, 0x21,
  0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x00, 0x01, 0x80,
  0x66, 0x08, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x0F, 0xF8, 0x01, 0x01, 0xD8, 0x41, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0xE0, 0x3C, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x22, 0x0C, 0x7E, 0x00, 0x00, 0x60, 0x14, 0x03,
  0x00, 0xA0, 0x24, 0x08, 0x81, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x20,
  0x84, 0x11, 0xFF, 0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0F,
  0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x60, 0x33, 0x00,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x10, 0x63,
  0xF0, 0x00, 0x00, 0x81, 0xD0, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x4E, 0x1C, 0x4A, 0x0B, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20,
  0xC4, 0x21, 0xF0, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x00, 0x01, 0x01, 0xD8, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44,
  0x08, 0x82, 0x08, 0x80, 0xE0, 0x38, 0x18, 0x86, 0x08, 0x81, 0x20, 0x24,
  0x04, 0x80, 0x90, 0x11, 0x04, 0x1F, 0x00, 0x01, 0x01, 0xD8, 0x21, 0x08,
  0x11, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x64, 0x08, 0x83, 0x0D, 0xA0,
  0x44, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x7C, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x0C, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x20, 0x84, 0x10, 0x80, 0x00, 0x40, 0x60,
  0x60, 0x60, 0x60, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00, 0x08, 0x36,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x03, 0xF8, 0x08, 0x08, 0x20, 0x10,
  0x80, 0x12, 0x00, 0x24, 0x1C, 0x50, 0xC8, 0xA3, 0x11, 0x44, 0x23, 0x08,
  0x86, 0x21, 0x0C, 0x42, 0x28, 0x84, 0x51, 0x19, 0x22, 0x52, 0x43, 0x38,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x40,
  0x14, 0x02, 0x80, 0x90, 0x12, 0x06, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84,
  0x20, 0x87, 0xF1, 0x02, 0x20, 0x4C, 0x09, 0x01, 0x60, 0x28, 0x07, 0x00,
  0x80, 0x0F, 0xE0, 0x83, 0x08, 0x10, 0x81, 0x18, 0x11, 0x01, 0x10, 0x21,
  0x06, 0x1F, 0x82, 0x18, 0x20, 0x42, 0x04, 0x20, 0x22, 0x06, 0x40, 0x44,
  0x04, 0x40, 0xC4, 0x18, 0xFE, 0x00, 0x00, 0x40, 0x33, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0xF0,
  0x0F, 0xC0, 0x41, 0x82, 0x04, 0x10, 0x31, 0x80, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x19, 0x00, 0x88, 0x04, 0x40, 0x22, 0x03, 0x10, 0x11, 0x01,
  0x88, 0x08, 0x40, 0x82, 0x18, 0x3F, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xC2, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0xF8, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0E, 0xF0, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x1F,
  0x30, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x30, 0x08, 0x40, 0x21, 0x01,
  0x02, 0x04, 0x07, 0xF0, 0x0C, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x18,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x1F, 0xF0, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x0C,
  0x04, 0x00, 0x0F, 0x82, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x3E, 0x00,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x0C, 0x18, 0x40, 0x82, 0x08, 0x10,
  0x81, 0x88, 0x08, 0x80, 0x4C, 0x02, 0xC0, 0x14, 0x01, 0x50, 0x0C, 0x80,
  0x44, 0x02, 0x20, 0x10, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x30,
  0x20, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x14, 0x30, 0x06, 0x14, 0x02, 0x85, 0x00, 0xA1, 0x20, 0x48,
  0x48, 0x12, 0x12, 0x09, 0x08, 0x82, 0x42, 0x21, 0x10, 0x88, 0x44, 0x22,
  0x22, 0x08, 0x88, 0x84, 0x24, 0x21, 0x09, 0x08, 0x42, 0x82, 0x10, 0x61,
  0x0C, 0x10, 0x40, 0x0C, 0x02, 0x18, 0x08, 0x30, 0x10, 0x50, 0x21, 0xA0,
  0x42, 0x41, 0x04, 0x82, 0x08, 0x84, 0x11, 0x08, 0x42, 0x10, 0x84, 0x41,
  0x04, 0x82, 0x09, 0x04, 0x12, 0x10, 0x24, 0x20, 0x30, 0x40, 0x60, 0x80,
  0xC3, 0x01, 0x80, 0x01, 0x80, 0x33, 0x02, 0x04, 0x20, 0x21, 0x00, 0x90,
  0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01,
  0x40, 0x1A, 0x00, 0x90, 0x04, 0x40, 0x42, 0x06, 0x18, 0x60, 0x7E, 0x00,
  0x0F, 0xC0, 0x82, 0x08, 0x20, 0x81, 0x18, 0x11, 0x03, 0x10, 0x21, 0x02,
  0x10, 0x42, 0x08, 0x3F, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x33, 0x02, 0x04, 0x20, 0x21,
  0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x05, 0x80,
  0x28, 0x01, 0x40, 0x1A, 0x00, 0x90, 0x04, 0xC0, 0x42, 0x06, 0x18, 0x60,
  0x7E, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xC0,
  0x82, 0x08, 0x20, 0x81, 0x18, 0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x42,
  0x38, 0x3E, 0x02, 0x20, 0x21, 0x02, 0x10, 0x41, 0x04, 0x10, 0x40, 0x84,
  0x08, 0xC0, 0x80, 0x01, 0x01, 0xDC, 0x60, 0x08, 0x03, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x22, 0x0C, 0x7E, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x10, 0x08, 0x80, 0x44, 0x02,
  0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x06, 0x60, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x44, 0x04, 0x40, 0x22, 0x01, 0x10, 0x18, 0xC0, 0x82, 0x08,
  0x0F, 0x80, 0x80, 0x28, 0x09, 0x01, 0x20, 0x64, 0x08, 0x83, 0x10, 0x42,
  0x08, 0x42, 0x08, 0x41, 0x10, 0x22, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xA0, 0x60, 0x50,
  0x50, 0x28, 0x28, 0x24, 0x14, 0x12, 0x12, 0x11, 0x09, 0x08, 0x88, 0x8C,
  0x44, 0x44, 0x24, 0x22, 0x12, 0x12, 0x09, 0x09, 0x05, 0x05, 0x02, 0x82,
  0x81, 0x81, 0x40, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x20, 0x00, 0x04, 0x0C,
  0x18, 0x20, 0x21, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x01, 0x20, 0x04, 0x80, 0x22, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x41, 0x81, 0x0C, 0x04, 0x00, 0x80, 0xD0, 0x24, 0x11,
  0x04, 0x42, 0x10, 0x84, 0x40, 0xB0, 0x28, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x3F, 0xE0, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x03, 0xE0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x22, 0x10, 0x07, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x0F, 0x80, 0x06, 0x01, 0x80, 0x90,
  0x64, 0x11, 0x08, 0x22, 0x09, 0x03, 0x40, 0x60, 0x10, 0xFF, 0x91, 0x22,
  0x06, 0x06, 0x53, 0x0C, 0x83, 0x40, 0xD0, 0x24, 0x0A, 0x02, 0x80, 0xA0,
  0x68, 0x12, 0x04, 0x83, 0x31, 0x47, 0x90, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x40, 0xB6, 0x18, 0x63, 0x04, 0x40, 0x98, 0x12,
  0x02, 0x40, 0x48, 0x13, 0x02, 0x40, 0x48, 0x11, 0x82, 0x30, 0x89, 0xE0,
  0x02, 0x8E, 0x8C, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x02, 0x01, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x06, 0x21, 0x94, 0x30, 0xC2, 0x0C, 0x40, 0xC4, 0x0C, 0x40,
  0x88, 0x08, 0x80, 0x88, 0x18, 0x81, 0x08, 0x10, 0x83, 0x0C, 0x50, 0x79,
  0x00, 0x06, 0x0C, 0x8C, 0x24, 0x14, 0x0A, 0x09, 0x09, 0xF8, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0xF8, 0x00, 0x30, 0x0D, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x7C, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0xE0, 0x00, 0x03,
  0x10, 0xCA, 0x18, 0x61, 0x06, 0x20, 0x62, 0x04, 0x20, 0x44, 0x04, 0x40,
  0x44, 0x0C, 0x40, 0x84, 0x08, 0x41, 0x86, 0x28, 0x3C, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0xFC, 0x00, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x10, 0x5B, 0x18, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x0D, 0x82, 0x40, 0x90, 0x24, 0x09, 0x04, 0x81, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x08,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xF0, 0x00, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x08, 0x82, 0x10, 0x82, 0x20, 0x48,
  0x12, 0x02, 0xC0, 0x58, 0x0D, 0x03, 0x20, 0x42, 0x08, 0x41, 0x08, 0x21,
  0x08, 0x10, 0x04, 0x30, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x18, 0x41, 0x04, 0x10, 0x80, 0x01, 0x04, 0x16, 0xDB, 0x18, 0x61,
  0x10, 0x61, 0x10, 0x41, 0x20, 0x41, 0x20, 0x41, 0x20, 0x81, 0x20, 0x82,
  0x60, 0x82, 0x40, 0x82, 0x41, 0x02, 0x41, 0x02, 0x41, 0x04, 0x81, 0x04,
  0x01, 0x05, 0xB1, 0x84, 0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x90,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x48, 0x10, 0x06, 0x06, 0xE3, 0x08, 0x82,
  0x40, 0x50, 0x14, 0x0E, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x83, 0x30,
  0x87, 0xC0, 0x00, 0x80, 0xB6, 0x0C, 0x30, 0xC1, 0x08, 0x11, 0x81, 0x10,
  0x11, 0x01, 0x10, 0x21, 0x02, 0x20, 0x22, 0x04, 0x20, 0x43, 0x08, 0x4F,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x06, 0x23,
  0x28, 0xC3, 0x10, 0x64, 0x0C, 0x81, 0x90, 0x24, 0x04, 0x80, 0x90, 0x32,
  0x04, 0x40, 0x88, 0x31, 0x8A, 0x1E, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x01, 0x0B, 0x46, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x06, 0x0C, 0xC8, 0x04,
  0x02, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x40, 0x24, 0x23,
  0xF0, 0x10, 0x41, 0x08, 0x7C, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x83, 0x80, 0x20, 0x48, 0x12, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09,
  0x04, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x86, 0x1E, 0x80, 0xC0, 0xA0, 0x90,
  0x48, 0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14, 0x0E, 0x06, 0x03,
  0x00, 0x82, 0x0E, 0x18, 0x28, 0x61, 0x22, 0x84, 0x8A, 0x12, 0x28, 0x89,
  0x22, 0x24, 0x90, 0xA2, 0x42, 0x8A, 0x0C, 0x28, 0x30, 0xA0, 0xC3, 0x02,
  0x0C, 0x00, 0x10, 0x61, 0x08, 0x22, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x00,
  0x60, 0x0A, 0x02, 0x40, 0x88, 0x10, 0x84, 0x11, 0x02, 0x00, 0x04, 0x0C,
  0x10, 0x20, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10,
  0x04, 0x80, 0x12, 0x00, 0x50, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x2C, 0x00, 0x40, 0x00, 0x1F,
  0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x3F, 0x80, 0x03, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x10, 0x03, 0x03, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x0F, 0x00, 0x38, 0x73, 0x98, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 8, 3, -19 },
  { 19, 13, 19, 12, 0, -19 },
  { 50, 11, 23, 11, 0, -21 },
  { 82, 13, 20, 16, 2, -20 },
  { 115, 11, 20, 12, 0, -20 },
  { 143, 2, 7, 4, 3, -19 },
  { 145, 7, 23, 7, 1, -19 },
  { 166, 8, 23, 7, -2, -19 },
  { 189, 8, 8, 11, 3, -20 },
  { 197, 10, 13, 12, 1, -16 },
  { 214, 4, 6, 5, -1, -3 },
  { 217, 6, 1, 7, 1, -8 },
  { 218, 1, 2, 5, 1, -2 },
  { 219, 11, 19, 8, -1, -19 },
  { 246, 10, 20, 11, 1, -20 },
  { 271, 6, 19, 11, 3, -19 },
  { 286, 12, 20, 11, -1, -20 },
  { 316, 11, 20, 11, 0, -20 },
  { 344, 11, 19, 11, 0, -19 },
  { 371, 11, 19, 11, 0, -19 },
  { 398, 10, 20, 11, 1, -20 },
  { 423, 10, 19, 11, 2, -19 },
  { 447, 11, 20, 11, 0, -20 },
  { 475, 11, 20, 11, 0, -20 },
  { 503, 5, 14, 5, 0, -14 },
  { 512, 6, 17, 5, -1, -14 },
  { 525, 10, 11, 12, 1, -15 },
  { 539, 10, 7, 12, 1, -13 },
  { 548, 10, 11, 12, 1, -15 },
  { 562, 8, 20, 8, 1, -20 },
  { 582, 15, 21, 17, 1, -19 },
  { 622, 11, 19, 11, -2, -19 },
  { 649, 12, 19, 12, 0, -19 },
  { 678, 12, 20, 11, 1, -20 },
  { 708, 13, 19, 13, 0, -19 },
  { 739, 12, 19, 11, 0, -19 },
  { 768, 12, 19, 10, 0, -19 },
  { 797, 14, 20, 14, 1, -20 },
  { 832, 14, 19, 14, 0, -19 },
  { 866, 9, 19, 6, -1, -19 },
  { 888, 10, 24, 5, -4, -19 },
  { 918, 13, 19, 11, 0, -19 },
  { 949, 8, 19, 10, 0, -19 },
  { 968, 18, 19, 18, 0, -19 },
  { 1011, 15, 19, 14, 0, -19 },
  { 1047, 13, 20, 14, 1, -20 },
  { 1080, 12, 19, 11, 0, -19 },
  { 1109, 13, 25, 14, 1, -20 },
  { 1150, 12, 19, 12, 0, -19 },
  { 1179, 11, 20, 11, 0, -20 },
  { 1207, 10, 19, 10, 2, -19 },
  { 1231, 13, 19, 14, 1, -19 },
  { 1262, 11, 19, 11, 2, -19 },
  { 1289, 17, 19, 18, 3, -19 },
  { 1330, 14, 19, 10, -2, -19 },
  { 1364, 10, 19, 10, 2, -19 },
  { 1388, 13, 19, 10, -1, -19 },
  { 1419, 9, 23, 8, 0, -19 },
  { 1445, 4, 19, 9, 3, -19 },
  { 1455, 10, 23, 8, -2, -19 },
  { 1484, 10, 10, 12, 1, -19 },
  { 1497, 8, 1, 8, -2, 2 },
  { 1498, 3, 5, 6, 4, -21 },
  { 1500, 10, 15, 12, 1, -15 },
  { 1519, 11, 21, 12, 0, -21 },
  { 1548, 9, 15, 9, 1, -15 },
  { 1565, 12, 21, 12, 1, -21 },
  { 1597, 9, 15, 10, 1, -15 },
  { 1614, 12, 27, 6, -3, -21 },
  { 1655, 12, 21, 12, 0, -15 },
  { 1687, 10, 21, 12, 0, -21 },
  { 1714, 6, 19, 5, 0, -19 },
  { 1729, 10, 25, 5, -4, -19 },
  { 1761, 11, 21, 10, 0, -21 },
  { 1790, 6, 21, 5, 0, -21 },
  { 1806, 16, 15, 17, 0, -15 },
  { 1836, 10, 15, 11, 0, -15 },
  { 1855, 10, 15, 12, 1, -15 },
  { 1874, 12, 21, 12, -1, -15 },
  { 1906, 11, 21, 12, 1, -15 },
  { 1935, 9, 15, 8, 0, -15 },
  { 1952, 9, 15, 9, 0, -15 },
  { 1969, 6, 18, 6, 1, -18 },
  { 1983, 10, 14, 12, 1, -14 },
  { 2001, 9, 14, 9, 1, -14 },
  { 2017, 14, 14, 14, 2, -14 },
  { 2042, 11, 14, 9, -1, -14 },
  { 2062, 14, 21, 9, -3, -14 },
  { 2099, 10, 14, 8, -1, -14 },
  { 2117, 9, 23, 9, 1, -19 },
  { 2143, 1, 28, 11, 5, -21 },
  { 2147, 10, 23, 9, -2, -19 },
  { 2176, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC27PT7B_H_
