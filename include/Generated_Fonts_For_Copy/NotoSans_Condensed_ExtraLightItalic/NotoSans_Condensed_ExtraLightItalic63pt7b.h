#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x06, 0x38, 0x18,
  0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC6, 0x07, 0x18, 0x18,
  0x60, 0x61, 0x81, 0x84, 0x06, 0x30, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xF1,
  0x83, 0x80, 0xE0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x10, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x0E, 0x20, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x20,
  0xE0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x40, 0xE0, 0x40, 0x60, 0xE0, 0x38, 0x31, 0xE0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1C,
  0x07, 0xBC, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x30, 0x0C, 0x0E, 0x00, 0x70,
  0x1C, 0x06, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x00,
  0x60, 0x0E, 0x07, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x0C, 0x00,
  0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x1C, 0x18, 0x00,
  0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x70, 0x00, 0xC0, 0x18, 0x61, 0xFC,
  0xC0, 0x30, 0xE3, 0xFE, 0xC0, 0x30, 0xC7, 0x06, 0xC0, 0x71, 0x86, 0x06,
  0xC0, 0x61, 0x8C, 0x06, 0xC0, 0xE3, 0x0C, 0x07, 0xE1, 0xC7, 0x18, 0x07,
  0x77, 0x86, 0x18, 0x07, 0x3F, 0x0E, 0x38, 0x07, 0x08, 0x0C, 0x30, 0x06,
  0x00, 0x18, 0x30, 0x06, 0x00, 0x18, 0x30, 0x06, 0x00, 0x30, 0x70, 0x06,
  0x00, 0x70, 0x60, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x00, 0xE0, 0x60, 0x0C,
  0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xE0, 0x30,
  0x0E, 0x00, 0xE0, 0x30, 0x0C, 0x00, 0x60, 0x60, 0x18, 0x00, 0x60, 0xE0,
  0x18, 0x00, 0x7B, 0xC0, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01,
  0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xE0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x06, 0x03,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x70, 0x70, 0x0C, 0x38, 0x0C, 0x03, 0x1C, 0x03, 0x01, 0xC6, 0x00,
  0xE0, 0x63, 0x80, 0x18, 0x18, 0xC0, 0x07, 0x0C, 0x70, 0x00, 0xC3, 0x18,
  0x00, 0x31, 0xC6, 0x00, 0x0E, 0x61, 0x80, 0x01, 0xB0, 0xE0, 0x00, 0x7C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0x60, 0x00,
  0xF8, 0x18, 0x00, 0x77, 0x07, 0x00, 0x38, 0xC0, 0xE0, 0x1C, 0x30, 0x1F,
  0xFE, 0x0E, 0x03, 0xFE, 0x01, 0x80, 0x38, 0x00, 0x10, 0x1C, 0x71, 0x86,
  0x18, 0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x04, 0x03, 0x00, 0xF0, 0x20, 0x03, 0xC6, 0x00, 0x0E,
  0x60, 0x20, 0x3E, 0x7F, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x01, 0xA0, 0x00,
  0x33, 0x00, 0x0E, 0x10, 0x01, 0xC1, 0x80, 0x38, 0x1C, 0x07, 0x00, 0xC0,
  0x20, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x27, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x70, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00,
  0x19, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xCC, 0x00, 0x03,
  0x38, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00,
  0x07, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x7C, 0x07, 0x60, 0x73, 0x0F, 0x38, 0xF1, 0xCE, 0x0C, 0xE0,
  0x62, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x02, 0x00, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x77,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x20, 0x00, 0xF0, 0x0C, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x03, 0x0F, 0xF8, 0x03, 0x9F, 0xFE, 0x01,
  0x9C, 0x07, 0x80, 0xD8, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x01, 0xC0, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x20, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x00, 0xC1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x70, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x06, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x36, 0x0E, 0x00, 0x7E,
  0x07, 0x00, 0xEC, 0x03, 0xEF, 0xCC, 0x01, 0xFF, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x78, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xE0, 0x3C, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0xC0, 0xE0, 0x38,
  0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x60, 0x03,
  0xFC, 0x03, 0x0E, 0x00, 0x7F, 0xE0, 0x30, 0xC0, 0x1C, 0x0C, 0x03, 0x0C,
  0x03, 0x80, 0xC0, 0x31, 0x80, 0x30, 0x0C, 0x07, 0x18, 0x06, 0x01, 0xC0,
  0x73, 0x80, 0xE0, 0x18, 0x06, 0x30, 0x0C, 0x01, 0x80, 0x63, 0x01, 0xC0,
  0x18, 0x06, 0x30, 0x18, 0x03, 0x80, 0x67, 0x01, 0x80, 0x30, 0x06, 0x60,
  0x38, 0x03, 0x00, 0xE6, 0x03, 0x00, 0x30, 0x0C, 0x60, 0x30, 0x07, 0x00,
  0xC6, 0x03, 0x00, 0x60, 0x1C, 0xE0, 0x30, 0x06, 0x01, 0x8E, 0x07, 0x00,
  0xE0, 0x18, 0xC0, 0x60, 0x0E, 0x03, 0x0C, 0x06, 0x01, 0xE0, 0x30, 0xC0,
  0x70, 0x1E, 0x07, 0x0C, 0x07, 0x03, 0x60, 0x60, 0xC0, 0x30, 0x76, 0x0C,
  0x0C, 0x03, 0x8E, 0x71, 0x80, 0xC0, 0x1F, 0xC3, 0xF0, 0x0C, 0x00, 0xF0,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xC0, 0x03, 0x80,
  0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0x80, 0x7E, 0x00, 0x30, 0x01, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0x81, 0xFC, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x3C, 0x01, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xF0, 0x06, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x04, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0xC0, 0x0F, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x01,
  0xE0, 0x03, 0x00, 0x3E, 0x00, 0x18, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE1, 0xC0, 0x01,
  0xFF, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x02, 0x0E, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x06,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00,
  0x01, 0x80, 0xF0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x19, 0xF0,
  0x00, 0x00, 0x6E, 0xC0, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x0F, 0x8E, 0x00,
  0x00, 0x3C, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x70,
  0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xD8, 0x03,
  0x60, 0x00, 0x00, 0xEC, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x73, 0x00, 0x00, 0x39,
  0x80, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x00, 0x1C, 0xE0, 0x0C,
  0x60, 0x00, 0x0C, 0x70, 0x0E, 0x30, 0x00, 0x0E, 0x30, 0x07, 0x18, 0x00,
  0x06, 0x18, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x01, 0x86, 0x00, 0x03, 0x0E,
  0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x00, 0x70,
  0xE0, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x00, 0xC1, 0xC0, 0x18, 0x18, 0x00,
  0xE0, 0xE0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0x70, 0x30,
  0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x38, 0x1C, 0x01, 0x80,
  0xC0, 0x18, 0x0E, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x00, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x1C, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x06, 0x01, 0xC0,
  0x18, 0x07, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x83, 0x00, 0x60, 0x0E, 0x00,
  0xC3, 0x80, 0x30, 0x06, 0x00, 0x61, 0x80, 0x38, 0x03, 0x00, 0x31, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x01, 0xC0, 0x0C, 0xE0, 0x06, 0x00,
  0xC0, 0x06, 0x60, 0x03, 0x00, 0x60, 0x03, 0x70, 0x03, 0x80, 0x30, 0x01,
  0xF0, 0x01, 0xC0, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x1C, 0x00, 0x78, 0x00,
  0x60, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x3C, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x18, 0x03, 0x30, 0x00, 0x0C,
  0x01, 0x98, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0x06, 0x00, 0x67, 0x00, 0x03,
  0x00, 0x71, 0x80, 0x01, 0x80, 0x30, 0xC0, 0x01, 0xC0, 0x18, 0x60, 0x00,
  0xE0, 0x0C, 0x38, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x30, 0x07, 0x06, 0x00,
  0x18, 0x03, 0x03, 0x00, 0x1C, 0x01, 0x81, 0xC0, 0x0E, 0x00, 0xC0, 0x60,
  0x06, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x70, 0x18, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x60, 0x0E, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x70, 0x18, 0x03, 0x00, 0x38, 0x1C, 0x01, 0x80,
  0x0C, 0x0C, 0x01, 0xC0, 0x06, 0x06, 0x00, 0xE0, 0x03, 0x83, 0x00, 0x60,
  0x01, 0xC3, 0x80, 0x30, 0x00, 0x61, 0xC0, 0x18, 0x00, 0x30, 0xC0, 0x1C,
  0x00, 0x1C, 0x60, 0x0E, 0x00, 0x0E, 0x30, 0x06, 0x00, 0x03, 0x38, 0x03,
  0x00, 0x01, 0x9C, 0x01, 0x80, 0x00, 0xEC, 0x01, 0xC0, 0x00, 0x76, 0x00,
  0xE0, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x07, 0xC0,
  0x18, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x06,
  0x03, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x60,
  0x0E, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x01, 0x80, 0x07, 0x00, 0x60, 0x07, 0x80, 0x18, 0x0F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x03, 0xE0, 0x01, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0x80, 0x0F, 0x00, 0x60, 0x0F,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1E, 0x00, 0x70, 0x07, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x02, 0x00,
  0x07, 0x80, 0x70, 0x01, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFA, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00,
  0xEC, 0x00, 0x03, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x73, 0x00,
  0x01, 0xB0, 0x00, 0x31, 0x80, 0x01, 0xD8, 0x00, 0x38, 0xC0, 0x00, 0xCC,
  0x00, 0x1C, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x0E,
  0x18, 0x00, 0x31, 0x80, 0x06, 0x0C, 0x00, 0x38, 0xC0, 0x07, 0x06, 0x00,
  0x18, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18,
  0x01, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x07, 0x06, 0x00, 0xE0,
  0x30, 0x03, 0x03, 0x00, 0x60, 0x18, 0x03, 0x81, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0x70, 0x0C, 0x0E, 0x00,
  0x60, 0x30, 0x06, 0x06, 0x00, 0x30, 0x38, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x01, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x61,
  0xC0, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x87, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0x61, 0x80, 0x0E, 0x30, 0x00, 0x31, 0x80,
  0x07, 0x38, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00, 0x0C, 0xE0, 0x01, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x03, 0x70, 0x00, 0x76, 0x00, 0x01,
  0xB0, 0x00, 0x3F, 0x00, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x0D, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E,
  0x1C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x80,
  0xC0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x06,
  0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x70,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x30,
  0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x02, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x30, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x38, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x1C, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x39, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x06, 0x0C, 0x00, 0x0F, 0x80,
  0x80, 0x1F, 0xF1, 0x80, 0x3E, 0x3C, 0xC0, 0x3C, 0x06, 0x60, 0x38, 0x01,
  0xB0, 0x18, 0x00, 0xF8, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x70,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x06, 0x00, 0x36, 0x03, 0x00, 0x36, 0x01, 0xC0, 0x3B, 0x00, 0x70, 0x39,
  0x80, 0x3F, 0xF8, 0xC0, 0x0F, 0xF0, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x81, 0xF0, 0x01, 0x87, 0xF8, 0x03,
  0x9E, 0x3C, 0x03, 0xB8, 0x0E, 0x03, 0x70, 0x07, 0x03, 0x60, 0x07, 0x03,
  0xC0, 0x03, 0x07, 0x80, 0x03, 0x07, 0x80, 0x03, 0x07, 0x00, 0x03, 0x07,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x78,
  0x00, 0x38, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x68, 0x00, 0xE0, 0x6C,
  0x01, 0xC0, 0xCE, 0x03, 0x80, 0xC7, 0xFF, 0x00, 0xC3, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x70, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x20, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x81, 0x80, 0x03,
  0xFE, 0x38, 0x00, 0xF8, 0xF3, 0x00, 0x1E, 0x03, 0x30, 0x03, 0x80, 0x1B,
  0x00, 0x30, 0x01, 0xB0, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x60, 0x03, 0x60,
  0x06, 0x00, 0x76, 0x00, 0x70, 0x0E, 0xE0, 0x03, 0x81, 0xCC, 0x00, 0x3F,
  0xF8, 0xC0, 0x01, 0xFF, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0x00, 0x3E, 0x3C, 0x03, 0xC0, 0x60, 0x38, 0x03, 0x81,
  0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01,
  0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0xE1, 0xC0,
  0x1E, 0x0E, 0x03, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x60, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x87, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x0C, 0x00, 0xF8,
  0xF3, 0x00, 0x3C, 0x06, 0x60, 0x0E, 0x00, 0x6C, 0x01, 0x80, 0x0D, 0x80,
  0x70, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x3C, 0x01, 0x80, 0x0D, 0x80, 0x30, 0x03, 0xF0, 0x07, 0x00, 0xEE, 0x00,
  0x70, 0x39, 0x80, 0x0F, 0xFE, 0x30, 0x00, 0xFF, 0x86, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0x00,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0xFC, 0x00, 0xC7, 0xFE, 0x03,
  0x9E, 0x3C, 0x07, 0x60, 0x1C, 0x0D, 0x80, 0x18, 0x1E, 0x00, 0x30, 0x3C,
  0x00, 0x60, 0xF0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x04, 0x78, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x01, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0E,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xF0, 0x00, 0x1D,
  0xF8, 0x00, 0x1F, 0x98, 0x00, 0x1B, 0x18, 0x00, 0x1E, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30,
  0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60,
  0x07, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0,
  0x03, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x0C, 0x7F,
  0xC1, 0xFF, 0x00, 0xC7, 0x1E, 0x1E, 0x3C, 0x06, 0x60, 0x39, 0xC0, 0x70,
  0x36, 0x00, 0xD8, 0x03, 0x81, 0xE0, 0x06, 0xC0, 0x0C, 0x0E, 0x00, 0x3C,
  0x00, 0x60, 0xF0, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x38,
  0x00, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x01, 0xC1, 0x80, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x60, 0xE0,
  0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x01,
  0xC1, 0x80, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x60, 0xE0, 0x01,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x01, 0xC1,
  0x80, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x1F,
  0xF8, 0x0C, 0x78, 0xF0, 0x19, 0xC0, 0x70, 0x36, 0x00, 0x60, 0x78, 0x00,
  0xC0, 0xF0, 0x01, 0x83, 0xC0, 0x03, 0x07, 0x80, 0x06, 0x0E, 0x00, 0x0C,
  0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xC0, 0x03, 0xE3, 0xC0, 0x0F, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x60, 0x03, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x60, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE6, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x73, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00, 0x03,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0x87, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C,
  0x01, 0xE0, 0x1C, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x0F, 0xF0, 0x00, 0x73, 0xC7,
  0x80, 0x06, 0x70, 0x1C, 0x00, 0x6E, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00,
  0x78, 0x00, 0x60, 0x0F, 0x80, 0x06, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60,
  0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x0F, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xD0, 0x01, 0xC0, 0x0D,
  0x80, 0x38, 0x01, 0xDC, 0x07, 0x00, 0x1C, 0xFF, 0xE0, 0x01, 0x87, 0xFC,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0xC0, 0x3E, 0x3C, 0xC0,
  0x3C, 0x06, 0x60, 0x38, 0x01, 0xB0, 0x18, 0x00, 0xD8, 0x1C, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38,
  0x00, 0x78, 0x1C, 0x00, 0x3C, 0x06, 0x00, 0x36, 0x03, 0x00, 0x3B, 0x01,
  0xC0, 0x3B, 0x80, 0x70, 0x39, 0x80, 0x3F, 0xF8, 0xC0, 0x0F, 0xF8, 0x60,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x31, 0xFC, 0x0C, 0x7C, 0x81, 0x9C, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x03, 0xE0, 0xF0, 0x38, 0x01, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x80, 0x0E, 0x0C, 0x01, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0,
  0xE0, 0x02, 0xC0, 0xE0, 0x06, 0xC0, 0xE0, 0x0D, 0x80, 0x70, 0x19, 0x80,
  0x7F, 0xF1, 0x80, 0x3F, 0xE1, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3B,
  0x00, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0xE1, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x00, 0x38, 0x18,
  0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0x70, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xC0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00,
  0x33, 0x80, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x06,
  0xC0, 0x06, 0x80, 0x0E, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x0F, 0xC0, 0x1C,
  0xC0, 0x0D, 0xC0, 0x18, 0xC0, 0x0D, 0xC0, 0x18, 0xC0, 0x19, 0xC0, 0x38,
  0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x70, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC1, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80,
  0xC1, 0x80, 0xC3, 0x00, 0xC3, 0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC7, 0x00,
  0xC7, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xC6, 0x00, 0xCC, 0x00,
  0xCC, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0xD8, 0x00, 0xDC, 0x00, 0xD8, 0x00,
  0xD8, 0x00, 0xF8, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F, 0xF0,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 45, 13, 1, -45 },
  { 75, 14, 16, 18, 6, -45 },
  { 103, 28, 45, 28, 1, -45 },
  { 261, 25, 52, 26, 1, -48 },
  { 424, 32, 47, 38, 4, -46 },
  { 612, 26, 47, 28, 0, -46 },
  { 765, 6, 16, 10, 6, -45 },
  { 777, 17, 55, 16, 2, -45 },
  { 894, 17, 55, 16, -4, -45 },
  { 1011, 20, 21, 25, 7, -48 },
  { 1064, 24, 29, 29, 3, -37 },
  { 1151, 9, 14, 11, -3, -6 },
  { 1167, 14, 2, 17, 2, -18 },
  { 1171, 4, 5, 11, 1, -5 },
  { 1174, 27, 45, 19, -3, -45 },
  { 1326, 23, 47, 26, 2, -46 },
  { 1462, 13, 45, 26, 8, -45 },
  { 1536, 26, 46, 26, -1, -46 },
  { 1686, 27, 47, 26, -1, -46 },
  { 1845, 26, 45, 26, -1, -45 },
  { 1992, 26, 46, 26, 0, -45 },
  { 2142, 25, 47, 26, 2, -46 },
  { 2289, 24, 45, 26, 4, -45 },
  { 2424, 26, 47, 26, 0, -46 },
  { 2577, 24, 47, 26, 1, -46 },
  { 2718, 10, 34, 11, 1, -34 },
  { 2761, 14, 42, 11, -3, -34 },
  { 2835, 24, 27, 29, 3, -36 },
  { 2916, 24, 16, 29, 3, -30 },
  { 2964, 24, 27, 29, 3, -36 },
  { 3045, 19, 46, 19, 2, -46 },
  { 3155, 36, 51, 39, 2, -45 },
  { 3385, 26, 45, 25, -4, -45 },
  { 3532, 27, 45, 28, 1, -45 },
  { 3684, 28, 47, 27, 3, -46 },
  { 3849, 29, 45, 31, 1, -45 },
  { 4013, 27, 45, 25, 1, -45 },
  { 4165, 27, 45, 23, 1, -45 },
  { 4317, 31, 47, 33, 3, -46 },
  { 4500, 32, 45, 33, 1, -45 },
  { 4680, 20, 45, 14, -2, -45 },
  { 4793, 22, 56, 12, -9, -45 },
  { 4947, 30, 45, 26, 1, -45 },
  { 5116, 17, 45, 23, 1, -45 },
  { 5212, 41, 45, 42, 1, -45 },
  { 5443, 33, 45, 34, 1, -45 },
  { 5629, 29, 47, 34, 3, -46 },
  { 5800, 26, 45, 27, 1, -45 },
  { 5947, 29, 57, 34, 3, -46 },
  { 6154, 26, 45, 27, 1, -45 },
  { 6301, 27, 47, 25, -1, -46 },
  { 6460, 23, 45, 23, 5, -45 },
  { 6590, 30, 46, 32, 3, -45 },
  { 6763, 25, 45, 26, 6, -45 },
  { 6904, 41, 45, 43, 6, -45 },
  { 7135, 32, 45, 23, -4, -45 },
  { 7315, 23, 45, 23, 5, -45 },
  { 7445, 29, 45, 24, -2, -45 },
  { 7609, 23, 55, 18, -1, -45 },
  { 7768, 10, 45, 20, 6, -45 },
  { 7825, 23, 55, 18, -4, -45 },
  { 7984, 25, 24, 28, 2, -45 },
  { 8059, 19, 2, 19, -5, 6 },
  { 8064, 7, 10, 14, 9, -48 },
  { 8073, 25, 35, 28, 2, -34 },
  { 8183, 24, 49, 28, 1, -48 },
  { 8330, 20, 35, 21, 2, -34 },
  { 8418, 28, 49, 28, 2, -48 },
  { 8590, 21, 35, 24, 2, -34 },
  { 8682, 30, 63, 14, -8, -48 },
  { 8919, 27, 49, 28, 0, -34 },
  { 9085, 23, 48, 27, 1, -48 },
  { 9223, 12, 45, 11, 1, -45 },
  { 9291, 21, 60, 11, -8, -45 },
  { 9449, 24, 48, 22, 1, -48 },
  { 9593, 12, 48, 11, 1, -48 },
  { 9665, 37, 34, 41, 1, -34 },
  { 9823, 23, 34, 27, 1, -34 },
  { 9921, 23, 35, 27, 2, -34 },
  { 10022, 28, 48, 28, -2, -34 },
  { 10190, 25, 49, 28, 2, -34 },
  { 10344, 19, 34, 18, 1, -34 },
  { 10425, 20, 35, 20, 0, -34 },
  { 10513, 14, 42, 14, 2, -41 },
  { 10587, 24, 34, 27, 2, -33 },
  { 10689, 21, 33, 20, 3, -33 },
  { 10776, 32, 33, 34, 4, -33 },
  { 10908, 27, 33, 22, -3, -33 },
  { 11020, 32, 48, 21, -7, -33 },
  { 11212, 22, 33, 19, -2, -33 },
  { 11303, 22, 55, 20, 2, -45 },
  { 11455, 2, 63, 26, 12, -48 },
  { 11471, 22, 55, 20, -4, -45 },
  { 11623, 24, 6, 29, 3, -25 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC63PT7B_H_
