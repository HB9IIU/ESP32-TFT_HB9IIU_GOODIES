#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0x80, 0x14, 0xA7, 0xCA, 0x4B, 0xE5,
  0x14, 0xA0, 0x11, 0xD4, 0xA5, 0x18, 0xA5, 0x36, 0x10, 0xE6, 0xAA, 0xAD,
  0xEC, 0xD5, 0x55, 0x9C, 0x39, 0x4A, 0x66, 0x4E, 0x72, 0xE8, 0xE0, 0x12,
  0x44, 0x88, 0x88, 0x88, 0x40, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x59,
  0xD0, 0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10,
  0x84, 0x10, 0x80, 0x3A, 0x52, 0x98, 0xC6, 0x32, 0x60, 0x75, 0x6A, 0x80,
  0x78, 0x42, 0x11, 0x11, 0x08, 0xF0, 0x78, 0x42, 0x13, 0x04, 0x22, 0xE0,
  0x08, 0xCA, 0x55, 0x4B, 0xE2, 0x10, 0x3A, 0x10, 0xE0, 0x84, 0x22, 0xE0,
  0x3C, 0x84, 0x1C, 0x4A, 0x28, 0xA2, 0x70, 0xF8, 0x84, 0x42, 0x21, 0x10,
  0x80, 0x3A, 0x52, 0x67, 0x46, 0x31, 0xF0, 0x3A, 0x52, 0x95, 0x94, 0x42,
  0xE0, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x3A, 0x20, 0xC1, 0x80, 0xF8,
  0x3E, 0xC1, 0x06, 0xC8, 0x00, 0x71, 0x12, 0x24, 0x40, 0x80, 0x1E, 0x21,
  0x4D, 0x55, 0xA5, 0xA9, 0xAA, 0x94, 0x80, 0x78, 0x08, 0xC6, 0x52, 0x9D,
  0x29, 0x88, 0x3C, 0x94, 0x52, 0x79, 0x28, 0xA2, 0xF0, 0x3A, 0x21, 0x08,
  0x42, 0x10, 0xF0, 0x3C, 0x94, 0x51, 0x45, 0x18, 0x62, 0xF0, 0x3C, 0x84,
  0x10, 0x79, 0x08, 0x20, 0xF0, 0x3C, 0x84, 0x10, 0x79, 0x08, 0x20, 0x80,
  0x3D, 0x08, 0x20, 0x9A, 0x28, 0xA2, 0xF0, 0x22, 0x45, 0x0A, 0x27, 0xC8,
  0xA1, 0x44, 0x88, 0x38, 0x88, 0x42, 0x10, 0x88, 0xE0, 0x08, 0x44, 0x21,
  0x08, 0x84, 0x21, 0x30, 0x24, 0xA5, 0x18, 0x61, 0x49, 0x24, 0x88, 0x22,
  0x44, 0x44, 0x88, 0xF0, 0x20, 0x90, 0x98, 0xCC, 0x65, 0x52, 0xAA, 0x65,
  0x34, 0x92, 0x00, 0x22, 0x45, 0x4A, 0x95, 0x4A, 0xA3, 0x44, 0x88, 0x79,
  0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x38, 0x94, 0x52, 0x71, 0x08, 0x20,
  0x80, 0x79, 0x18, 0x61, 0x86, 0x28, 0xA2, 0xD0, 0x82, 0x00, 0x38, 0x94,
  0x52, 0x71, 0x49, 0x24, 0x88, 0x7A, 0x10, 0x82, 0x08, 0x22, 0xF0, 0xF9,
  0x10, 0x84, 0x21, 0x10, 0x80, 0x46, 0x18, 0xA2, 0x8A, 0x28, 0xA4, 0xE0,
  0x8C, 0x65, 0x2A, 0x53, 0x18, 0x80, 0x88, 0xC4, 0xA6, 0x55, 0x4A, 0xA5,
  0x53, 0x31, 0x10, 0x88, 0x00, 0x26, 0x28, 0x60, 0x81, 0x06, 0x0A, 0x24,
  0x88, 0x8C, 0xA9, 0x44, 0x21, 0x10, 0x80, 0x3C, 0x21, 0x04, 0x21, 0x04,
  0x20, 0xF0, 0x39, 0x10, 0x84, 0x22, 0x10, 0x84, 0x30, 0xA9, 0x55, 0x40,
  0x38, 0x42, 0x21, 0x08, 0x44, 0x21, 0x38, 0x10, 0xA4, 0x92, 0x84, 0xF0,
  0xC0, 0x3A, 0x53, 0x18, 0xC9, 0xC0, 0x21, 0x10, 0xF4, 0xA5, 0x31, 0x8F,
  0x80, 0x3A, 0x11, 0x08, 0x41, 0xC0, 0x04, 0x10, 0x4E, 0x49, 0x28, 0xA2,
  0x91, 0xC0, 0x3A, 0x52, 0xE8, 0x41, 0xC0, 0x04, 0x20, 0x86, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0xC0, 0x3D, 0x24, 0xA2, 0x8A, 0x47, 0x04, 0x13,
  0x80, 0x21, 0x10, 0x74, 0xA5, 0x31, 0x94, 0x80, 0x21, 0x24, 0xA4, 0x80,
  0x08, 0x04, 0x21, 0x08, 0x84, 0x21, 0x09, 0x80, 0x21, 0x10, 0x95, 0x31,
  0x94, 0x94, 0x80, 0x25, 0x24, 0x94, 0x90, 0x3F, 0x49, 0x49, 0x49, 0x91,
  0x92, 0x92, 0x3A, 0x52, 0x98, 0xCA, 0x40, 0x3A, 0x53, 0x18, 0xC5, 0xC0,
  0x7A, 0x52, 0x98, 0xC7, 0xD0, 0x84, 0x00, 0x3D, 0x24, 0xA2, 0x8A, 0x47,
  0x04, 0x10, 0x40, 0x34, 0x44, 0x88, 0x80, 0x74, 0x42, 0x21, 0xE0, 0x29,
  0xA4, 0xA4, 0xC0, 0x4A, 0x52, 0x98, 0xCB, 0xC0, 0x9A, 0xAA, 0xC8, 0x80,
  0x96, 0x9A, 0x76, 0x9A, 0x49, 0x00, 0x24, 0xA3, 0x04, 0x31, 0x4C, 0x80,
  0x24, 0x92, 0x8A, 0x30, 0x82, 0x08, 0x43, 0x00, 0x71, 0x24, 0x48, 0xE0,
  0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8, 0x10, 0x84, 0x21,
  0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 11, 5, 0, -10 },
  { 21, 6, 9, 8, 1, -9 },
  { 28, 5, 9, 6, 0, -9 },
  { 34, 1, 3, 2, 1, -9 },
  { 35, 4, 11, 3, 0, -9 },
  { 41, 4, 11, 3, -1, -9 },
  { 47, 3, 4, 5, 2, -10 },
  { 49, 5, 6, 6, 1, -8 },
  { 53, 2, 3, 2, -1, -1 },
  { 54, 3, 1, 4, 0, -4 },
  { 55, 1, 1, 2, 0, -1 },
  { 56, 6, 9, 4, -1, -9 },
  { 63, 5, 9, 5, 0, -9 },
  { 69, 2, 9, 5, 2, -9 },
  { 72, 5, 9, 5, 0, -9 },
  { 78, 5, 9, 5, 0, -9 },
  { 84, 5, 9, 5, 0, -9 },
  { 90, 5, 9, 5, 0, -9 },
  { 96, 6, 9, 5, 0, -9 },
  { 103, 5, 9, 5, 1, -9 },
  { 109, 5, 9, 5, 0, -9 },
  { 115, 5, 9, 5, 0, -9 },
  { 121, 2, 7, 2, 0, -7 },
  { 123, 3, 9, 2, -1, -7 },
  { 127, 5, 5, 6, 1, -7 },
  { 131, 5, 3, 6, 1, -6 },
  { 133, 5, 5, 6, 1, -7 },
  { 137, 4, 9, 4, 0, -9 },
  { 142, 8, 10, 8, 0, -9 },
  { 152, 5, 9, 5, -1, -9 },
  { 158, 6, 9, 6, 0, -9 },
  { 165, 5, 9, 5, 1, -9 },
  { 171, 6, 9, 6, 0, -9 },
  { 178, 6, 9, 5, 0, -9 },
  { 185, 6, 9, 5, 0, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 7, 9, 7, 0, -9 },
  { 207, 5, 9, 3, -1, -9 },
  { 213, 5, 11, 2, -2, -9 },
  { 220, 6, 9, 5, 0, -9 },
  { 227, 4, 9, 5, 0, -9 },
  { 232, 9, 9, 9, 0, -9 },
  { 243, 7, 9, 7, 0, -9 },
  { 251, 6, 9, 7, 1, -9 },
  { 258, 6, 9, 5, 0, -9 },
  { 265, 6, 11, 7, 1, -9 },
  { 274, 6, 9, 6, 0, -9 },
  { 281, 5, 9, 5, 0, -9 },
  { 287, 5, 9, 5, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 5, 9, 5, 1, -9 },
  { 306, 9, 9, 9, 1, -9 },
  { 317, 7, 9, 5, -1, -9 },
  { 325, 5, 9, 5, 1, -9 },
  { 331, 6, 9, 5, 0, -9 },
  { 338, 5, 11, 4, 0, -9 },
  { 345, 2, 9, 4, 1, -9 },
  { 348, 5, 11, 4, -1, -9 },
  { 355, 6, 5, 6, 0, -9 },
  { 359, 4, 1, 4, -1, 1 },
  { 360, 1, 2, 3, 2, -10 },
  { 361, 5, 7, 6, 0, -7 },
  { 366, 5, 10, 6, 0, -10 },
  { 373, 5, 7, 4, 0, -7 },
  { 378, 6, 10, 6, 0, -10 },
  { 386, 5, 7, 5, 0, -7 },
  { 391, 6, 13, 3, -2, -10 },
  { 401, 6, 10, 6, 0, -7 },
  { 409, 5, 10, 6, 0, -10 },
  { 416, 3, 9, 2, 0, -9 },
  { 420, 5, 12, 2, -2, -9 },
  { 428, 5, 10, 5, 0, -10 },
  { 435, 3, 10, 2, 0, -10 },
  { 439, 8, 7, 8, 0, -7 },
  { 446, 5, 7, 6, 0, -7 },
  { 451, 5, 7, 6, 0, -7 },
  { 456, 5, 10, 6, 0, -7 },
  { 463, 6, 10, 6, 0, -7 },
  { 471, 4, 7, 4, 0, -7 },
  { 475, 4, 7, 4, 0, -7 },
  { 479, 3, 9, 3, 0, -9 },
  { 483, 5, 7, 6, 0, -7 },
  { 488, 4, 7, 4, 1, -7 },
  { 492, 6, 7, 7, 1, -7 },
  { 498, 6, 7, 5, -1, -7 },
  { 504, 6, 10, 4, -1, -7 },
  { 512, 4, 7, 4, 0, -7 },
  { 516, 5, 11, 4, 0, -9 },
  { 523, 1, 13, 5, 2, -10 },
  { 525, 5, 11, 4, -1, -9 },
  { 532, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC13PT7B_H_
