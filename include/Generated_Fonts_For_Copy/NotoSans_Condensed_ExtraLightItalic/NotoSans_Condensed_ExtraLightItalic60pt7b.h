#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x18, 0x18, 0xC1, 0xCE, 0x0E, 0x70,
  0x63, 0x03, 0x18, 0x18, 0xC1, 0xC6, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18,
  0xC1, 0x84, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x10, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xFF, 0x01, 0xE1,
  0x06, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x02,
  0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x04, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x8C,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x17, 0x00, 0x00, 0x13, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0xC0, 0xC7,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x18, 0x07, 0xF8, 0x00, 0x60, 0x1C, 0x30, 0x00,
  0xC0, 0x70, 0x30, 0x03, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x80, 0x60, 0x70, 0x06,
  0x00, 0xC0, 0xC0, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x03, 0x06, 0x00, 0x30,
  0x06, 0x18, 0x00, 0x60, 0x18, 0x30, 0x00, 0xC0, 0x30, 0xC1, 0xF3, 0x80,
  0x63, 0x8F, 0xF7, 0x01, 0x86, 0x38, 0x66, 0x03, 0x18, 0x60, 0xEC, 0x0C,
  0x31, 0x80, 0xD8, 0x18, 0xC7, 0x01, 0xB0, 0x61, 0x8C, 0x03, 0x3F, 0x86,
  0x18, 0x06, 0x7E, 0x1C, 0x60, 0x0C, 0x00, 0x30, 0xC0, 0x18, 0x00, 0xC1,
  0x80, 0x70, 0x01, 0x87, 0x00, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x0C, 0x18,
  0x03, 0x00, 0x30, 0x30, 0x06, 0x00, 0xE0, 0x60, 0x1C, 0x01, 0x80, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x38, 0x18, 0x07, 0x00, 0x30, 0x30,
  0x0C, 0x00, 0x60, 0xC0, 0x30, 0x00, 0xE7, 0x80, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x06, 0x01, 0x87, 0x03,
  0x00, 0xC7, 0x01, 0xC0, 0xC7, 0x00, 0x60, 0x63, 0x00, 0x38, 0x73, 0x80,
  0x0C, 0x31, 0x80, 0x06, 0x38, 0xC0, 0x03, 0x98, 0x60, 0x00, 0xDC, 0x70,
  0x00, 0x7C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x03,
  0x00, 0x07, 0x81, 0x80, 0x06, 0xE0, 0xE0, 0x06, 0x30, 0x38, 0x0E, 0x18,
  0x1F, 0xBE, 0x0E, 0x03, 0xFE, 0x03, 0x00, 0x20, 0x00, 0x00, 0x18, 0xCE,
  0x73, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x18, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x40, 0x60, 0x38, 0x18, 0x07, 0x84, 0x00, 0x7B,
  0x03, 0x07, 0xDF, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x0D, 0x80, 0x06, 0x20,
  0x07, 0x0C, 0x03, 0x83, 0x01, 0xC0, 0x60, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x27, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0x03, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x38,
  0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00,
  0x06, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x0E,
  0x60, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xE0, 0x03, 0x03,
  0x80, 0x1C, 0x06, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x30, 0x38, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xE0,
  0x7E, 0x0E, 0x61, 0xC6, 0x78, 0xEE, 0x0C, 0xC0, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x01,
  0xC0, 0x1C, 0x00, 0x60, 0x04, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x81, 0x00, 0x03, 0x80, 0xE0, 0x07, 0x80, 0x7F,
  0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0C,
  0x03, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x01, 0x00, 0x07, 0x00, 0xC0, 0x0F, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x7F, 0x00,
  0x31, 0xFF, 0xC0, 0x33, 0x81, 0xC0, 0x36, 0x00, 0xE0, 0x7C, 0x00, 0x60,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x60, 0x01, 0x80,
  0x60, 0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x03,
  0x80, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x06, 0x00,
  0x0E, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x8E, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x06, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x83, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x0F,
  0xDF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xE0, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0xC0,
  0x70, 0x01, 0x80, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0xC1, 0x80, 0x0D,
  0x83, 0x80, 0x3E, 0x03, 0x80, 0xEC, 0x07, 0xFF, 0x98, 0x03, 0xFC, 0x70,
  0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0xC0, 0xC0, 0x78, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x3E, 0x00, 0xC3, 0x00, 0x3F, 0xF0, 0x30, 0xC0, 0x1C,
  0x18, 0x0C, 0x70, 0x0E, 0x06, 0x03, 0x18, 0x07, 0x01, 0x80, 0xC6, 0x03,
  0x80, 0xC0, 0x33, 0x00, 0xC0, 0x30, 0x0C, 0xC0, 0x70, 0x0C, 0x07, 0x30,
  0x18, 0x03, 0x01, 0x9C, 0x0E, 0x01, 0x80, 0x66, 0x03, 0x00, 0x60, 0x19,
  0x80, 0xC0, 0x18, 0x06, 0x60, 0x70, 0x0E, 0x03, 0x98, 0x18, 0x03, 0x00,
  0xCE, 0x06, 0x00, 0xC0, 0x33, 0x01, 0x80, 0x30, 0x1C, 0xC0, 0x60, 0x1C,
  0x06, 0x30, 0x18, 0x07, 0x01, 0x8C, 0x06, 0x03, 0x80, 0xC3, 0x01, 0x80,
  0xA0, 0x30, 0xC0, 0x60, 0x6C, 0x18, 0x30, 0x1C, 0x33, 0x0C, 0x0C, 0x03,
  0xF8, 0xFE, 0x03, 0x00, 0x7C, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x00,
  0xE0, 0x01, 0x80, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x38,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x03, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x80,
  0x60, 0x03, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x60,
  0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x20, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0x81, 0xF8, 0x00, 0x70,
  0x07, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x30,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x38, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x03,
  0x00, 0x3C, 0x00, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x01, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0xE0,
  0x00, 0xFF, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x67, 0x80, 0x00,
  0x07, 0x6E, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60,
  0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x1B,
  0x00, 0x00, 0x0F, 0x80, 0x36, 0x00, 0x00, 0x1B, 0x00, 0xEC, 0x00, 0x00,
  0x66, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x03, 0x30, 0x00, 0x03, 0x30, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x39, 0x80, 0x00,
  0x31, 0x80, 0x63, 0x00, 0x00, 0xC7, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x01,
  0x8E, 0x00, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x0E, 0x18, 0x00,
  0x30, 0xE0, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x03, 0x83, 0x00,
  0x38, 0x38, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0xC0, 0xC0,
  0x18, 0x18, 0x03, 0x01, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x0E, 0x01, 0x80, 0x60, 0x70, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x30,
  0x06, 0x01, 0x83, 0x80, 0x60, 0x1C, 0x03, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x30, 0x06, 0x00, 0xC0, 0x18, 0xE0, 0x0C,
  0x01, 0x80, 0x31, 0x80, 0x18, 0x07, 0x00, 0x67, 0x00, 0x70, 0x0C, 0x00,
  0xCC, 0x00, 0xC0, 0x18, 0x01, 0xF8, 0x01, 0x80, 0x30, 0x03, 0xE0, 0x03,
  0x00, 0xE0, 0x03, 0xC0, 0x06, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0xD8, 0x00, 0x0E, 0x00, 0xD8, 0x00, 0x0C, 0x01, 0xD8, 0x00, 0x0C,
  0x01, 0x9C, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x1C, 0x01, 0x8C, 0x00, 0x18,
  0x01, 0x8C, 0x00, 0x18, 0x03, 0x8E, 0x00, 0x18, 0x03, 0x06, 0x00, 0x18,
  0x03, 0x06, 0x00, 0x38, 0x03, 0x06, 0x00, 0x30, 0x03, 0x07, 0x00, 0x30,
  0x07, 0x03, 0x00, 0x30, 0x06, 0x03, 0x00, 0x30, 0x06, 0x03, 0x00, 0x70,
  0x06, 0x03, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x01, 0xC0, 0xE0, 0x0C, 0x00, 0xC0, 0xC0,
  0x1C, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0xE1, 0xC0,
  0x18, 0x00, 0x61, 0x80, 0x18, 0x00, 0x61, 0x80, 0x38, 0x00, 0x61, 0x80,
  0x30, 0x00, 0x71, 0x80, 0x30, 0x00, 0x33, 0x80, 0x30, 0x00, 0x33, 0x00,
  0x30, 0x00, 0x33, 0x00, 0x70, 0x00, 0x3B, 0x00, 0x60, 0x00, 0x1B, 0x00,
  0x60, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x18, 0x3F, 0x00, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x38, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x18, 0x3F,
  0x00, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xE0, 0x30, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x07, 0x80, 0x70, 0x0F, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x02, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x30, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0x60, 0x03, 0x80, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x1C, 0x00, 0x60, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x31, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x01, 0xE0,
  0x00, 0x76, 0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x0F, 0x80, 0x01, 0x98,
  0x00, 0x1B, 0x00, 0x07, 0x30, 0x00, 0x34, 0x00, 0x0C, 0x60, 0x00, 0xD8,
  0x00, 0x38, 0xC0, 0x01, 0xB0, 0x00, 0x61, 0x80, 0x07, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0xC0, 0x03, 0x86, 0x00, 0x19, 0x80, 0x06, 0x0C, 0x00, 0x63,
  0x00, 0x1C, 0x18, 0x00, 0xC6, 0x00, 0x30, 0x30, 0x03, 0x8C, 0x00, 0x60,
  0x60, 0x06, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x30, 0x03, 0x01, 0x80, 0x30,
  0x60, 0x0E, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x06, 0x01, 0x81, 0x80, 0x70,
  0x0C, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x06, 0x01, 0x80, 0x30, 0x18,
  0x0C, 0x07, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x38,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x0C, 0x38, 0x03, 0x06, 0x00, 0x18, 0x60, 0x06, 0x1C,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x18, 0x60, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0xCE,
  0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00,
  0x61, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x80,
  0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0xC0,
  0x30, 0x03, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0,
  0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xC0, 0x60, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x70, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xE0, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x80,
  0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x71, 0x80,
  0x00, 0x67, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x86, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x10,
  0x00, 0x3F, 0x86, 0x01, 0xFF, 0x8C, 0x07, 0x83, 0x98, 0x1C, 0x03, 0x30,
  0x70, 0x03, 0xC0, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1,
  0xC0, 0x07, 0x83, 0x80, 0x0B, 0x03, 0x00, 0x36, 0x07, 0x00, 0xD8, 0x0E,
  0x03, 0x30, 0x0F, 0xBC, 0x60, 0x0F, 0xF0, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE1, 0xFC, 0x01, 0x8F, 0xFC, 0x03, 0x38, 0x3C,
  0x06, 0xE0, 0x38, 0x0F, 0x80, 0x38, 0x36, 0x00, 0x70, 0x78, 0x00, 0x60,
  0xF0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x00,
  0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x78, 0x00, 0xE0, 0xF0, 0x03, 0x81,
  0x30, 0x0E, 0x06, 0x60, 0x38, 0x0C, 0x7B, 0xE0, 0x18, 0x7F, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0x80, 0x81, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x08, 0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xE1,
  0xC0, 0x07, 0xFE, 0x30, 0x01, 0xE0, 0x66, 0x00, 0x70, 0x06, 0xC0, 0x1C,
  0x00, 0xD8, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x70, 0x07, 0x00, 0x1E,
  0x00, 0xE0, 0x03, 0xC0, 0x0C, 0x00, 0xD8, 0x01, 0xC0, 0x33, 0x00, 0x38,
  0x0C, 0xC0, 0x03, 0xEF, 0x18, 0x00, 0x3F, 0xC3, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xE0, 0xE0, 0x38, 0x06, 0x07,
  0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x30, 0x03, 0x87, 0x00, 0xF0,
  0x60, 0x7E, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x20, 0x1F, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x84, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x0F, 0xFC, 0x60, 0x07, 0x81, 0x98,
  0x03, 0x80, 0x36, 0x01, 0xC0, 0x0D, 0x80, 0x60, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00,
  0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x03, 0x80, 0x1F, 0x00, 0x60, 0x06, 0xC0, 0x1C, 0x03, 0x70,
  0x07, 0x01, 0x98, 0x00, 0xFB, 0xC6, 0x00, 0x1F, 0xE1, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x03, 0x00, 0x70,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x7F, 0x00, 0xC7, 0xFE, 0x03, 0x38, 0x3C, 0x0D, 0x80, 0x70, 0x3C, 0x00,
  0xC1, 0xA0, 0x03, 0x07, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC1,
  0x80, 0x03, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x70, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60,
  0x01, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03,
  0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x66, 0xC0, 0x01, 0xB3, 0x00, 0x07, 0x8E,
  0x00, 0x1C, 0x18, 0x00, 0xF0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x07, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x0F, 0xE0, 0x3F, 0x80, 0x63, 0xFE, 0x1F, 0xF8, 0x0C, 0xC0,
  0xE7, 0x03, 0x81, 0xB0, 0x0D, 0xC0, 0x30, 0x3C, 0x01, 0xB0, 0x06, 0x0F,
  0x00, 0x3C, 0x00, 0xC1, 0xE0, 0x07, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x03,
  0x07, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x00, 0x0C, 0x38, 0x00, 0xE0,
  0x01, 0x86, 0x00, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x01, 0x87, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x80, 0x0E, 0x18,
  0x00, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x06,
  0x1C, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x0E, 0x00, 0x38, 0x60, 0x01, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x70, 0x01,
  0xC0, 0x03, 0x0C, 0x00, 0x38, 0x00, 0xE1, 0x80, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x00, 0x0C,
  0x30, 0x00, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x00, 0x60, 0x03, 0x0F, 0xF0,
  0x0C, 0x7F, 0xE0, 0x33, 0x83, 0xC0, 0xD8, 0x07, 0x03, 0xC0, 0x0C, 0x1A,
  0x00, 0x30, 0x78, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61,
  0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0C,
  0x07, 0x00, 0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x1C,
  0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x19, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00,
  0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x03,
  0xF7, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0xFE, 0x00,
  0x18, 0xFF, 0xC0, 0x06, 0x70, 0x38, 0x01, 0xB8, 0x06, 0x00, 0x6C, 0x01,
  0xC0, 0x36, 0x00, 0x30, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x03, 0x00, 0xE0,
  0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xF0, 0x01, 0xC0,
  0x3C, 0x00, 0xE0, 0x0D, 0x00, 0x70, 0x07, 0x60, 0x38, 0x01, 0x8F, 0x7C,
  0x00, 0x61, 0xFE, 0x00, 0x18, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x83, 0x00, 0xFF, 0xC6, 0x01, 0xE0, 0xE6, 0x03,
  0x80, 0x36, 0x07, 0x00, 0x36, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0,
  0x01, 0xE0, 0xC0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x60,
  0x06, 0xC0, 0x60, 0x0D, 0xC0, 0x70, 0x19, 0x80, 0x3E, 0xF1, 0x80, 0x1F,
  0xE1, 0x80, 0x03, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x0F, 0xC0, 0xC7,
  0xF0, 0x33, 0x80, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0x03, 0x80, 0x60, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x08, 0x01, 0xC0, 0xF9,
  0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x03, 0xFF, 0x7F, 0xF8, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7B, 0x01, 0xF8, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0E,
  0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00,
  0x18, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0xE0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C,
  0x00, 0x78, 0x30, 0x03, 0x60, 0xE0, 0x1D, 0x81, 0x80, 0xEC, 0x07, 0xDF,
  0x30, 0x0F, 0xF0, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03,
  0x86, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00,
  0xC0, 0x60, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x06, 0x03, 0x00, 0x60,
  0x70, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06,
  0x18, 0x00, 0x71, 0x80, 0x07, 0x30, 0x00, 0x73, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1B, 0x00,
  0x1C, 0x00, 0x76, 0x00, 0x38, 0x00, 0xCC, 0x00, 0xD0, 0x03, 0x98, 0x01,
  0xA0, 0x06, 0x30, 0x06, 0x40, 0x0C, 0x60, 0x0C, 0xC0, 0x38, 0xC0, 0x19,
  0x80, 0x61, 0x80, 0x63, 0x01, 0xC3, 0x00, 0xC6, 0x03, 0x06, 0x03, 0x0C,
  0x06, 0x0C, 0x06, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60,
  0xE0, 0x60, 0xE0, 0xC1, 0x80, 0xC1, 0x81, 0x83, 0x01, 0x83, 0x03, 0x0C,
  0x03, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0xC0,
  0x18, 0xC0, 0x33, 0x80, 0x33, 0x80, 0x66, 0x00, 0x66, 0x00, 0xCC, 0x00,
  0xCC, 0x01, 0xB0, 0x01, 0xB0, 0x03, 0x60, 0x03, 0x60, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x70,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x80, 0x00, 0x33, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03,
  0x00, 0x1C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01,
  0x80, 0x60, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x40, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x02, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x3E, 0x01, 0xFB,
  0xE8, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 43, 13, 1, -43 },
  { 66, 13, 16, 17, 6, -43 },
  { 92, 27, 43, 27, 1, -43 },
  { 238, 24, 49, 25, 1, -46 },
  { 385, 31, 44, 36, 3, -43 },
  { 556, 25, 44, 27, 0, -43 },
  { 694, 5, 16, 10, 6, -43 },
  { 704, 16, 52, 15, 2, -43 },
  { 808, 17, 52, 15, -4, -43 },
  { 919, 18, 19, 23, 7, -45 },
  { 962, 23, 28, 27, 3, -35 },
  { 1043, 9, 14, 11, -3, -6 },
  { 1059, 13, 2, 17, 2, -17 },
  { 1063, 4, 5, 11, 1, -5 },
  { 1066, 26, 43, 18, -3, -43 },
  { 1206, 22, 44, 25, 2, -43 },
  { 1327, 12, 43, 25, 8, -43 },
  { 1392, 25, 43, 25, -1, -43 },
  { 1527, 25, 44, 25, -1, -43 },
  { 1665, 25, 43, 25, -1, -43 },
  { 1800, 25, 44, 25, 0, -43 },
  { 1938, 24, 44, 25, 2, -43 },
  { 2070, 24, 43, 25, 3, -43 },
  { 2199, 25, 44, 25, 0, -43 },
  { 2337, 23, 44, 25, 1, -43 },
  { 2464, 9, 32, 11, 1, -32 },
  { 2500, 13, 40, 11, -3, -32 },
  { 2565, 23, 26, 27, 3, -34 },
  { 2640, 22, 15, 27, 3, -29 },
  { 2682, 23, 26, 27, 3, -34 },
  { 2757, 18, 43, 18, 2, -43 },
  { 2854, 34, 48, 37, 2, -43 },
  { 3058, 25, 43, 24, -4, -43 },
  { 3193, 26, 43, 27, 1, -43 },
  { 3333, 26, 45, 25, 3, -44 },
  { 3480, 27, 43, 30, 1, -43 },
  { 3626, 25, 43, 24, 1, -43 },
  { 3761, 25, 43, 22, 1, -43 },
  { 3896, 29, 45, 32, 3, -44 },
  { 4060, 31, 43, 31, 1, -43 },
  { 4227, 19, 43, 13, -2, -43 },
  { 4330, 21, 54, 11, -9, -43 },
  { 4472, 29, 43, 25, 1, -43 },
  { 4628, 16, 43, 22, 1, -43 },
  { 4714, 39, 43, 40, 1, -43 },
  { 4924, 32, 43, 32, 1, -43 },
  { 5096, 28, 44, 32, 3, -43 },
  { 5250, 25, 43, 25, 1, -43 },
  { 5385, 28, 53, 32, 3, -43 },
  { 5571, 25, 43, 26, 1, -43 },
  { 5706, 26, 44, 24, -1, -43 },
  { 5849, 21, 43, 22, 5, -43 },
  { 5962, 29, 44, 31, 3, -43 },
  { 6122, 24, 43, 25, 5, -43 },
  { 6251, 39, 43, 41, 6, -43 },
  { 6461, 30, 43, 22, -3, -43 },
  { 6623, 22, 43, 22, 5, -43 },
  { 6742, 28, 43, 23, -2, -43 },
  { 6893, 22, 52, 17, -1, -43 },
  { 7036, 9, 43, 19, 6, -43 },
  { 7085, 22, 52, 17, -4, -43 },
  { 7228, 23, 23, 26, 2, -43 },
  { 7295, 18, 2, 18, -5, 6 },
  { 7300, 6, 10, 13, 9, -46 },
  { 7308, 23, 33, 26, 2, -32 },
  { 7403, 23, 47, 26, 1, -46 },
  { 7539, 19, 33, 20, 2, -32 },
  { 7618, 27, 47, 27, 2, -46 },
  { 7777, 20, 33, 23, 2, -32 },
  { 7860, 29, 60, 13, -8, -46 },
  { 8078, 26, 46, 27, 0, -32 },
  { 8228, 22, 46, 26, 1, -46 },
  { 8355, 11, 43, 11, 1, -43 },
  { 8415, 21, 57, 11, -8, -43 },
  { 8565, 22, 46, 21, 1, -46 },
  { 8692, 12, 46, 11, 1, -46 },
  { 8761, 35, 32, 39, 1, -32 },
  { 8901, 22, 32, 26, 1, -32 },
  { 8989, 22, 33, 26, 2, -32 },
  { 9080, 26, 46, 26, -2, -32 },
  { 9230, 24, 46, 27, 2, -32 },
  { 9368, 18, 32, 17, 1, -32 },
  { 9440, 20, 33, 20, 0, -32 },
  { 9523, 13, 40, 14, 2, -39 },
  { 9588, 22, 33, 26, 2, -32 },
  { 9679, 20, 32, 20, 3, -32 },
  { 9759, 31, 32, 32, 4, -32 },
  { 9883, 24, 32, 21, -2, -32 },
  { 9979, 30, 47, 20, -7, -32 },
  { 10156, 21, 32, 18, -2, -32 },
  { 10240, 21, 52, 19, 2, -43 },
  { 10377, 3, 61, 24, 11, -46 },
  { 10400, 21, 52, 19, -4, -43 },
  { 10537, 23, 6, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC60PT7B_H_
