#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x40, 0x0C, 0x59, 0x9A, 0xA0, 0x04,
  0x84, 0x82, 0x41, 0x23, 0xF8, 0x90, 0x48, 0x48, 0x24, 0x7F, 0x91, 0x09,
  0x04, 0x82, 0x40, 0x04, 0x1F, 0x24, 0x28, 0x28, 0x28, 0x18, 0x08, 0x14,
  0x12, 0x12, 0x14, 0xD8, 0x20, 0x20, 0x30, 0x92, 0x24, 0x92, 0x24, 0x8A,
  0x25, 0x09, 0x5E, 0x69, 0x6A, 0x45, 0x11, 0x44, 0x92, 0x44, 0x91, 0xC0,
  0x0C, 0x12, 0x12, 0x12, 0x14, 0x14, 0x18, 0x28, 0x49, 0x89, 0x86, 0x84,
  0x84, 0x7A, 0x6A, 0x80, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x80, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x44, 0x21, 0x11,
  0x08, 0x80, 0x13, 0x43, 0xCC, 0xD0, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2,
  0x04, 0x08, 0x10, 0x29, 0x40, 0xF8, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x49, 0x0A,
  0x14, 0x30, 0x60, 0xC2, 0x85, 0x0A, 0x14, 0x49, 0x1E, 0x00, 0x13, 0xD1,
  0x12, 0x22, 0x22, 0x44, 0x44, 0x1C, 0x22, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFC, 0x1C, 0x22, 0x01, 0x01, 0x01,
  0x02, 0x1C, 0x2C, 0x04, 0x02, 0x02, 0x04, 0x04, 0xF8, 0x01, 0x02, 0x06,
  0x0A, 0x0A, 0x12, 0x22, 0x24, 0x44, 0x84, 0xFE, 0x08, 0x08, 0x08, 0x1F,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x7C, 0x04, 0x02, 0x02, 0x02, 0x04, 0x04,
  0xF8, 0x0E, 0x20, 0x82, 0x04, 0x12, 0x3A, 0x42, 0x85, 0x0A, 0x14, 0x28,
  0x9E, 0x00, 0x7E, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x00, 0x0E, 0x11, 0x21, 0x21, 0x21, 0x22, 0x1C, 0x38, 0x44,
  0x82, 0x82, 0x82, 0x84, 0x78, 0x0C, 0x12, 0x21, 0x21, 0x41, 0x41, 0x42,
  0x26, 0x3A, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x20, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x00, 0x24, 0x48, 0x02, 0x18, 0xC2, 0x0C, 0x04, 0x06, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x20, 0x63, 0x08, 0x60,
  0x70, 0x42, 0x10, 0x88, 0x88, 0x44, 0x20, 0x00, 0x40, 0x07, 0x06, 0x22,
  0x05, 0x01, 0x47, 0x62, 0x59, 0x26, 0x49, 0xA2, 0x68, 0x9A, 0x4A, 0x6C,
  0x80, 0x20, 0x04, 0x00, 0xF0, 0x02, 0x02, 0x06, 0x0A, 0x0A, 0x0A, 0x12,
  0x12, 0x3E, 0x22, 0x42, 0x41, 0x81, 0x81, 0x1E, 0x08, 0x84, 0x24, 0x12,
  0x11, 0x08, 0xF8, 0x44, 0x42, 0x20, 0x90, 0x88, 0x48, 0x67, 0xC0, 0x0F,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x78, 0x1E, 0x08, 0x84, 0x24, 0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0,
  0x90, 0x48, 0x48, 0x47, 0xC0, 0x1F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x3E,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0xFC, 0x1F, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0F, 0x08, 0x48,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x0E, 0x81, 0x40, 0xA0, 0x50, 0x44, 0x23,
  0xF0, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x88, 0x23, 0xF8, 0x82, 0x41,
  0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x80, 0x1C, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x23, 0x80, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xE0, 0x10, 0x88, 0x44,
  0x44, 0x42, 0x41, 0x40, 0xC0, 0x50, 0x48, 0x24, 0x11, 0x08, 0x88, 0x44,
  0x10, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x7C, 0x10, 0x08,
  0x80, 0xC4, 0x0C, 0x50, 0x62, 0x85, 0x14, 0x28, 0xA2, 0x45, 0x14, 0x49,
  0x22, 0x49, 0x12, 0x88, 0x94, 0x48, 0xC4, 0x42, 0x20, 0x10, 0x44, 0x11,
  0x04, 0xA1, 0x28, 0x4A, 0x22, 0x48, 0x92, 0x44, 0x91, 0x24, 0x31, 0x0C,
  0x83, 0x20, 0x40, 0x0E, 0x08, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x02,
  0x81, 0x40, 0xA0, 0x50, 0x48, 0x43, 0xC0, 0x1C, 0x13, 0x11, 0x21, 0x21,
  0x21, 0x22, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0E, 0x08, 0x88,
  0x28, 0x14, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x43,
  0x40, 0x40, 0x10, 0x08, 0x00, 0x1C, 0x13, 0x11, 0x21, 0x21, 0x21, 0x22,
  0x3C, 0x48, 0x44, 0x44, 0x44, 0x84, 0x84, 0x0E, 0x31, 0x20, 0x20, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0xF8, 0xFC, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x00, 0x20, 0x90, 0x50, 0x28,
  0x24, 0x12, 0x09, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0x48, 0x43, 0xC0,
  0x83, 0x06, 0x14, 0x28, 0x51, 0x22, 0x48, 0x91, 0x42, 0x86, 0x0C, 0x10,
  0x00, 0x82, 0x18, 0x41, 0x84, 0x28, 0xA2, 0x8A, 0x29, 0x24, 0x92, 0x49,
  0x28, 0xA2, 0x8A, 0x28, 0xC3, 0x0C, 0x30, 0x86, 0x08, 0x20, 0x10, 0x88,
  0x44, 0x41, 0x20, 0xA0, 0x60, 0x30, 0x10, 0x14, 0x0A, 0x09, 0x08, 0x84,
  0x24, 0x10, 0x86, 0x18, 0xA2, 0x92, 0x4A, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x00, 0x1F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x07, 0xF0, 0x1E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x48, 0x92, 0x49,
  0x22, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0xE0, 0x10, 0x30, 0xA1, 0x24, 0x48, 0xA0, 0xC1,
  0xFC, 0xA4, 0x3E, 0x8D, 0x0C, 0x28, 0x50, 0xA1, 0x44, 0x89, 0xF0, 0x10,
  0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x44,
  0xB8, 0x3D, 0x04, 0x20, 0x82, 0x08, 0x20, 0x83, 0xC0, 0x01, 0x01, 0x01,
  0x02, 0x3E, 0x42, 0x42, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0xF8, 0x3D,
  0x14, 0x62, 0xF2, 0x08, 0x20, 0x81, 0xC0, 0x03, 0x82, 0x01, 0x00, 0x80,
  0x80, 0xF0, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x10, 0x00, 0x1F, 0x21, 0x21, 0x42, 0x42, 0x42,
  0x42, 0x44, 0x44, 0x7C, 0x04, 0x04, 0x08, 0x98, 0x60, 0x10, 0x20, 0x41,
  0x03, 0xE4, 0x48, 0xA1, 0x42, 0x85, 0x0A, 0x28, 0x50, 0x80, 0x11, 0x00,
  0x22, 0x24, 0x44, 0x44, 0x88, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x20,
  0x41, 0x02, 0x24, 0x8A, 0x28, 0x50, 0xE1, 0x22, 0x48, 0x90, 0x80, 0x11,
  0x12, 0x22, 0x24, 0x44, 0x44, 0x88, 0x3E, 0xE2, 0x31, 0x22, 0x14, 0x22,
  0x42, 0x24, 0x22, 0x44, 0x24, 0x42, 0x84, 0x48, 0x44, 0x3E, 0x44, 0x8A,
  0x14, 0x28, 0x50, 0xA2, 0x85, 0x08, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x61,
  0x8B, 0xC0, 0x17, 0x0C, 0x44, 0x22, 0x12, 0x09, 0x08, 0x84, 0x42, 0x22,
  0x2E, 0x10, 0x08, 0x04, 0x04, 0x00, 0x3E, 0x85, 0x0C, 0x28, 0x50, 0xA1,
  0x46, 0x89, 0xF0, 0x20, 0x40, 0x82, 0x00, 0x3C, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x82, 0x00, 0x3D, 0x04, 0x10, 0x20, 0x40, 0x82, 0x0B, 0xC0, 0x64,
  0xF4, 0x48, 0x88, 0x88, 0x8C, 0x42, 0x85, 0x14, 0x28, 0x50, 0xA2, 0x44,
  0x89, 0xF0, 0x86, 0x18, 0xA2, 0x92, 0x4A, 0x28, 0xC1, 0x00, 0x88, 0x62,
  0x29, 0x4A, 0x52, 0x95, 0x29, 0x4A, 0x63, 0x18, 0xC4, 0x21, 0x00, 0x11,
  0x12, 0x14, 0x14, 0x08, 0x18, 0x18, 0x24, 0x44, 0x84, 0x10, 0x88, 0x44,
  0x42, 0x21, 0x20, 0x90, 0x30, 0x18, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01,
  0x03, 0x00, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0xF0, 0x04,
  0x61, 0x04, 0x20, 0x82, 0x08, 0xC1, 0x04, 0x10, 0x42, 0x08, 0x20, 0x60,
  0xFF, 0xFF, 0xE0, 0x18, 0x10, 0x41, 0x04, 0x20, 0x82, 0x04, 0x21, 0x04,
  0x10, 0x42, 0x08, 0xC0, 0x61, 0x3C,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 5, 2, -14 },
  { 11, 9, 14, 9, 0, -14 },
  { 27, 8, 15, 8, 0, -14 },
  { 42, 10, 14, 12, 1, -14 },
  { 60, 8, 14, 8, 0, -14 },
  { 74, 2, 5, 3, 2, -14 },
  { 76, 5, 17, 5, 1, -14 },
  { 87, 5, 17, 5, -1, -14 },
  { 98, 6, 6, 7, 2, -14 },
  { 103, 7, 9, 9, 1, -11 },
  { 111, 3, 4, 3, -1, -2 },
  { 113, 5, 1, 5, 0, -6 },
  { 114, 2, 1, 3, 0, -1 },
  { 115, 8, 14, 6, -1, -14 },
  { 129, 7, 14, 8, 1, -14 },
  { 142, 4, 14, 8, 2, -14 },
  { 149, 8, 14, 8, 0, -14 },
  { 163, 8, 14, 8, 0, -14 },
  { 177, 8, 14, 8, 0, -14 },
  { 191, 8, 14, 8, 0, -14 },
  { 205, 7, 14, 8, 1, -14 },
  { 218, 7, 14, 8, 1, -14 },
  { 231, 8, 14, 8, 0, -14 },
  { 245, 8, 14, 8, 0, -14 },
  { 259, 3, 10, 3, 0, -10 },
  { 263, 4, 12, 3, -1, -10 },
  { 269, 7, 8, 9, 1, -11 },
  { 276, 7, 5, 9, 1, -9 },
  { 281, 7, 8, 9, 1, -11 },
  { 288, 5, 14, 6, 1, -14 },
  { 297, 10, 16, 12, 1, -14 },
  { 317, 8, 14, 8, -1, -14 },
  { 331, 9, 14, 9, 0, -14 },
  { 347, 8, 14, 8, 1, -14 },
  { 361, 9, 14, 9, 0, -14 },
  { 377, 8, 14, 8, 0, -14 },
  { 391, 8, 14, 7, 0, -14 },
  { 405, 9, 14, 10, 1, -14 },
  { 421, 10, 14, 10, 0, -14 },
  { 439, 6, 14, 4, -1, -14 },
  { 450, 7, 17, 4, -3, -14 },
  { 465, 9, 14, 8, 0, -14 },
  { 481, 5, 14, 7, 0, -14 },
  { 490, 13, 14, 13, 0, -14 },
  { 513, 10, 14, 10, 0, -14 },
  { 531, 9, 14, 10, 1, -14 },
  { 547, 8, 14, 8, 0, -14 },
  { 561, 9, 17, 10, 1, -14 },
  { 581, 8, 14, 8, 0, -14 },
  { 595, 8, 14, 7, 0, -14 },
  { 609, 6, 14, 7, 2, -14 },
  { 620, 9, 14, 10, 1, -14 },
  { 636, 7, 14, 8, 2, -14 },
  { 649, 12, 14, 13, 2, -14 },
  { 670, 9, 14, 7, -1, -14 },
  { 686, 6, 14, 7, 2, -14 },
  { 697, 9, 14, 7, -1, -14 },
  { 713, 7, 17, 5, 0, -14 },
  { 728, 3, 14, 6, 2, -14 },
  { 734, 7, 17, 5, -1, -14 },
  { 749, 7, 8, 8, 1, -14 },
  { 756, 6, 1, 6, -2, 2 },
  { 757, 2, 3, 4, 3, -15 },
  { 758, 7, 10, 8, 1, -10 },
  { 767, 8, 14, 8, 0, -14 },
  { 781, 6, 10, 6, 1, -10 },
  { 789, 8, 14, 8, 1, -14 },
  { 803, 6, 10, 7, 1, -10 },
  { 811, 9, 20, 4, -2, -15 },
  { 834, 8, 15, 8, 0, -10 },
  { 849, 7, 14, 8, 0, -14 },
  { 862, 4, 14, 3, 0, -14 },
  { 869, 7, 19, 3, -3, -14 },
  { 886, 7, 14, 7, 0, -14 },
  { 899, 4, 14, 3, 0, -14 },
  { 906, 12, 10, 12, 0, -10 },
  { 921, 7, 10, 8, 0, -10 },
  { 930, 6, 10, 8, 1, -10 },
  { 938, 9, 14, 8, -1, -10 },
  { 954, 7, 14, 8, 1, -10 },
  { 967, 6, 10, 5, 0, -10 },
  { 975, 6, 10, 6, 0, -10 },
  { 983, 4, 12, 4, 1, -12 },
  { 989, 7, 10, 8, 1, -10 },
  { 998, 6, 10, 6, 1, -10 },
  { 1006, 10, 10, 10, 1, -10 },
  { 1019, 8, 10, 7, -1, -10 },
  { 1029, 9, 15, 6, -2, -10 },
  { 1046, 7, 10, 6, -1, -10 },
  { 1055, 6, 17, 6, 1, -14 },
  { 1068, 1, 19, 8, 3, -14 },
  { 1071, 6, 17, 6, -1, -14 },
  { 1084, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC19PT7B_H_
