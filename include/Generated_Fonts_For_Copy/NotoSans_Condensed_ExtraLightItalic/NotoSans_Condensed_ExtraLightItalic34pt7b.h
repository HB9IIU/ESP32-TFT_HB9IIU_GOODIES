#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x61, 0x00, 0x00, 0x02, 0x0C, 0x20, 0x23, 0x22, 0x22, 0x62, 0x42,
  0x44, 0x44, 0x44, 0x84, 0x00, 0xC2, 0x00, 0x84, 0x00, 0x84, 0x01, 0x84,
  0x01, 0x0C, 0x01, 0x08, 0x03, 0x08, 0x1F, 0xFF, 0x02, 0x10, 0x06, 0x10,
  0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x60, 0xFF, 0xFC,
  0x18, 0x40, 0x10, 0x40, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x21, 0x00,
  0x21, 0x00, 0x41, 0x00, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x7E, 0x06,
  0x4C, 0x31, 0x00, 0x88, 0x06, 0x20, 0x18, 0x80, 0x62, 0x00, 0x88, 0x03,
  0x40, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x02, 0x20, 0x08, 0x80,
  0x23, 0x00, 0x8C, 0x04, 0x20, 0x10, 0x88, 0x44, 0x3F, 0xE0, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0D, 0x81, 0x8C, 0x40, 0x84,
  0x20, 0xC6, 0x10, 0x42, 0x08, 0x41, 0x04, 0x21, 0x82, 0x20, 0x83, 0x30,
  0x41, 0x10, 0x20, 0x99, 0xD0, 0x49, 0xB8, 0x49, 0x8C, 0x64, 0x85, 0xE4,
  0x82, 0x46, 0x41, 0x02, 0x20, 0x83, 0x30, 0x41, 0x10, 0x61, 0x08, 0x20,
  0x84, 0x10, 0x82, 0x18, 0xC1, 0x08, 0x40, 0xCC, 0x60, 0x3C, 0x00, 0x00,
  0xC0, 0x07, 0xC0, 0x21, 0x01, 0x86, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01,
  0x0C, 0x04, 0x20, 0x11, 0x00, 0x68, 0x00, 0xC0, 0x07, 0x00, 0x24, 0x01,
  0x10, 0x48, 0x61, 0x60, 0x8D, 0x03, 0x2C, 0x05, 0xB0, 0x14, 0xC0, 0x63,
  0x01, 0x8C, 0x0F, 0x18, 0x64, 0x3F, 0x18, 0x24, 0xB4, 0x92, 0x80, 0x00,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x10, 0x18,
  0x08, 0x08, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x43, 0x10, 0x64, 0x07,
  0xF0, 0xC0, 0x50, 0x62, 0x30, 0x80, 0x10, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x1F, 0xFF, 0xFF, 0xF8, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x13, 0x26, 0x4C,
  0x80, 0xFE, 0xB8, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x1F, 0x01, 0x84, 0x18, 0x20, 0x81, 0x88, 0x0C, 0x40, 0x66,
  0x03, 0x20, 0x19, 0x00, 0xD8, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0B, 0x00,
  0xD8, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00, 0x88, 0x0C, 0x60, 0x41,
  0x06, 0x0C, 0x60, 0x3E, 0x00, 0x06, 0x14, 0xDB, 0x2C, 0x40, 0x81, 0x06,
  0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x00, 0x60, 0x07, 0xF0, 0x18, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0xE0, 0x00, 0xC0, 0x1F, 0xC0, 0xC0, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x38, 0x0F, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x20, 0x60, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x60, 0x09, 0x00, 0x64, 0x01,
  0x10, 0x08, 0x40, 0x43, 0x03, 0x08, 0x08, 0x20, 0x40, 0x83, 0x06, 0x08,
  0x18, 0x40, 0x43, 0x01, 0x0F, 0xFF, 0x80, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x48, 0x01, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x08, 0x18, 0x3F, 0xC0, 0x00,
  0x30, 0x0F, 0xC0, 0xC0, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x09, 0xE0, 0xD9, 0x85, 0x02, 0x30, 0x11, 0x00, 0xD8,
  0x06, 0xC0, 0x26, 0x01, 0x30, 0x09, 0x80, 0x4C, 0x06, 0x60, 0x21, 0x03,
  0x0C, 0x30, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x60,
  0x83, 0x03, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x03, 0x08, 0x08, 0x30,
  0x40, 0x62, 0x00, 0xF0, 0x03, 0x80, 0x33, 0x01, 0x06, 0x08, 0x08, 0x40,
  0x31, 0x00, 0x4C, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0x84, 0x06, 0x18,
  0x30, 0x3F, 0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x61, 0x83, 0x02, 0x08, 0x08,
  0x60, 0x31, 0x00, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x23, 0x00, 0x8C, 0x06,
  0x10, 0x18, 0x40, 0xE0, 0xFD, 0x01, 0x84, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0xFC, 0x00, 0x0C,
  0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xC3,
  0x00, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x04, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x00, 0x06, 0x0F,
  0xE2, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x10, 0x0C,
  0x01, 0x02, 0x00, 0x30, 0xC0, 0x02, 0x10, 0x00, 0x44, 0x00, 0x09, 0x83,
  0xF1, 0x20, 0x84, 0x24, 0x30, 0x85, 0x84, 0x10, 0xA1, 0x04, 0x14, 0x20,
  0x82, 0x8C, 0x10, 0xF1, 0x06, 0x14, 0x20, 0x82, 0x84, 0x10, 0x90, 0x86,
  0x12, 0x19, 0xC4, 0x41, 0xE7, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x03, 0x06, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x18, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x20, 0x08, 0x80,
  0x62, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82, 0x06, 0x08, 0x10, 0x20,
  0xFF, 0x82, 0x02, 0x18, 0x08, 0x40, 0x23, 0x00, 0x88, 0x02, 0x60, 0x09,
  0x00, 0x34, 0x00, 0xF0, 0x03, 0x0F, 0xF0, 0x30, 0x60, 0x80, 0xC2, 0x01,
  0x08, 0x04, 0x60, 0x11, 0x80, 0x44, 0x03, 0x10, 0x08, 0x40, 0x43, 0x0E,
  0x0F, 0xF0, 0x20, 0x60, 0x80, 0xC2, 0x01, 0x18, 0x04, 0x40, 0x11, 0x00,
  0x44, 0x01, 0x10, 0x0C, 0xC0, 0x22, 0x01, 0x08, 0x18, 0x3F, 0xC0, 0x00,
  0x30, 0x03, 0xFC, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x20, 0x1F, 0x80, 0x0F, 0xF0,
  0x18, 0x30, 0x20, 0x30, 0x40, 0x20, 0x80, 0x63, 0x00, 0x46, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0xC0, 0x09, 0x00, 0x32, 0x00, 0x64, 0x00,
  0x88, 0x01, 0x30, 0x06, 0x40, 0x08, 0x80, 0x31, 0x00, 0x46, 0x01, 0x8C,
  0x06, 0x10, 0x18, 0x20, 0xE0, 0x7E, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0F, 0xF8, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xE0,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x07,
  0x01, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x7C, 0x80,
  0x84, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0xC0, 0x10, 0x60, 0x10, 0x30, 0x10, 0x1F, 0xE0, 0x0C, 0x00, 0x86,
  0x00, 0xC2, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x87, 0xFF, 0x82, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x10,
  0x02, 0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20,
  0x07, 0xC0, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x03, 0xE0, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x98, 0x0F, 0x00, 0x0C, 0x03, 0x0C, 0x04, 0x08, 0x08, 0x08, 0x18, 0x08,
  0x30, 0x18, 0x60, 0x18, 0xC0, 0x10, 0x80, 0x11, 0x00, 0x13, 0x00, 0x36,
  0x00, 0x2E, 0x00, 0x3A, 0x00, 0x33, 0x00, 0x21, 0x00, 0x61, 0x00, 0x41,
  0x80, 0x40, 0x80, 0x40, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x40, 0x80,
  0x40, 0x80, 0x60, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0xFF, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xA0, 0x03, 0x82, 0x80, 0x0A, 0x0A, 0x00, 0x68, 0x68, 0x01, 0x61, 0xA0,
  0x0D, 0x04, 0x80, 0x24, 0x12, 0x01, 0x90, 0x48, 0x04, 0x43, 0x20, 0x33,
  0x08, 0xC0, 0x88, 0x23, 0x06, 0x20, 0x8C, 0x10, 0x82, 0x10, 0xC6, 0x18,
  0x42, 0x18, 0x41, 0x18, 0x41, 0x04, 0x41, 0x04, 0x13, 0x04, 0x30, 0x48,
  0x30, 0xC1, 0x60, 0x82, 0x05, 0x02, 0x08, 0x1C, 0x08, 0x20, 0x60, 0x60,
  0x0C, 0x00, 0xC3, 0x80, 0x20, 0xA0, 0x08, 0x28, 0x06, 0x0A, 0x01, 0x06,
  0xC0, 0x41, 0x90, 0x10, 0x44, 0x04, 0x11, 0x03, 0x04, 0x60, 0x83, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x31, 0x82, 0x04, 0x41, 0x81, 0x10,
  0x40, 0x44, 0x10, 0x1B, 0x04, 0x02, 0xC3, 0x00, 0xA0, 0xC0, 0x28, 0x20,
  0x0E, 0x08, 0x01, 0x82, 0x00, 0x40, 0x00, 0x40, 0x07, 0xF0, 0x18, 0x30,
  0x60, 0x31, 0x80, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x60, 0x02, 0x80,
  0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x18, 0x06, 0x10,
  0x18, 0x30, 0x60, 0x3F, 0x80, 0x0F, 0xE0, 0x30, 0x60, 0x80, 0x82, 0x03,
  0x08, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x63, 0x01,
  0x0C, 0x08, 0x23, 0xC0, 0xFC, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x07, 0xF0, 0x18, 0x30, 0x60, 0x31, 0x80, 0x22, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x60, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00,
  0xC8, 0x01, 0x18, 0x06, 0x10, 0x18, 0x30, 0x60, 0x3F, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x0F, 0xE0,
  0x30, 0x60, 0x80, 0x82, 0x03, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x02,
  0x10, 0x08, 0x40, 0x63, 0x03, 0x0C, 0x18, 0x3F, 0xC0, 0x84, 0x02, 0x10,
  0x18, 0x60, 0x41, 0x81, 0x02, 0x04, 0x08, 0x30, 0x30, 0xC0, 0xC2, 0x01,
  0x08, 0x04, 0x20, 0x18, 0x00, 0x40, 0x0F, 0xF0, 0xC0, 0x42, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x20, 0x60, 0xFF, 0x00,
  0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x18, 0x03, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x30, 0x06,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x30, 0x80, 0x20, 0x80, 0x60, 0xC0, 0x40, 0x40, 0xC0, 0x3F, 0x00,
  0x80, 0x0E, 0x00, 0x68, 0x01, 0x20, 0x04, 0xC0, 0x23, 0x00, 0x8C, 0x06,
  0x30, 0x10, 0xC0, 0xC3, 0x02, 0x0C, 0x18, 0x10, 0x40, 0x43, 0x01, 0x08,
  0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x16, 0x00, 0x50,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x50, 0x12, 0x03, 0x40, 0x48, 0x09,
  0x03, 0x20, 0x24, 0x08, 0x81, 0x10, 0x62, 0x04, 0x41, 0x0C, 0x31, 0x04,
  0x30, 0x84, 0x30, 0xC6, 0x10, 0x83, 0x10, 0x46, 0x0C, 0x41, 0x10, 0x32,
  0x04, 0x40, 0xC8, 0x12, 0x03, 0x60, 0x48, 0x0D, 0x01, 0x60, 0x3C, 0x05,
  0x00, 0xA0, 0x1C, 0x02, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x02, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08,
  0x40, 0x06, 0x60, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0C, 0xC0, 0x04, 0x60,
  0x06, 0x10, 0x02, 0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x81, 0x00,
  0x41, 0x80, 0x20, 0x80, 0x3C, 0x02, 0xC0, 0x64, 0x04, 0x40, 0x84, 0x18,
  0x41, 0x04, 0x30, 0x62, 0x06, 0x60, 0x24, 0x02, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0F, 0xE0, 0x00, 0xC2, 0x10, 0x84, 0x31, 0x84, 0x21, 0x08, 0x43, 0x08,
  0x42, 0x10, 0x86, 0x30, 0x84, 0x21, 0x03, 0xF0, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0xFC, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xB0, 0x0C, 0x80, 0x44, 0x04, 0x30,
  0x60, 0x82, 0x04, 0x30, 0x11, 0x00, 0x98, 0x06, 0x80, 0x18, 0x00, 0x80,
  0xFF, 0xE0, 0x84, 0x42, 0x30, 0x07, 0xC8, 0x61, 0x46, 0x0A, 0x20, 0x32,
  0x01, 0x10, 0x09, 0x80, 0x48, 0x06, 0x40, 0x36, 0x01, 0x30, 0x09, 0x80,
  0xC8, 0x06, 0x40, 0x33, 0x03, 0x08, 0x28, 0x63, 0x41, 0xF6, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x09, 0xF0, 0x2C, 0x60, 0xC0, 0x87, 0x03, 0x18, 0x0C, 0x60, 0x31,
  0x00, 0xC4, 0x03, 0x30, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x11,
  0x80, 0xC6, 0x02, 0x18, 0x18, 0x50, 0xC3, 0x3E, 0x00, 0x07, 0xE1, 0x80,
  0x60, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x61, 0x07, 0xE0, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x07, 0xC8, 0x18, 0x50, 0x60, 0x60, 0x80, 0xC2, 0x01, 0x84, 0x02,
  0x18, 0x04, 0x20, 0x08, 0x40, 0x31, 0x80, 0x43, 0x00, 0x86, 0x03, 0x08,
  0x06, 0x10, 0x0C, 0x30, 0x30, 0x20, 0xE0, 0x63, 0x40, 0x7C, 0x80, 0x07,
  0xC1, 0x84, 0x60, 0x98, 0x12, 0x02, 0x40, 0xD0, 0x12, 0x0C, 0x7F, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x87, 0xF0,
  0x00, 0x0F, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x03, 0xE4, 0x18, 0x50,
  0xC0, 0xC2, 0x03, 0x10, 0x0C, 0x40, 0x23, 0x00, 0x88, 0x02, 0x20, 0x19,
  0x80, 0x46, 0x01, 0x18, 0x0C, 0x40, 0x31, 0x00, 0xC6, 0x06, 0x18, 0x38,
  0x31, 0xA0, 0x7C, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x83, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x09, 0xF0, 0x50, 0xC3, 0x02,
  0x18, 0x11, 0x80, 0x8C, 0x04, 0x40, 0x62, 0x02, 0x30, 0x11, 0x80, 0x88,
  0x04, 0x40, 0x62, 0x02, 0x30, 0x11, 0x00, 0x88, 0x0C, 0x40, 0x66, 0x02,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x18, 0x41, 0x82, 0x08, 0x30, 0x81, 0x88, 0x08, 0xC0, 0x4C, 0x02, 0xC0,
  0x36, 0x01, 0x58, 0x0C, 0x40, 0x42, 0x02, 0x10, 0x30, 0xC1, 0x02, 0x08,
  0x10, 0x40, 0x86, 0x06, 0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x06,
  0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x41, 0x80, 0x09, 0xF1, 0xF0, 0x50, 0x90, 0x83, 0x07, 0x06,
  0x30, 0x30, 0x31, 0x81, 0x81, 0x8C, 0x08, 0x08, 0x40, 0x40, 0x42, 0x02,
  0x02, 0x30, 0x30, 0x31, 0x81, 0x81, 0x88, 0x08, 0x08, 0x40, 0x40, 0x42,
  0x02, 0x02, 0x30, 0x30, 0x31, 0x01, 0x01, 0x08, 0x08, 0x08, 0x40, 0x40,
  0x46, 0x06, 0x06, 0x00, 0x09, 0xF0, 0x50, 0xC3, 0x02, 0x38, 0x11, 0x80,
  0x8C, 0x04, 0x40, 0x62, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0x40, 0x62,
  0x02, 0x30, 0x11, 0x00, 0x88, 0x0C, 0x40, 0x66, 0x02, 0x00, 0x07, 0xE0,
  0xC2, 0x18, 0x33, 0x01, 0x20, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x1C,
  0x01, 0xC0, 0x3C, 0x02, 0x80, 0x2C, 0x06, 0xC0, 0x44, 0x08, 0x61, 0x83,
  0xE0, 0x04, 0xF8, 0x0B, 0x18, 0x1C, 0x10, 0x70, 0x30, 0xC0, 0x61, 0x80,
  0xC2, 0x01, 0x84, 0x03, 0x18, 0x04, 0x30, 0x08, 0x40, 0x10, 0x80, 0x61,
  0x00, 0x86, 0x01, 0x0C, 0x04, 0x18, 0x18, 0x28, 0x60, 0x4F, 0x81, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x07, 0xC8, 0x61, 0x46, 0x0A, 0x20, 0x32, 0x01, 0x90, 0x09,
  0x80, 0x48, 0x02, 0x40, 0x36, 0x01, 0x30, 0x09, 0x80, 0x48, 0x06, 0x40,
  0x33, 0x03, 0x18, 0x38, 0x63, 0x41, 0xF2, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x09, 0xE1, 0x40,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x0F, 0xE3,
  0x04, 0xC0, 0x18, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x83, 0x1F, 0xC0, 0x08,
  0x08, 0x18, 0x10, 0x7F, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x10, 0x18, 0x80,
  0xC4, 0x04, 0x60, 0x22, 0x01, 0x10, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x22,
  0x01, 0x10, 0x18, 0x80, 0x8C, 0x04, 0x60, 0x62, 0x03, 0x18, 0x28, 0xC2,
  0x83, 0xE4, 0x00, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x48, 0x19, 0x02, 0x20,
  0xC4, 0x10, 0xC6, 0x18, 0x83, 0x30, 0x64, 0x0D, 0x80, 0xA0, 0x14, 0x03,
  0x00, 0x60, 0x08, 0x00, 0x80, 0xC0, 0xE0, 0x30, 0x28, 0x14, 0x1A, 0x07,
  0x04, 0x83, 0xC3, 0x20, 0x90, 0x88, 0x64, 0x22, 0x11, 0x10, 0x84, 0x44,
  0x22, 0x13, 0x08, 0x84, 0x82, 0x41, 0x20, 0x90, 0x50, 0x2C, 0x14, 0x0A,
  0x07, 0x02, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x08, 0x0C, 0x20,
  0x60, 0xC1, 0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0x28, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x50, 0x03, 0x40, 0x19, 0x80, 0x42, 0x02, 0x08, 0x18,
  0x20, 0x40, 0xC2, 0x01, 0x00, 0x03, 0x00, 0x81, 0x80, 0xC0, 0xC0, 0x40,
  0x20, 0x60, 0x10, 0x20, 0x08, 0x30, 0x04, 0x10, 0x02, 0x18, 0x01, 0x08,
  0x00, 0x8C, 0x00, 0x44, 0x00, 0x26, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0F, 0xF8, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x00, 0xC0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0xF0, 0x00, 0x10, 0x0F, 0xC1, 0x83, 0xF0, 0x04,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 8, 9, 10, 3, -24 },
  { 28, 16, 24, 15, 0, -24 },
  { 76, 14, 28, 14, 0, -26 },
  { 125, 17, 25, 21, 2, -25 },
  { 179, 14, 25, 15, 0, -25 },
  { 223, 3, 9, 5, 3, -24 },
  { 227, 9, 29, 8, 1, -24 },
  { 260, 9, 29, 8, -2, -24 },
  { 293, 10, 11, 13, 4, -26 },
  { 307, 13, 16, 15, 1, -20 },
  { 333, 4, 7, 6, -1, -3 },
  { 337, 7, 1, 9, 1, -10 },
  { 338, 2, 3, 6, 1, -3 },
  { 339, 15, 24, 10, -2, -24 },
  { 384, 13, 25, 14, 1, -25 },
  { 425, 7, 24, 14, 4, -24 },
  { 446, 15, 25, 14, -1, -25 },
  { 493, 14, 25, 14, 0, -25 },
  { 537, 14, 25, 14, 0, -25 },
  { 581, 14, 24, 14, 0, -24 },
  { 623, 13, 25, 14, 1, -25 },
  { 664, 13, 24, 14, 2, -24 },
  { 703, 14, 25, 14, 0, -25 },
  { 747, 14, 25, 14, 0, -25 },
  { 791, 6, 18, 6, 0, -18 },
  { 805, 8, 22, 6, -2, -18 },
  { 827, 13, 14, 15, 1, -19 },
  { 850, 13, 8, 15, 1, -16 },
  { 863, 13, 14, 15, 1, -19 },
  { 886, 10, 25, 10, 1, -25 },
  { 918, 19, 27, 21, 1, -24 },
  { 983, 14, 24, 14, -2, -24 },
  { 1025, 14, 24, 15, 1, -24 },
  { 1067, 15, 25, 14, 2, -25 },
  { 1114, 15, 24, 17, 1, -24 },
  { 1159, 14, 24, 14, 1, -24 },
  { 1201, 14, 24, 13, 1, -24 },
  { 1243, 16, 25, 18, 2, -25 },
  { 1293, 17, 24, 18, 1, -24 },
  { 1344, 10, 24, 7, -1, -24 },
  { 1374, 12, 30, 6, -5, -24 },
  { 1419, 16, 24, 14, 1, -24 },
  { 1467, 9, 24, 12, 1, -24 },
  { 1494, 22, 24, 23, 1, -24 },
  { 1560, 18, 24, 18, 1, -24 },
  { 1614, 15, 25, 18, 2, -25 },
  { 1661, 14, 24, 14, 1, -24 },
  { 1703, 15, 31, 18, 2, -25 },
  { 1762, 14, 24, 15, 1, -24 },
  { 1804, 14, 25, 13, 0, -25 },
  { 1848, 12, 24, 12, 3, -24 },
  { 1884, 16, 24, 17, 2, -24 },
  { 1932, 14, 24, 14, 3, -24 },
  { 1974, 22, 24, 23, 3, -24 },
  { 2040, 17, 24, 13, -2, -24 },
  { 2091, 12, 24, 12, 3, -24 },
  { 2127, 16, 24, 13, -1, -24 },
  { 2175, 13, 29, 10, -1, -24 },
  { 2223, 5, 24, 11, 3, -24 },
  { 2238, 12, 29, 10, -2, -24 },
  { 2282, 13, 13, 15, 1, -24 },
  { 2304, 11, 1, 10, -3, 3 },
  { 2306, 4, 5, 8, 5, -26 },
  { 2309, 13, 18, 15, 1, -18 },
  { 2339, 14, 26, 15, 0, -26 },
  { 2385, 11, 18, 11, 1, -18 },
  { 2410, 15, 26, 15, 1, -26 },
  { 2459, 11, 18, 13, 1, -18 },
  { 2484, 16, 34, 7, -4, -26 },
  { 2552, 14, 26, 15, 0, -18 },
  { 2598, 13, 26, 14, 0, -26 },
  { 2641, 7, 24, 6, 0, -24 },
  { 2662, 12, 32, 6, -5, -24 },
  { 2710, 13, 26, 12, 0, -26 },
  { 2753, 7, 26, 6, 0, -26 },
  { 2776, 21, 18, 22, 0, -18 },
  { 2824, 13, 18, 14, 0, -18 },
  { 2854, 12, 18, 15, 1, -18 },
  { 2881, 15, 26, 15, -1, -18 },
  { 2930, 13, 26, 15, 1, -18 },
  { 2973, 11, 18, 10, 0, -18 },
  { 2998, 11, 18, 11, 0, -18 },
  { 3023, 8, 22, 8, 1, -22 },
  { 3045, 13, 18, 14, 1, -18 },
  { 3075, 11, 18, 11, 2, -18 },
  { 3100, 18, 18, 18, 2, -18 },
  { 3141, 14, 18, 12, -1, -18 },
  { 3173, 17, 26, 12, -4, -18 },
  { 3229, 12, 18, 10, -1, -18 },
  { 3256, 12, 29, 11, 1, -24 },
  { 3300, 2, 34, 14, 6, -26 },
  { 3309, 12, 29, 11, -2, -24 },
  { 3353, 12, 4, 15, 2, -14 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC34PT7B_H_
