#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x0E, 0x03, 0x00, 0x38, 0x66,
  0x0C, 0xC1, 0x98, 0x62, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x88, 0x33,
  0x06, 0x60, 0x8C, 0x10, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x08,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x0C, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10,
  0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x7F, 0xFF,
  0xF0, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xF8, 0x03, 0xD9, 0xE0, 0x30, 0xC1, 0x03, 0x04, 0x00,
  0x18, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04,
  0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x1C, 0xC0, 0x00,
  0x74, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xB8,
  0x00, 0x04, 0xE0, 0x00, 0x23, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x83, 0x04, 0x04, 0x38, 0x38, 0x67, 0x80, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC3, 0x00,
  0x60, 0x60, 0xC0, 0x18, 0x18, 0x30, 0x0C, 0x0C, 0x04, 0x02, 0x03, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x18, 0x06,
  0x03, 0x06, 0x01, 0x00, 0xC3, 0x00, 0xC0, 0x20, 0x80, 0x30, 0x18, 0x60,
  0x0C, 0x06, 0x30, 0x03, 0x01, 0x8C, 0x7C, 0xC0, 0xC6, 0x3B, 0xB0, 0x31,
  0x98, 0x2C, 0x08, 0xC6, 0x0F, 0x06, 0x23, 0x03, 0xC3, 0x18, 0xC0, 0xDF,
  0x8C, 0x60, 0x33, 0xC3, 0x18, 0x0C, 0x01, 0x84, 0x03, 0x00, 0x63, 0x00,
  0x80, 0x30, 0xC0, 0x60, 0x08, 0x30, 0x18, 0x06, 0x0C, 0x06, 0x03, 0x02,
  0x01, 0x80, 0xC0, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x0C,
  0x02, 0x06, 0x02, 0x00, 0x81, 0x81, 0x80, 0x30, 0xC0, 0xC0, 0x0C, 0x60,
  0x30, 0x01, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x1C, 0x30, 0x00, 0xC1, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x70,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x63, 0x80, 0x03, 0x38, 0x00, 0x1B,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00,
  0x63, 0x00, 0x06, 0x0C, 0x0C, 0x60, 0x60, 0x67, 0x01, 0x83, 0x30, 0x0C,
  0x33, 0x00, 0x61, 0x98, 0x01, 0x98, 0xC0, 0x0C, 0xCC, 0x00, 0x3C, 0x60,
  0x01, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xE0, 0x07, 0x83, 0x00, 0x66,
  0x1C, 0x06, 0x30, 0x70, 0xE1, 0x81, 0xFE, 0x06, 0x01, 0x00, 0x00, 0x39,
  0x8C, 0x63, 0x31, 0x8C, 0x62, 0x11, 0x8C, 0x00, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x80, 0x80, 0xE1, 0x80, 0x39, 0x80, 0x0D, 0x0E, 0x03, 0xFF,
  0x03, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x38, 0x40, 0x70, 0x60, 0x60, 0x60,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x60,
  0xC3, 0x04, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x07, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x10,
  0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x06, 0x01, 0x81, 0x80, 0x1C, 0xE0, 0x01, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x07, 0x61, 0x8C, 0xE1, 0xB8, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x78, 0x1C,
  0x01, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00,
  0xF0, 0x38, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x20,
  0x07, 0x01, 0xE0, 0xF0, 0x0F, 0xFE, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x37, 0xC0, 0x01, 0xFF, 0xC0, 0x04, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x04, 0x00, 0xE0, 0x3C, 0x3E, 0x00,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x1F, 0xC0, 0x67, 0x9E,
  0x06, 0xC0, 0x70, 0x78, 0x03, 0x07, 0x00, 0x30, 0x60, 0x01, 0x8E, 0x00,
  0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x0C, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x8F, 0x00,
  0x1F, 0xE0, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x60, 0x18, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x18, 0x10,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x07, 0x01, 0xC0, 0x30,
  0x06, 0x07, 0x00, 0x18, 0x70, 0x00, 0x6E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0x98, 0x00, 0x70, 0x60, 0x06, 0x01, 0x80, 0x60, 0x0E, 0x06,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x3C, 0x38, 0x00, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0x07, 0x01, 0xC0,
  0x60, 0x70, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x05,
  0x0E, 0x01, 0xE0, 0xE0, 0xEC, 0x0F, 0xF9, 0x80, 0xFC, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x41, 0xE0, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x06, 0x07,
  0x0E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0xE0,
  0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xF0,
  0x60, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x82, 0x00, 0xFE, 0x04, 0x30, 0x0F,
  0x70, 0x31, 0x00, 0xC1, 0x81, 0x98, 0x0C, 0x0C, 0x08, 0xC0, 0xC0, 0x40,
  0x44, 0x04, 0x06, 0x02, 0x60, 0x60, 0x30, 0x33, 0x03, 0x01, 0x81, 0x98,
  0x30, 0x08, 0x0C, 0x81, 0x80, 0xC0, 0x6C, 0x08, 0x06, 0x06, 0x60, 0xC0,
  0x30, 0x33, 0x06, 0x03, 0x01, 0x98, 0x30, 0x18, 0x18, 0xC1, 0x80, 0xC0,
  0xC6, 0x0C, 0x0E, 0x04, 0x20, 0x60, 0x70, 0x61, 0x03, 0x04, 0x86, 0x08,
  0x0C, 0xE6, 0x60, 0x60, 0x3E, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC2,
  0x00, 0x0C, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x30,
  0x20, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x30, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03,
  0x60, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0x06,
  0x07, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x70,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0xC0,
  0x0E, 0x03, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x38,
  0x06, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0,
  0x60, 0x07, 0x03, 0x00, 0x78, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0x80, 0x80, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x87, 0x00, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0x07, 0xC0, 0x06, 0x01, 0xE0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x20, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x18, 0x00,
  0xE0, 0x30, 0x03, 0x80, 0x40, 0x0E, 0x01, 0x80, 0x78, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x78, 0x07, 0x00,
  0xE0, 0x01, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x07, 0xF8, 0xC0, 0x07, 0xF8, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x1F,
  0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0xE0, 0x00, 0x0D, 0xE0, 0x00, 0x0D, 0xE0, 0x00, 0x0B, 0x30,
  0x00, 0x1E, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xB0,
  0x36, 0x00, 0x00, 0xF0, 0x1B, 0x00, 0x00, 0xD8, 0x0D, 0x80, 0x00, 0x6C,
  0x06, 0xC0, 0x00, 0x66, 0x03, 0x60, 0x00, 0x32, 0x03, 0x30, 0x00, 0x33,
  0x01, 0x98, 0x00, 0x19, 0x80, 0xCC, 0x00, 0x18, 0xC0, 0x62, 0x00, 0x0C,
  0x60, 0x21, 0x00, 0x0C, 0x60, 0x30, 0xC0, 0x06, 0x30, 0x18, 0x60, 0x06,
  0x18, 0x0C, 0x30, 0x03, 0x0C, 0x06, 0x18, 0x03, 0x06, 0x02, 0x0C, 0x01,
  0x86, 0x03, 0x06, 0x01, 0x83, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC1, 0x80,
  0xC0, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x10,
  0x30, 0x30, 0x18, 0x08, 0x30, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x04, 0x03,
  0x18, 0x0C, 0x06, 0x01, 0x8C, 0x06, 0x03, 0x00, 0xCC, 0x03, 0x01, 0x80,
  0x66, 0x01, 0x80, 0xC0, 0x36, 0x00, 0xC0, 0x40, 0x1B, 0x00, 0xC0, 0x60,
  0x0F, 0x00, 0x60, 0x30, 0x07, 0x80, 0x30, 0x18, 0x03, 0x80, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xF0,
  0x00, 0x60, 0x36, 0x00, 0x0C, 0x06, 0xC0, 0x01, 0x80, 0xC8, 0x00, 0x60,
  0x19, 0x80, 0x0C, 0x03, 0x30, 0x01, 0x80, 0xC6, 0x00, 0x30, 0x18, 0x40,
  0x04, 0x03, 0x0C, 0x01, 0x80, 0x61, 0x80, 0x30, 0x08, 0x30, 0x06, 0x03,
  0x02, 0x00, 0xC0, 0x60, 0x60, 0x30, 0x0C, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0xC0, 0x20, 0x10, 0x18, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x30,
  0x0C, 0x18, 0x06, 0x00, 0x83, 0x01, 0x80, 0x18, 0x60, 0x30, 0x03, 0x0C,
  0x06, 0x00, 0x63, 0x00, 0xC0, 0x04, 0x60, 0x18, 0x00, 0xCC, 0x06, 0x00,
  0x19, 0x80, 0xC0, 0x03, 0x20, 0x18, 0x00, 0x2C, 0x03, 0x00, 0x07, 0x80,
  0x40, 0x00, 0xF0, 0x18, 0x00, 0x1E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x07, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x0C,
  0x3F, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x30, 0x03, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x01, 0xC1,
  0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x1C, 0x02, 0x03, 0xC0, 0x3F, 0xFC,
  0x01, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x06, 0x03, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x30, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0x80, 0x0C, 0x3F, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x30, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x60, 0x3C,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x60, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0x70, 0x01, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0xE0,
  0x3E, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00,
  0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x04,
  0x18, 0x00, 0x41, 0x80, 0x04, 0x30, 0x00, 0x43, 0x00, 0x04, 0x60, 0x00,
  0x46, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00,
  0xEC, 0x00, 0x2C, 0x00, 0x66, 0x00, 0x36, 0x00, 0x33, 0x00, 0x1B, 0x00,
  0x31, 0x80, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x0C, 0x60,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x10, 0x06, 0x0C, 0x03, 0x08,
  0x03, 0x06, 0x01, 0x84, 0x03, 0x03, 0x01, 0x82, 0x01, 0x81, 0x80, 0xC1,
  0x00, 0xC0, 0xC0, 0x40, 0x80, 0xC0, 0x60, 0x60, 0x40, 0x60, 0x30, 0x30,
  0x20, 0x60, 0x18, 0x30, 0x10, 0x30, 0x0C, 0x18, 0x08, 0x30, 0x06, 0x18,
  0x04, 0x18, 0x03, 0x0C, 0x02, 0x0C, 0x01, 0x86, 0x01, 0x0C, 0x00, 0xC6,
  0x00, 0x86, 0x00, 0x63, 0x00, 0x46, 0x00, 0x33, 0x00, 0x23, 0x00, 0x19,
  0x80, 0x11, 0x80, 0x0C, 0x80, 0x09, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x03,
  0x60, 0x02, 0xC0, 0x01, 0xE0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0xA0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x40, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0xEC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0C,
  0x18, 0x01, 0x81, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x06, 0x30, 0x00, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x80, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0xC0, 0x40,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x00, 0x7F, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x18, 0x40, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x30,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x30,
  0xFF, 0xFE, 0xE1, 0x86, 0x0C, 0x10, 0x60, 0x83, 0x00, 0xFC, 0x20, 0x79,
  0xC4, 0x1C, 0x0D, 0x87, 0x00, 0xB0, 0xC0, 0x1E, 0x30, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C,
  0x30, 0x07, 0x86, 0x01, 0xB0, 0x60, 0x64, 0x0F, 0x39, 0x80, 0xFE, 0x30,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x3F, 0x80,
  0x67, 0x3C, 0x06, 0xC0, 0xE0, 0x58, 0x06, 0x0F, 0x00, 0x60, 0xF0, 0x06,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x18, 0x70,
  0x01, 0x87, 0x00, 0x30, 0x70, 0x07, 0x0D, 0x00, 0x60, 0xD8, 0x0C, 0x0C,
  0xE3, 0x80, 0x87, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x03, 0xE3, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x60, 0x1F,
  0xE0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0xFE, 0x30, 0x0F, 0x1C, 0x80, 0x70, 0x16, 0x03, 0x80, 0x78, 0x0C,
  0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x38,
  0x0C, 0x01, 0xE0, 0x30, 0x0D, 0x80, 0x60, 0x66, 0x01, 0xE3, 0x10, 0x03,
  0xF8, 0xC0, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xC7, 0x07, 0x03, 0x0E,
  0x03, 0x0C, 0x01, 0x18, 0x01, 0x18, 0x03, 0x30, 0x03, 0x30, 0x07, 0x60,
  0x06, 0x60, 0x1C, 0x60, 0x38, 0xC7, 0xE0, 0xFF, 0x80, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x08, 0x3C, 0x78, 0x1F, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8C, 0x03, 0xC7, 0x20, 0x1C,
  0x04, 0x80, 0xE0, 0x1E, 0x03, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x70,
  0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x78, 0x0C, 0x03, 0x60, 0x18,
  0x19, 0x80, 0x78, 0xEC, 0x00, 0xFE, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x30, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x63, 0xF8,
  0x0C, 0xE3, 0x81, 0xB0, 0x30, 0x2C, 0x03, 0x0F, 0x00, 0x61, 0xC0, 0x0C,
  0x38, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x03, 0x00, 0x00, 0x80, 0x70, 0x38, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x0C,
  0x03, 0x81, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x30,
  0x60, 0x06, 0x1C, 0x00, 0x87, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCE,
  0x00, 0x1B, 0xC0, 0x06, 0xD8, 0x00, 0xF1, 0x80, 0x1C, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x06, 0x3F, 0x07, 0xF0, 0x1B, 0x8E, 0x38, 0xE0, 0x48, 0x1D,
  0x81, 0xC1, 0x40, 0x3C, 0x03, 0x0F, 0x00, 0xE0, 0x0C, 0x38, 0x03, 0x80,
  0x30, 0xE0, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x08,
  0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01, 0x86, 0x00, 0x60, 0x06, 0x18,
  0x01, 0x80, 0x18, 0xC0, 0x04, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x0C, 0x00,
  0xC0, 0x0C, 0x30, 0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x60,
  0x06, 0x18, 0x01, 0x80, 0x18, 0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01,
  0x86, 0x00, 0x60, 0x04, 0x30, 0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x3F, 0x80, 0xCE,
  0x38, 0x13, 0x03, 0x02, 0xC0, 0x30, 0xF0, 0x06, 0x1C, 0x00, 0xC3, 0x80,
  0x18, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x04,
  0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x00, 0x00, 0xFE, 0x00, 0xF1, 0xC0, 0x70, 0x38, 0x38, 0x06, 0x0C, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x60, 0x38, 0x0E, 0x3C, 0x01,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0xC7, 0xF0, 0x01, 0x9C, 0xF0, 0x03, 0x60,
  0x70, 0x05, 0x80, 0x60, 0x1A, 0x00, 0xC0, 0x3C, 0x00, 0x80, 0x70, 0x01,
  0x80, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x10,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x38, 0x0D, 0x00,
  0x60, 0x1B, 0x01, 0x80, 0x33, 0x8E, 0x00, 0x63, 0xF8, 0x00, 0x81, 0x80,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x30,
  0x3C, 0xF2, 0x07, 0x03, 0x20, 0xE0, 0x1E, 0x0C, 0x00, 0xE1, 0x80, 0x0E,
  0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0,
  0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x1E, 0x0C, 0x03, 0x60, 0x60, 0x66, 0x07,
  0x8C, 0xC0, 0x3F, 0x8C, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x3E, 0x0C, 0xE4, 0x13, 0x00, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x01, 0xFE, 0x03, 0xC7, 0xC3, 0x80, 0x41, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x80, 0x70, 0x70, 0x70, 0x3F, 0xF0, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x03, 0xFF, 0x3F, 0xF0, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x62, 0x07, 0xE0, 0x08, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x20,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x82,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x38, 0x30,
  0x07, 0x06, 0x01, 0xE0, 0xC0, 0x6C, 0x0E, 0x39, 0x01, 0xFE, 0x20, 0x04,
  0x00, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x41, 0x80, 0x41, 0x80, 0x43, 0x00,
  0x43, 0x00, 0x66, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0xF0,
  0x03, 0x00, 0x3C, 0x01, 0xC0, 0x1B, 0x00, 0x70, 0x06, 0xC0, 0x34, 0x01,
  0x30, 0x0D, 0x00, 0xCC, 0x02, 0x40, 0x33, 0x01, 0x90, 0x18, 0xC0, 0x44,
  0x06, 0x30, 0x31, 0x03, 0x0C, 0x0C, 0x40, 0xC3, 0x06, 0x10, 0x30, 0xC1,
  0x86, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x63, 0x03, 0x08, 0x18, 0xC0,
  0xC6, 0x06, 0x20, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x1B,
  0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xA0, 0x0D, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x18, 0x08, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x10,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x17,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x3F,
  0x80, 0x17, 0x3E, 0x03, 0xC0, 0x7C, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 11, 13, 15, 5, -36 },
  { 64, 23, 36, 23, 1, -36 },
  { 168, 21, 42, 21, 0, -39 },
  { 279, 26, 38, 31, 3, -37 },
  { 403, 21, 38, 23, 0, -37 },
  { 503, 5, 13, 8, 5, -36 },
  { 512, 15, 44, 13, 1, -36 },
  { 595, 15, 44, 13, -4, -36 },
  { 678, 16, 17, 20, 6, -39 },
  { 712, 20, 24, 23, 2, -30 },
  { 772, 7, 12, 9, -2, -5 },
  { 783, 12, 2, 14, 1, -15 },
  { 786, 3, 4, 9, 1, -4 },
  { 788, 21, 36, 16, -2, -36 },
  { 883, 19, 38, 21, 2, -37 },
  { 974, 11, 36, 21, 6, -36 },
  { 1024, 21, 37, 21, -1, -37 },
  { 1122, 21, 38, 21, 0, -37 },
  { 1222, 22, 37, 21, -1, -37 },
  { 1324, 21, 37, 21, 0, -36 },
  { 1422, 20, 38, 21, 2, -37 },
  { 1517, 20, 36, 21, 3, -36 },
  { 1607, 21, 38, 21, 0, -37 },
  { 1707, 19, 38, 21, 1, -37 },
  { 1798, 8, 27, 9, 1, -27 },
  { 1825, 11, 34, 9, -2, -27 },
  { 1872, 20, 22, 23, 2, -29 },
  { 1927, 20, 12, 23, 2, -24 },
  { 1957, 20, 22, 23, 2, -29 },
  { 2012, 15, 37, 15, 2, -37 },
  { 2082, 29, 41, 32, 2, -36 },
  { 2231, 20, 37, 21, -3, -37 },
  { 2324, 22, 36, 23, 1, -36 },
  { 2423, 22, 38, 21, 3, -37 },
  { 2528, 23, 36, 25, 1, -36 },
  { 2632, 21, 36, 20, 1, -36 },
  { 2727, 21, 36, 19, 1, -36 },
  { 2822, 24, 38, 27, 3, -37 },
  { 2936, 26, 36, 26, 1, -36 },
  { 3053, 16, 36, 11, -2, -36 },
  { 3125, 19, 45, 9, -8, -36 },
  { 3232, 24, 36, 21, 1, -36 },
  { 3340, 14, 36, 19, 1, -36 },
  { 3403, 33, 36, 34, 1, -36 },
  { 3552, 27, 36, 27, 1, -36 },
  { 3674, 24, 38, 27, 2, -37 },
  { 3788, 21, 36, 22, 1, -36 },
  { 3883, 24, 46, 27, 2, -37 },
  { 4021, 21, 36, 22, 1, -36 },
  { 4116, 22, 38, 20, -1, -37 },
  { 4221, 18, 36, 18, 4, -36 },
  { 4302, 25, 37, 26, 2, -36 },
  { 4418, 20, 36, 21, 5, -36 },
  { 4508, 33, 36, 34, 5, -36 },
  { 4657, 26, 36, 19, -3, -36 },
  { 4774, 19, 36, 18, 4, -36 },
  { 4860, 24, 36, 19, -2, -36 },
  { 4968, 19, 44, 14, -1, -36 },
  { 5073, 8, 36, 16, 5, -36 },
  { 5109, 18, 44, 14, -3, -36 },
  { 5208, 20, 19, 22, 2, -36 },
  { 5256, 15, 1, 15, -4, 5 },
  { 5258, 6, 8, 11, 7, -39 },
  { 5264, 19, 28, 22, 2, -27 },
  { 5331, 20, 40, 22, 1, -39 },
  { 5431, 16, 28, 17, 2, -27 },
  { 5487, 22, 40, 23, 2, -39 },
  { 5597, 16, 28, 20, 2, -27 },
  { 5653, 25, 51, 11, -7, -39 },
  { 5813, 22, 39, 23, 0, -27 },
  { 5921, 19, 39, 22, 1, -39 },
  { 6014, 10, 37, 9, 1, -37 },
  { 6061, 18, 49, 9, -7, -37 },
  { 6172, 19, 39, 18, 1, -39 },
  { 6265, 10, 39, 9, 1, -39 },
  { 6314, 30, 27, 33, 1, -27 },
  { 6416, 19, 27, 22, 1, -27 },
  { 6481, 18, 28, 22, 2, -27 },
  { 6544, 23, 39, 22, -2, -27 },
  { 6657, 20, 39, 23, 2, -27 },
  { 6755, 15, 27, 14, 1, -27 },
  { 6806, 17, 28, 17, 0, -27 },
  { 6866, 12, 35, 12, 1, -34 },
  { 6919, 19, 28, 22, 2, -27 },
  { 6986, 16, 27, 17, 3, -27 },
  { 7040, 26, 27, 27, 3, -27 },
  { 7128, 21, 27, 18, -2, -27 },
  { 7199, 26, 39, 17, -6, -27 },
  { 7326, 17, 27, 15, -1, -27 },
  { 7384, 18, 44, 16, 1, -36 },
  { 7483, 2, 51, 21, 10, -39 },
  { 7496, 18, 44, 16, -3, -36 },
  { 7595, 20, 4, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC51PT7B_H_
