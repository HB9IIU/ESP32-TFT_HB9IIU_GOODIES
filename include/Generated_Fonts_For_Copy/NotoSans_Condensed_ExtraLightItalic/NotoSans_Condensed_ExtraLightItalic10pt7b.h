#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x29, 0x96, 0xAF, 0x52, 0x80, 0x23, 0x66, 0x25,
  0x5E, 0x40, 0xD6, 0xBD, 0x56, 0xD6, 0xC0, 0x75, 0x24, 0xB9, 0xF0, 0xC0,
  0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x52, 0x80, 0x5D, 0x50, 0x22, 0xF2,
  0x20, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x75, 0x99, 0x99, 0xE0,
  0x75, 0x68, 0x71, 0x12, 0x24, 0xE0, 0x71, 0x16, 0x11, 0xE0, 0x13, 0x55,
  0xA7, 0x20, 0x74, 0x43, 0x11, 0xE0, 0x34, 0x69, 0x99, 0xE0, 0xE4, 0xA5,
  0x20, 0x75, 0x56, 0x99, 0xE0, 0x75, 0x97, 0x12, 0xE0, 0x40, 0x80, 0x40,
  0xA0, 0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0x64, 0xA4, 0x20,
  0x3D, 0x17, 0xEB, 0xD6, 0xE8, 0x1C, 0x11, 0x33, 0x55, 0x90, 0x75, 0x57,
  0x99, 0xE0, 0x3A, 0x11, 0x08, 0x41, 0x80, 0x72, 0x52, 0x98, 0xCB, 0x80,
  0x74, 0x47, 0x88, 0xE0, 0x74, 0x46, 0x88, 0x80, 0x3A, 0x11, 0x38, 0xC5,
  0xC0, 0x4A, 0x52, 0xF8, 0xCA, 0x40, 0x69, 0x29, 0x20, 0x11, 0x11, 0x22,
  0x22, 0xC0, 0x4A, 0x98, 0x8A, 0x52, 0x40, 0x49, 0x29, 0x38, 0x42, 0x89,
  0x33, 0x6B, 0x56, 0xA9, 0x00, 0x4B, 0x5A, 0xD9, 0x4A, 0x40, 0x3A, 0x53,
  0x18, 0xC5, 0xC0, 0x75, 0x57, 0x88, 0x80, 0x3A, 0x53, 0x18, 0xC5, 0x44,
  0x10, 0x75, 0x56, 0xAA, 0x90, 0x74, 0x42, 0x21, 0xE0, 0xE9, 0x49, 0x20,
  0x4A, 0x52, 0x98, 0xCB, 0xC0, 0x9A, 0xAA, 0xC8, 0x80, 0x96, 0x9A, 0x76,
  0x9A, 0x49, 0x00, 0x29, 0x44, 0x42, 0x2A, 0x40, 0xB7, 0x49, 0x20, 0x71,
  0x24, 0x48, 0xE0, 0x69, 0x29, 0x24, 0xC0, 0xFE, 0x31, 0x11, 0x22, 0x22,
  0xC0, 0x25, 0x59, 0xE0, 0x90, 0x79, 0x99, 0xE0, 0x44, 0x65, 0x59, 0x9E,
  0x78, 0x88, 0xE0, 0x08, 0x4A, 0xA9, 0x4A, 0x5C, 0x79, 0xE8, 0xE0, 0x12,
  0x32, 0x24, 0x44, 0x4C, 0x79, 0x99, 0xE2, 0xE0, 0x44, 0x65, 0x59, 0x9A,
  0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44, 0x56, 0x4A, 0xAA, 0x55, 0x6A,
  0x7D, 0x59, 0x69, 0xA4, 0x75, 0x99, 0xA0, 0x79, 0x99, 0xE0, 0x75, 0x99,
  0xE8, 0x80, 0x79, 0x99, 0xE2, 0x20, 0x6A, 0x48, 0xF1, 0x1E, 0x4D, 0x49,
  0x30, 0x55, 0x99, 0xE0, 0xBA, 0x48, 0xCE, 0xAD, 0x4A, 0x00, 0x74, 0x4A,
  0xA0, 0x4A, 0x8C, 0x42, 0x23, 0x00, 0x65, 0x4C, 0x32, 0x44, 0xC4, 0x48,
  0x40, 0xFF, 0xC0, 0x31, 0x12, 0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 5, 7, 6, 1, -7 },
  { 19, 4, 7, 4, 0, -7 },
  { 23, 1, 2, 2, 1, -7 },
  { 24, 3, 9, 2, 0, -7 },
  { 28, 3, 9, 2, -1, -7 },
  { 32, 3, 4, 4, 1, -8 },
  { 34, 4, 5, 5, 0, -6 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 2, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 0, -1 },
  { 40, 4, 7, 3, 0, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 2, 7, 4, 1, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 3, 7, 4, 1, -7 },
  { 73, 4, 7, 4, 0, -7 },
  { 77, 4, 7, 4, 0, -7 },
  { 81, 2, 5, 2, 0, -5 },
  { 83, 2, 6, 2, 0, -5 },
  { 85, 4, 5, 5, 0, -6 },
  { 88, 4, 3, 5, 0, -5 },
  { 90, 4, 5, 5, 0, -6 },
  { 93, 3, 7, 3, 0, -7 },
  { 96, 6, 8, 6, 0, -7 },
  { 102, 4, 7, 4, -1, -7 },
  { 106, 4, 7, 4, 0, -7 },
  { 110, 5, 7, 4, 0, -7 },
  { 115, 5, 7, 5, 0, -7 },
  { 120, 4, 7, 4, 0, -7 },
  { 124, 4, 7, 4, 0, -7 },
  { 128, 5, 7, 5, 0, -7 },
  { 133, 5, 7, 5, 0, -7 },
  { 138, 3, 7, 2, 0, -7 },
  { 141, 4, 9, 2, -2, -7 },
  { 146, 5, 7, 4, 0, -7 },
  { 151, 3, 7, 4, 0, -7 },
  { 154, 7, 7, 7, 0, -7 },
  { 161, 5, 7, 5, 0, -7 },
  { 166, 5, 7, 5, 0, -7 },
  { 171, 4, 7, 4, 0, -7 },
  { 175, 5, 9, 5, 0, -7 },
  { 181, 4, 7, 4, 0, -7 },
  { 185, 4, 7, 4, 0, -7 },
  { 189, 3, 7, 4, 1, -7 },
  { 192, 5, 7, 5, 0, -7 },
  { 197, 4, 7, 4, 1, -7 },
  { 201, 6, 7, 7, 1, -7 },
  { 207, 5, 7, 4, -1, -7 },
  { 212, 3, 7, 4, 1, -7 },
  { 215, 4, 7, 4, 0, -7 },
  { 219, 3, 9, 3, 0, -7 },
  { 223, 1, 7, 3, 1, -7 },
  { 224, 4, 9, 3, -1, -7 },
  { 229, 4, 4, 4, 0, -7 },
  { 231, 3, 1, 3, -1, 1 },
  { 232, 2, 2, 2, 1, -8 },
  { 233, 4, 5, 4, 0, -5 },
  { 236, 4, 8, 4, 0, -8 },
  { 240, 4, 5, 3, 0, -5 },
  { 243, 5, 8, 4, 0, -8 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 4, 10, 2, -1, -8 },
  { 256, 4, 7, 4, 0, -5 },
  { 260, 4, 8, 4, 0, -8 },
  { 264, 2, 7, 2, 0, -7 },
  { 266, 3, 9, 2, -1, -7 },
  { 270, 4, 8, 4, 0, -8 },
  { 274, 2, 8, 2, 0, -8 },
  { 276, 6, 5, 6, 0, -5 },
  { 280, 4, 5, 4, 0, -5 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 4, 7, 4, 0, -5 },
  { 290, 4, 7, 4, 0, -5 },
  { 294, 3, 5, 3, 0, -5 },
  { 296, 3, 5, 3, 0, -5 },
  { 298, 3, 7, 2, 0, -7 },
  { 301, 4, 5, 4, 0, -5 },
  { 304, 3, 5, 3, 1, -5 },
  { 306, 5, 5, 5, 1, -5 },
  { 310, 4, 5, 3, 0, -5 },
  { 313, 5, 7, 3, -1, -5 },
  { 318, 3, 5, 3, 0, -5 },
  { 320, 4, 9, 3, 0, -7 },
  { 325, 1, 10, 4, 2, -8 },
  { 327, 4, 9, 3, -1, -7 },
  { 332, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC10PT7B_H_
