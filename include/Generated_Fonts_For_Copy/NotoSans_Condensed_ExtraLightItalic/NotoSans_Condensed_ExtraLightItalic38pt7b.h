#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x04, 0x00, 0x00, 0x00, 0xC1, 0x83,
  0x00, 0x63, 0x63, 0x62, 0x42, 0x42, 0x46, 0xC6, 0x84, 0x84, 0x84, 0x00,
  0x61, 0x80, 0x10, 0x40, 0x04, 0x10, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x18, 0x60, 0x04, 0x10, 0x1F, 0xFF, 0xC0, 0x41, 0x00, 0x30, 0xC0,
  0x08, 0x20, 0x02, 0x08, 0x01, 0x86, 0x00, 0x41, 0x00, 0x10, 0x40, 0x0C,
  0x30, 0x3F, 0xFF, 0x80, 0x82, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x10,
  0x01, 0x04, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x70, 0x03, 0xFF, 0x06, 0x22,
  0x0C, 0x20, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x0C, 0x40,
  0x0C, 0x80, 0x06, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0x30,
  0x01, 0x10, 0x01, 0x18, 0x01, 0x08, 0x03, 0x08, 0x02, 0x18, 0x02, 0x10,
  0x02, 0x30, 0xC2, 0x60, 0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x08, 0x62, 0x02, 0x18, 0x40, 0xC2,
  0x08, 0x10, 0x41, 0x06, 0x18, 0x20, 0x82, 0x04, 0x20, 0x40, 0x84, 0x08,
  0x31, 0x03, 0x06, 0x60, 0x60, 0x88, 0x4C, 0x13, 0x3F, 0x86, 0x4C, 0x70,
  0x9B, 0x0E, 0x22, 0x41, 0x7C, 0x88, 0x22, 0x33, 0x04, 0x04, 0x40, 0x81,
  0x88, 0x10, 0x21, 0x06, 0x0C, 0x60, 0xC1, 0x0C, 0x10, 0x41, 0x82, 0x18,
  0x30, 0xC2, 0x06, 0x10, 0xC0, 0x44, 0x30, 0x0F, 0x80, 0x00, 0x20, 0x00,
  0xF8, 0x01, 0x0C, 0x03, 0x0C, 0x02, 0x04, 0x02, 0x0C, 0x06, 0x0C, 0x06,
  0x08, 0x06, 0x18, 0x02, 0x10, 0x02, 0x30, 0x02, 0x60, 0x03, 0xC0, 0x03,
  0x00, 0x07, 0x80, 0x0C, 0x80, 0x18, 0xC3, 0x30, 0xC2, 0x60, 0x42, 0x40,
  0x66, 0x40, 0x24, 0xC0, 0x3C, 0xC0, 0x38, 0xC0, 0x10, 0xC0, 0x38, 0x40,
  0x68, 0x60, 0xCC, 0x3F, 0x0C, 0x2D, 0xA4, 0xB4, 0x90, 0x00, 0x60, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x30, 0x02, 0x04, 0x20, 0xE2,
  0x01, 0xA7, 0x07, 0xC0, 0xE0, 0x1B, 0x03, 0x10, 0x61, 0x80, 0x08, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x21, 0x84, 0x30, 0x82,
  0x10, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x07, 0xE0, 0x30, 0x81, 0x83, 0x0C, 0x04, 0x20, 0x11, 0x80, 0x44, 0x01,
  0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x60, 0x0D, 0x80, 0x34, 0x00,
  0xD0, 0x02, 0x40, 0x09, 0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0, 0x33, 0x00,
  0xCC, 0x02, 0x30, 0x18, 0x40, 0x41, 0x02, 0x06, 0x18, 0x0F, 0x80, 0x07,
  0x0E, 0x1A, 0x76, 0xC6, 0x84, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0x00, 0x10, 0x01, 0xFC, 0x03, 0x06, 0x02, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x08, 0xFF, 0xF0, 0x00, 0x20,
  0x07, 0xF8, 0x38, 0x18, 0x20, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC2, 0x03,
  0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x14, 0x00, 0x78, 0x00, 0xB0, 0x03,
  0x40, 0x0C, 0x80, 0x11, 0x00, 0x46, 0x01, 0x88, 0x02, 0x10, 0x08, 0x20,
  0x30, 0xC0, 0x41, 0x81, 0x02, 0x06, 0x04, 0x18, 0x08, 0x20, 0x30, 0xC0,
  0x63, 0x00, 0x87, 0xFF, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x10, 0x70, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x81, 0xC0, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x0C, 0x02, 0x7E,
  0x0D, 0x06, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x08, 0x80, 0x11, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04, 0x20, 0x18, 0x40, 0x20, 0xC0,
  0xC0, 0xC3, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC,
  0x03, 0x06, 0x06, 0x02, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x02, 0x0C, 0x06, 0x04, 0x0C, 0x06, 0x18, 0x03, 0x30, 0x01, 0xC0,
  0x03, 0xC0, 0x0C, 0x60, 0x18, 0x30, 0x30, 0x18, 0x60, 0x18, 0x40, 0x08,
  0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x30,
  0x30, 0x60, 0x1F, 0xC0, 0x00, 0x20, 0x03, 0xF0, 0x0C, 0x30, 0x30, 0x30,
  0xC0, 0x61, 0x00, 0xC6, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x18, 0x80, 0x31, 0x00, 0x62, 0x01, 0xC6, 0x03, 0x0C, 0x1A, 0x0F, 0xEC,
  0x02, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x02, 0x0C, 0x07, 0xF0, 0x00, 0x0C, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x30,
  0x03, 0x81, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x04, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x01, 0xFC,
  0x10, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x81, 0x80, 0x18, 0x03, 0x00,
  0xC0, 0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x00, 0xC6, 0x01,
  0x03, 0x10, 0x3F, 0x0C, 0xC1, 0x84, 0x32, 0x0C, 0x30, 0xC8, 0x20, 0xC3,
  0x61, 0x82, 0x09, 0x04, 0x08, 0x24, 0x30, 0x60, 0x90, 0xC1, 0x86, 0x42,
  0x04, 0x13, 0x08, 0x10, 0x4C, 0x20, 0xC3, 0x30, 0x83, 0x08, 0xC2, 0x14,
  0x63, 0x0F, 0x9F, 0x0C, 0x1C, 0x30, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40,
  0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x06, 0x10, 0x08,
  0x20, 0x30, 0x40, 0x40, 0x81, 0x81, 0x03, 0xFF, 0x0F, 0xFE, 0x18, 0x0C,
  0x20, 0x18, 0xC0, 0x31, 0x00, 0x66, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x40,
  0x07, 0x80, 0x0E, 0x00, 0x08, 0x07, 0xF8, 0x04, 0x0E, 0x04, 0x02, 0x04,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x08, 0x02, 0x18,
  0x06, 0x18, 0x0C, 0x10, 0x18, 0x1F, 0xE0, 0x30, 0xF0, 0x30, 0x18, 0x30,
  0x08, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40,
  0x08, 0x40, 0x18, 0xC0, 0x10, 0xC0, 0x70, 0x81, 0xC0, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xC0, 0x60, 0x40, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x08, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x02, 0x0E, 0x01, 0x01, 0x80, 0x80, 0x60, 0xC0, 0x10, 0x60, 0x0C,
  0x20, 0x06, 0x10, 0x03, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00,
  0x31, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x04, 0x40, 0x06, 0x20, 0x03, 0x10,
  0x01, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x61,
  0x80, 0x60, 0xC0, 0xE0, 0x43, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xE0, 0x18, 0x0C, 0x1C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xF3, 0x00, 0xFC, 0xC0, 0x03, 0x20,
  0x00, 0xC8, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x43, 0x00, 0x10, 0x60, 0x04, 0x18, 0x03, 0x03, 0x81, 0xC0, 0x3F, 0xE0,
  0x06, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04,
  0x18, 0x01, 0x82, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x10,
  0x60, 0x06, 0x08, 0x00, 0xC1, 0xFF, 0xF0, 0x60, 0x02, 0x0C, 0x00, 0x41,
  0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0x41, 0x80, 0x08, 0x30, 0x03, 0x04,
  0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x0C, 0x10,
  0x01, 0x82, 0x00, 0x20, 0x00, 0x07, 0xF0, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x06, 0x01,
  0xC1, 0x00, 0x40, 0x40, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00,
  0x83, 0x00, 0x21, 0x80, 0x08, 0x40, 0x06, 0x30, 0x01, 0x98, 0x00, 0x4C,
  0x00, 0x17, 0x00, 0x0F, 0x40, 0x03, 0x98, 0x00, 0xC6, 0x00, 0x20, 0x80,
  0x08, 0x20, 0x06, 0x0C, 0x01, 0x81, 0x00, 0x40, 0x40, 0x10, 0x18, 0x04,
  0x06, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x20, 0x0C, 0x08, 0x01, 0x00, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x0F, 0xFC, 0x06, 0x00, 0x03,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x40, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xB0, 0x68, 0x00, 0xD0, 0x24, 0x00, 0x48, 0x12, 0x00, 0x64, 0x09, 0x00,
  0x26, 0x0C, 0x80, 0x33, 0x06, 0x40, 0x11, 0x02, 0x20, 0x18, 0x81, 0x10,
  0x08, 0xC1, 0x8C, 0x0C, 0x60, 0xC6, 0x04, 0x30, 0x43, 0x06, 0x10, 0x21,
  0x82, 0x08, 0x10, 0x43, 0x0C, 0x18, 0x21, 0x06, 0x0C, 0x11, 0x82, 0x04,
  0x08, 0x81, 0x02, 0x04, 0xC0, 0x81, 0x02, 0x40, 0xC1, 0x81, 0x60, 0x60,
  0xC0, 0xE0, 0x20, 0x40, 0x70, 0x10, 0x20, 0x30, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x60, 0x02, 0x07, 0x00, 0x20, 0x70, 0x06, 0x0D, 0x00, 0x60, 0xD0,
  0x06, 0x09, 0x80, 0x40, 0x98, 0x04, 0x08, 0x80, 0xC1, 0x88, 0x0C, 0x18,
  0xC0, 0x81, 0x0C, 0x08, 0x10, 0x40, 0x83, 0x04, 0x18, 0x30, 0x61, 0x82,
  0x06, 0x10, 0x20, 0x21, 0x02, 0x02, 0x10, 0x60, 0x33, 0x06, 0x03, 0x30,
  0x40, 0x12, 0x04, 0x01, 0x20, 0x40, 0x1E, 0x0C, 0x01, 0xE0, 0xC0, 0x0C,
  0x08, 0x00, 0xC0, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xC0,
  0xC0, 0xC0, 0x20, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x02, 0x60, 0x01, 0x30,
  0x00, 0x90, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x48, 0x00, 0x64, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0x40, 0x18, 0x30,
  0x18, 0x0C, 0x18, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x08, 0x38, 0x10, 0x18,
  0x20, 0x30, 0xC0, 0x21, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30,
  0x0C, 0x60, 0x18, 0x80, 0x61, 0x01, 0x86, 0x06, 0x0F, 0xF8, 0x1F, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x02,
  0x60, 0x01, 0x30, 0x00, 0x90, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18,
  0x40, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x07, 0xF0, 0x08, 0x38, 0x10, 0x18, 0x20, 0x30, 0xC0, 0x21, 0x80, 0x42,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x61, 0x01,
  0x86, 0x0E, 0x0F, 0xF0, 0x10, 0x40, 0x20, 0x80, 0x41, 0x81, 0x83, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x0C, 0x10, 0x18, 0x60, 0x10, 0xC0, 0x21, 0x00,
  0x62, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x7F, 0x80, 0xE0, 0x60, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x30, 0x18,
  0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x08, 0x60, 0x02,
  0x18, 0x00, 0x84, 0x00, 0x61, 0x00, 0x18, 0x40, 0x04, 0x30, 0x01, 0x0C,
  0x00, 0xC2, 0x00, 0x30, 0x80, 0x08, 0x60, 0x02, 0x18, 0x00, 0x84, 0x00,
  0x61, 0x00, 0x18, 0x40, 0x04, 0x30, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x30,
  0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x30, 0x18,
  0x38, 0x03, 0xF8, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x40, 0x04, 0x40, 0x0C,
  0x40, 0x0C, 0x40, 0x18, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20,
  0x40, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x40, 0x80, 0x41, 0x80, 0x41, 0x00,
  0x43, 0x00, 0x43, 0x00, 0x42, 0x00, 0x46, 0x00, 0x64, 0x00, 0x6C, 0x00,
  0x68, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0x78,
  0x06, 0x80, 0x58, 0x04, 0x80, 0x58, 0x0C, 0x80, 0xD8, 0x08, 0x80, 0x98,
  0x18, 0x81, 0x98, 0x10, 0x81, 0x18, 0x30, 0x81, 0x18, 0x30, 0x83, 0x18,
  0x20, 0x82, 0x18, 0x60, 0x86, 0x18, 0x40, 0x84, 0x18, 0xC0, 0x8C, 0x18,
  0x80, 0x88, 0x18, 0x80, 0x88, 0x19, 0x80, 0x98, 0x19, 0x00, 0x90, 0x1B,
  0x00, 0xB0, 0x1A, 0x00, 0xA0, 0x1A, 0x00, 0xA0, 0x1E, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x20, 0x18,
  0x04, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x01, 0x04, 0x00, 0x21, 0x80,
  0x04, 0x20, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0x20, 0x00,
  0x46, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC1, 0x00, 0x30, 0x20, 0x04,
  0x04, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x08, 0x01, 0x03, 0x00, 0x20, 0x00,
  0xC0, 0x0D, 0x00, 0x64, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x81, 0x86, 0x04,
  0x18, 0x30, 0x21, 0x80, 0x84, 0x02, 0x30, 0x08, 0x80, 0x36, 0x00, 0xD0,
  0x01, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x84, 0x31, 0x84, 0x21,
  0x08, 0x43, 0x18, 0x42, 0x10, 0x86, 0x30, 0x84, 0x21, 0x08, 0x63, 0x08,
  0x42, 0x03, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x05,
  0x80, 0x19, 0x00, 0x22, 0x00, 0xC6, 0x01, 0x04, 0x04, 0x0C, 0x18, 0x18,
  0x20, 0x10, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x58, 0x00, 0xC0, 0xFF, 0xE0,
  0x8C, 0x46, 0x21, 0x03, 0xF2, 0x0C, 0x2C, 0x30, 0x30, 0xC0, 0x61, 0x00,
  0xC6, 0x01, 0x88, 0x03, 0x30, 0x04, 0x60, 0x08, 0x80, 0x11, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x70, 0x81,
  0x41, 0x86, 0x81, 0xF1, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x09, 0xF8,
  0x36, 0x10, 0x70, 0x30, 0xE0, 0x21, 0x80, 0x43, 0x00, 0x8C, 0x01, 0x18,
  0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0x88, 0x03,
  0x10, 0x06, 0x60, 0x18, 0xE0, 0x31, 0x40, 0xC2, 0xC3, 0x0C, 0xFC, 0x00,
  0x03, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x70, 0x83, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x01, 0xF9, 0x01, 0x85, 0x81, 0x81, 0xC1, 0x80, 0xC0, 0x80, 0x60,
  0xC0, 0x30, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x10, 0x02, 0x08, 0x03,
  0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x70, 0x60,
  0x38, 0x10, 0x28, 0x0C, 0x34, 0x03, 0xE2, 0x00, 0x03, 0xF0, 0x30, 0x83,
  0x06, 0x30, 0x31, 0x01, 0x98, 0x08, 0x80, 0xCC, 0x0C, 0x41, 0xC3, 0xF8,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x10, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0x10, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF9, 0x03, 0x0D, 0x06,
  0x07, 0x0C, 0x06, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06, 0x30,
  0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x38, 0x60, 0x38, 0x20, 0x70, 0x30, 0xD0, 0x1F, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0xC3, 0x80, 0x7E, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x09, 0xF8,
  0x34, 0x10, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x0C, 0x02, 0x18,
  0x04, 0x20, 0x18, 0x40, 0x31, 0x80, 0x43, 0x00, 0x86, 0x01, 0x08, 0x06,
  0x10, 0x0C, 0x60, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x01, 0x8C, 0x03, 0x00,
  0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x01,
  0xE0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0C, 0x30, 0x20, 0x60,
  0xC0, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x0C, 0x40, 0x19, 0x00, 0x26, 0x00,
  0x5C, 0x01, 0xEC, 0x03, 0x98, 0x06, 0x10, 0x08, 0x20, 0x10, 0x60, 0x60,
  0xC0, 0xC0, 0x81, 0x01, 0x02, 0x03, 0x0C, 0x06, 0x00, 0x01, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0x04, 0xF8, 0xFC, 0x1A, 0x1B, 0x0C, 0x28, 0x1C, 0x08, 0x60,
  0x30, 0x10, 0xC0, 0x40, 0x21, 0x00, 0x80, 0xC6, 0x03, 0x01, 0x8C, 0x06,
  0x02, 0x10, 0x08, 0x04, 0x20, 0x10, 0x08, 0xC0, 0x60, 0x31, 0x80, 0xC0,
  0x63, 0x01, 0x00, 0x84, 0x02, 0x01, 0x08, 0x04, 0x02, 0x30, 0x18, 0x0C,
  0x60, 0x30, 0x18, 0x80, 0x40, 0x21, 0x00, 0x80, 0x46, 0x03, 0x01, 0x80,
  0x04, 0xFC, 0x1A, 0x08, 0x28, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x00, 0x86,
  0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20, 0x18, 0xC0, 0x21, 0x80, 0x42, 0x00,
  0x84, 0x03, 0x08, 0x06, 0x30, 0x08, 0x60, 0x10, 0x80, 0x21, 0x00, 0xC6,
  0x01, 0x80, 0x03, 0xF0, 0x18, 0x60, 0xC0, 0x86, 0x03, 0x10, 0x0C, 0xC0,
  0x32, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x00, 0x34, 0x00, 0xB0, 0x02, 0xC0,
  0x1B, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0x40, 0x21, 0x81, 0x06, 0x0C, 0x0F,
  0xC0, 0x02, 0x7E, 0x06, 0xC2, 0x05, 0x83, 0x07, 0x01, 0x06, 0x01, 0x06,
  0x01, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x02, 0x10, 0x06, 0x10, 0x06, 0x30, 0x0C, 0x38, 0x0C, 0x28,
  0x18, 0x2C, 0x30, 0x27, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0xF2, 0x0C, 0x24, 0x30, 0x38, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x88, 0x03,
  0x30, 0x06, 0x60, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0xCC, 0x01, 0x98,
  0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0x70, 0x81, 0xC1, 0x86, 0x81, 0xF9,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x04, 0xF0, 0xD0, 0x0A, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x07, 0xF1, 0x81, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x81, 0x8F, 0xE0, 0x04, 0x06, 0x02, 0x01, 0x00, 0x8B,
  0xF8, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x78, 0x00, 0x18,
  0x06, 0x30, 0x08, 0x40, 0x10, 0x80, 0x61, 0x00, 0xC6, 0x01, 0x0C, 0x02,
  0x10, 0x0C, 0x20, 0x18, 0x40, 0x31, 0x80, 0x43, 0x00, 0x84, 0x03, 0x08,
  0x06, 0x10, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x41, 0x85, 0x83, 0xF2,
  0x00, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0x8C,
  0x18, 0x41, 0x04, 0x30, 0x42, 0x04, 0x60, 0x44, 0x04, 0xC0, 0x48, 0x05,
  0x80, 0x50, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x3C, 0x06, 0x02,
  0xC0, 0xE0, 0x6C, 0x0A, 0x04, 0xC1, 0xA0, 0xCC, 0x12, 0x0C, 0xC1, 0x20,
  0x8C, 0x22, 0x18, 0xC2, 0x21, 0x0C, 0x62, 0x30, 0xC4, 0x22, 0x0C, 0xC2,
  0x20, 0xC8, 0x26, 0x0D, 0x82, 0x40, 0xD0, 0x2C, 0x0D, 0x02, 0x80, 0xF0,
  0x28, 0x0E, 0x03, 0x80, 0x60, 0x30, 0x04, 0x03, 0x00, 0x06, 0x03, 0x02,
  0x02, 0x02, 0x04, 0x02, 0x0C, 0x03, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x06,
  0x40, 0x0C, 0x60, 0x08, 0x20, 0x10, 0x20, 0x30, 0x30, 0x60, 0x30, 0xC0,
  0x10, 0x01, 0x00, 0x60, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10,
  0x18, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x01, 0x06, 0x00, 0x30,
  0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x6C,
  0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8,
  0x40, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x07, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x0F, 0x00, 0xE0, 0x00, 0x7C, 0x07, 0x1C, 0x38, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 8, 10, 11, 4, -27 },
  { 35, 18, 27, 17, 0, -27 },
  { 96, 16, 31, 16, 0, -29 },
  { 158, 19, 28, 23, 2, -28 },
  { 225, 16, 28, 17, 0, -28 },
  { 281, 3, 10, 6, 4, -27 },
  { 285, 11, 33, 9, 1, -27 },
  { 331, 11, 33, 9, -3, -27 },
  { 377, 12, 13, 15, 4, -29 },
  { 397, 14, 17, 17, 2, -22 },
  { 427, 6, 9, 7, -2, -4 },
  { 434, 8, 1, 11, 1, -11 },
  { 435, 2, 3, 7, 1, -3 },
  { 436, 16, 27, 12, -2, -27 },
  { 490, 14, 28, 16, 1, -28 },
  { 539, 8, 27, 16, 5, -27 },
  { 566, 16, 28, 16, -1, -28 },
  { 622, 15, 28, 16, 0, -28 },
  { 675, 15, 27, 16, 0, -27 },
  { 726, 16, 27, 16, 0, -27 },
  { 780, 15, 28, 16, 1, -28 },
  { 833, 15, 27, 16, 2, -27 },
  { 884, 16, 28, 16, 0, -28 },
  { 940, 15, 28, 16, 0, -28 },
  { 993, 6, 20, 7, 0, -20 },
  { 1008, 9, 25, 7, -2, -20 },
  { 1037, 14, 17, 17, 2, -22 },
  { 1067, 14, 9, 17, 2, -18 },
  { 1083, 14, 17, 17, 2, -22 },
  { 1113, 12, 28, 11, 1, -28 },
  { 1155, 22, 30, 23, 1, -27 },
  { 1238, 15, 27, 15, -2, -27 },
  { 1289, 16, 27, 17, 1, -27 },
  { 1343, 17, 28, 16, 2, -28 },
  { 1403, 17, 27, 19, 1, -27 },
  { 1461, 16, 27, 15, 1, -27 },
  { 1515, 16, 27, 14, 1, -27 },
  { 1569, 18, 28, 20, 2, -28 },
  { 1632, 19, 27, 20, 1, -27 },
  { 1697, 12, 27, 8, -1, -27 },
  { 1738, 14, 34, 7, -6, -27 },
  { 1798, 18, 27, 16, 1, -27 },
  { 1859, 10, 27, 14, 1, -27 },
  { 1893, 25, 27, 25, 1, -27 },
  { 1978, 20, 27, 20, 1, -27 },
  { 2046, 17, 28, 20, 2, -28 },
  { 2106, 15, 27, 16, 1, -27 },
  { 2157, 17, 35, 20, 2, -28 },
  { 2232, 15, 27, 16, 1, -27 },
  { 2283, 17, 28, 15, -1, -28 },
  { 2343, 14, 27, 14, 3, -27 },
  { 2391, 18, 27, 19, 2, -27 },
  { 2452, 16, 27, 16, 3, -27 },
  { 2506, 24, 27, 26, 4, -27 },
  { 2587, 19, 27, 14, -2, -27 },
  { 2652, 14, 27, 14, 3, -27 },
  { 2700, 17, 27, 14, -1, -27 },
  { 2758, 14, 33, 11, -1, -27 },
  { 2816, 5, 27, 12, 4, -27 },
  { 2833, 13, 33, 11, -2, -27 },
  { 2887, 15, 14, 17, 1, -27 },
  { 2914, 11, 1, 11, -3, 4 },
  { 2916, 4, 6, 8, 6, -29 },
  { 2919, 15, 20, 17, 1, -20 },
  { 2957, 15, 29, 17, 0, -29 },
  { 3012, 12, 20, 13, 1, -20 },
  { 3042, 17, 29, 17, 1, -29 },
  { 3104, 13, 20, 15, 1, -20 },
  { 3137, 18, 38, 8, -5, -29 },
  { 3223, 16, 29, 17, 0, -20 },
  { 3281, 15, 29, 16, 0, -29 },
  { 3336, 8, 27, 7, 0, -27 },
  { 3363, 13, 36, 7, -5, -27 },
  { 3422, 15, 29, 13, 0, -29 },
  { 3477, 8, 29, 7, 0, -29 },
  { 3506, 23, 20, 25, 0, -20 },
  { 3564, 15, 20, 16, 0, -20 },
  { 3602, 14, 20, 16, 1, -20 },
  { 3637, 16, 29, 17, -1, -20 },
  { 3695, 15, 29, 17, 1, -20 },
  { 3750, 12, 20, 11, 0, -20 },
  { 3780, 12, 20, 12, 0, -20 },
  { 3810, 9, 25, 9, 1, -25 },
  { 3839, 15, 20, 16, 1, -20 },
  { 3877, 12, 20, 12, 2, -20 },
  { 3907, 20, 20, 20, 2, -20 },
  { 3957, 16, 20, 13, -2, -20 },
  { 3997, 19, 29, 13, -4, -20 },
  { 4066, 13, 20, 11, -1, -20 },
  { 4099, 13, 33, 12, 1, -27 },
  { 4153, 2, 38, 15, 7, -29 },
  { 4163, 13, 33, 12, -2, -27 },
  { 4217, 14, 3, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC38PT7B_H_
