#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x18, 0x73, 0x06, 0x30, 0x63, 0x06, 0x30, 0x42, 0x0C, 0x60, 0xC6, 0x0C,
  0x60, 0x86, 0x08, 0x41, 0x84, 0x18, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06,
  0x02, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x18, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x40, 0x01,
  0x81, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0,
  0x1C, 0x21, 0x80, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60,
  0x40, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80,
  0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x08,
  0xC0, 0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC3, 0x82, 0x02, 0x1C, 0x0F, 0x09, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x60, 0xE3, 0x00,
  0x30, 0x30, 0xC0, 0x18, 0x18, 0x10, 0x06, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x10, 0x10, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x06, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x30,
  0x0C, 0x06, 0x18, 0x03, 0x01, 0x84, 0x18, 0xC0, 0x63, 0x1F, 0xB0, 0x31,
  0x8E, 0x3C, 0x0C, 0x66, 0x0F, 0x06, 0x31, 0x81, 0xC1, 0x8C, 0xC0, 0x58,
  0xC6, 0x30, 0x17, 0xE1, 0x08, 0x04, 0x60, 0xC6, 0x03, 0x00, 0x61, 0x80,
  0xC0, 0x18, 0x60, 0x30, 0x0C, 0x30, 0x0C, 0x03, 0x0C, 0x03, 0x01, 0x83,
  0x00, 0x80, 0x40, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x60, 0x60, 0x0C, 0x18,
  0x10, 0x03, 0x9C, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x03, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x00, 0x81, 0x80, 0x03, 0x0C,
  0x00, 0x0C, 0x70, 0x00, 0x33, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x30, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0xC6, 0x07, 0x06, 0x30, 0x0C, 0x18, 0xC0, 0x30, 0xC6, 0x00, 0x63,
  0x18, 0x01, 0x88, 0x60, 0x07, 0x63, 0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x83, 0x80, 0x1B, 0x06, 0x00, 0xEC, 0x1C, 0x07,
  0x30, 0x3C, 0x70, 0x60, 0x7F, 0x81, 0x80, 0x30, 0x00, 0x00, 0x19, 0x8C,
  0x63, 0x19, 0x8C, 0x63, 0x10, 0x8C, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x80, 0x80, 0xE0, 0x80, 0x70, 0x80, 0x1D, 0x83, 0x07,
  0xFF, 0x01, 0xC0, 0x02, 0x80, 0x0C, 0xC0, 0x18, 0x40, 0x30, 0x60, 0x60,
  0x60, 0x40, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18,
  0x60, 0xC3, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x03, 0x8E, 0x00, 0xE0,
  0x60, 0x38, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03,
  0x80, 0xC0, 0x30, 0x38, 0x03, 0x9E, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0xF0, 0x7C, 0x33, 0x39, 0x9C, 0x6C, 0x1A, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFE, 0x00, 0x78, 0x38, 0x07, 0x00, 0x60, 0x10, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x81, 0x00, 0x38, 0x0F, 0x07, 0x80, 0x7F, 0xF0, 0x00,
  0x28, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x40, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x06, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x20, 0x07, 0x01, 0xE1, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3C, 0x10, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x0F, 0x80, 0x33, 0xFE, 0x06, 0x70, 0x70, 0x6C, 0x03,
  0x07, 0x80, 0x38, 0x70, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0xE0, 0x60, 0x1C, 0x07, 0x03, 0x80, 0x38, 0xF0, 0x01, 0xFE, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x0F, 0x00, 0x30, 0x0E, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30,
  0x0C, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x80, 0x01,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x03, 0x8E, 0x00, 0x18, 0x1C,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x30, 0x01, 0xC1, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x30,
  0x0E, 0x01, 0xC0, 0x1E, 0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0xE1, 0xC0, 0x18, 0x0C, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xE1,
  0x80, 0x1E, 0x1C, 0x03, 0x40, 0xE0, 0xEC, 0x07, 0xF8, 0xC0, 0x1E, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xC3, 0xC0, 0x0F, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0xE0, 0xC0, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0xF0, 0x78, 0x70, 0x80, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x3C, 0x06, 0x30, 0x07, 0xF8, 0x31, 0x80, 0xE0, 0xC1, 0x88,
  0x06, 0x0C, 0x0C, 0xC0, 0x60, 0x60, 0x66, 0x06, 0x03, 0x03, 0x20, 0x30,
  0x10, 0x1B, 0x03, 0x01, 0x80, 0xD8, 0x18, 0x0C, 0x06, 0xC1, 0x80, 0x60,
  0x64, 0x0C, 0x02, 0x03, 0x60, 0x60, 0x30, 0x1B, 0x02, 0x01, 0x80, 0x98,
  0x30, 0x0C, 0x0C, 0xC1, 0x80, 0xE0, 0x66, 0x0C, 0x06, 0x06, 0x30, 0x60,
  0x70, 0x31, 0x83, 0x02, 0x83, 0x0C, 0x0C, 0x36, 0x30, 0x60, 0x77, 0x3F,
  0x83, 0x01, 0xF0, 0xF0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x01,
  0x90, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x60, 0x06,
  0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x1B,
  0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x07, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x0F, 0x80, 0x3F, 0xF8,
  0x00, 0xC1, 0xF8, 0x03, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x01, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x03,
  0xC1, 0xC0, 0x3C, 0x01, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x3F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01,
  0x80, 0x78, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0E, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60,
  0x01, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x3C, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xFF, 0x8C, 0x00,
  0x7F, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x07, 0x80, 0x08,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60,
  0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x0C, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x03,
  0x6C, 0x00, 0x01, 0x66, 0x00, 0x01, 0xE3, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xD8, 0x00, 0x03, 0x60, 0x36, 0x00, 0x00, 0xD8, 0x0D, 0x80,
  0x00, 0x6C, 0x03, 0x60, 0x00, 0x1B, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x62,
  0x00, 0x03, 0x30, 0x18, 0x80, 0x01, 0x8C, 0x06, 0x30, 0x00, 0xE6, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x63, 0x00, 0x1C, 0x60, 0x30, 0xC0, 0x06, 0x18,
  0x0C, 0x30, 0x03, 0x86, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x60,
  0xC0, 0x20, 0xC0, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x0C, 0x03,
  0x06, 0x01, 0x81, 0x01, 0x81, 0x80, 0x60, 0x40, 0x60, 0x60, 0x30, 0x18,
  0x30, 0x18, 0x0C, 0x06, 0x0C, 0x06, 0x03, 0x01, 0x86, 0x03, 0x00, 0xC0,
  0x61, 0x80, 0xC0, 0x30, 0x18, 0xC0, 0x30, 0x18, 0x06, 0x30, 0x0C, 0x06,
  0x01, 0x98, 0x03, 0x01, 0x80, 0x66, 0x01, 0x80, 0x60, 0x1B, 0x00, 0x60,
  0x10, 0x06, 0xC0, 0x18, 0x0C, 0x00, 0xE0, 0x06, 0x03, 0x00, 0x38, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0x0C, 0x07, 0x80, 0x01, 0x80, 0xF0, 0x00, 0x30, 0x1E, 0x00, 0x0C, 0x06,
  0xC0, 0x01, 0x80, 0xCC, 0x00, 0x30, 0x19, 0x80, 0x06, 0x03, 0x30, 0x00,
  0x80, 0x66, 0x00, 0x30, 0x18, 0x60, 0x06, 0x03, 0x0C, 0x00, 0xC0, 0x61,
  0x80, 0x18, 0x0C, 0x30, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x60, 0x18,
  0x0C, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0x30, 0x18, 0x18, 0x04, 0x03,
  0x03, 0x01, 0x80, 0x60, 0x60, 0x30, 0x0C, 0x0C, 0x06, 0x00, 0xC1, 0x80,
  0xC0, 0x18, 0x60, 0x30, 0x03, 0x0C, 0x06, 0x00, 0x61, 0x80, 0xC0, 0x06,
  0x30, 0x18, 0x00, 0xCC, 0x03, 0x00, 0x19, 0x80, 0xC0, 0x03, 0x30, 0x18,
  0x00, 0x36, 0x03, 0x00, 0x06, 0xC0, 0x60, 0x00, 0xF0, 0x0C, 0x00, 0x1E,
  0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x06, 0x01, 0x80, 0x07, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x07, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x81, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC1,
  0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0xE0, 0x18, 0x7E,
  0x01, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x07, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x07, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x0E, 0x03, 0x01, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x30,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xF0, 0x01, 0xE0, 0xF8, 0x07, 0x00, 0x20, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x78, 0x0F, 0x83, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0xC7, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x0E, 0x00,
  0x40, 0xC0, 0x04, 0x0C, 0x00, 0x41, 0x80, 0x04, 0x18, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x6C, 0x00,
  0x1C, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x0C, 0xC0, 0x03, 0xC0, 0x03, 0x30,
  0x00, 0xF0, 0x01, 0xCC, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x18,
  0xC0, 0x0C, 0xC0, 0x0C, 0x30, 0x03, 0x30, 0x03, 0x0C, 0x00, 0xCC, 0x01,
  0x83, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x18, 0xC0, 0x18, 0x30, 0x0C, 0x30,
  0x0C, 0x0C, 0x03, 0x0C, 0x03, 0x03, 0x00, 0x83, 0x01, 0x80, 0xC0, 0x60,
  0xC0, 0x60, 0x30, 0x18, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x03, 0x03,
  0x03, 0x03, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x30, 0x60, 0x30, 0x60, 0x0C,
  0x18, 0x0C, 0x30, 0x03, 0x0C, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0xC3, 0x00,
  0x31, 0x80, 0x31, 0x80, 0x0C, 0x60, 0x0C, 0x60, 0x03, 0x10, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x0D,
  0x80, 0x03, 0x60, 0x03, 0x60, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x07,
  0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x08, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x03, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xC0,
  0x40, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x68, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFE, 0xC6, 0x38, 0xC2, 0x18, 0x43, 0x00, 0x7C, 0x30, 0x1F,
  0xE3, 0x03, 0x83, 0x20, 0x70, 0x1A, 0x0E, 0x01, 0xE0, 0xC0, 0x0E, 0x18,
  0x00, 0xE1, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x07,
  0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xE0, 0x16, 0x06, 0x06,
  0x60, 0x79, 0xC4, 0x03, 0xF8, 0x40, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x1F, 0x00, 0x63, 0xFC, 0x06, 0x60, 0xE0, 0x6C,
  0x06, 0x05, 0x80, 0x70, 0xF0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x10, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x01, 0x87, 0x00, 0x18, 0x70, 0x03,
  0x85, 0x00, 0x30, 0xD0, 0x06, 0x0D, 0x80, 0xC0, 0xCE, 0x38, 0x08, 0x7F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x81, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x70, 0x1F, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x07, 0xC3, 0x00, 0x3F, 0xE6, 0x00, 0xE0, 0xCC, 0x03, 0x80, 0xD8,
  0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x07,
  0x01, 0x80, 0x1E, 0x03, 0x00, 0x3C, 0x06, 0x00, 0xD0, 0x0E, 0x03, 0x60,
  0x0C, 0x0E, 0xC0, 0x1E, 0x39, 0x80, 0x1F, 0xC2, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0x80, 0xE0, 0xC0, 0xE0, 0x30, 0xE0, 0x18, 0x60,
  0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x03, 0x18, 0x03, 0x98, 0x01, 0x8C,
  0x03, 0x86, 0x07, 0x87, 0xFF, 0x03, 0xFC, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x04, 0x0F, 0x1E, 0x03, 0xFE, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x20,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x23, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x04,
  0x01, 0xFF, 0x30, 0x0E, 0x0C, 0xC0, 0x70, 0x1B, 0x03, 0x80, 0x28, 0x0C,
  0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00,
  0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x38,
  0x0C, 0x01, 0xE0, 0x38, 0x0D, 0x80, 0x60, 0x76, 0x01, 0xE3, 0x98, 0x03,
  0xF8, 0x40, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x02, 0x00, 0xE0, 0x0F, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x61, 0xF0, 0x0C, 0xFF, 0x81, 0xB8, 0x38, 0x3C,
  0x03, 0x05, 0x00, 0x61, 0xE0, 0x0C, 0x38, 0x01, 0x87, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x40, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0x01, 0xC0,
  0x70, 0x18, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x38, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x70,
  0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00,
  0xC3, 0x00, 0x10, 0xE0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03,
  0x78, 0x00, 0xD9, 0x80, 0x1E, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x0C,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x60, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x06, 0x1F, 0x01, 0xF0, 0x0C, 0xFF, 0x0F, 0xF0, 0x1B, 0x07, 0x30,
  0x70, 0x3C, 0x06, 0xC0, 0x60, 0x50, 0x0F, 0x00, 0x61, 0xC0, 0x1C, 0x00,
  0xC3, 0x80, 0x38, 0x01, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x0C,
  0x18, 0x01, 0x80, 0x18, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x61,
  0x80, 0x18, 0x01, 0x83, 0x00, 0x30, 0x03, 0x0C, 0x00, 0x60, 0x06, 0x18,
  0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00, 0x18, 0x60, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0x01, 0x86, 0x00, 0x60, 0x03, 0x0C, 0x00,
  0xC0, 0x0C, 0x18, 0x01, 0x80, 0x18, 0x30, 0x03, 0x00, 0x30, 0xC0, 0x06,
  0x00, 0x61, 0x80, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x1F, 0x80, 0xCF, 0xF8, 0x1B, 0x83, 0x83, 0xC0, 0x30,
  0x50, 0x06, 0x1E, 0x00, 0xC3, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0x38, 0x38, 0x1C, 0x06, 0x0E, 0x00, 0xC3, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00,
  0x63, 0x00, 0x30, 0x60, 0x1C, 0x1C, 0x0E, 0x03, 0xCF, 0x00, 0x7F, 0x80,
  0x02, 0x00, 0x00, 0x00, 0xC3, 0xE0, 0x01, 0x8F, 0xF0, 0x03, 0x30, 0x70,
  0x06, 0xC0, 0x60, 0x0B, 0x00, 0xE0, 0x3C, 0x00, 0xC0, 0x78, 0x01, 0x80,
  0xE0, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x70, 0x00,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x30,
  0x1A, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x67, 0x1C, 0x00, 0xC7, 0xF0, 0x01,
  0x83, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C,
  0x10, 0x1F, 0xF3, 0x03, 0x83, 0x30, 0x70, 0x1B, 0x0E, 0x00, 0xA0, 0xC0,
  0x0E, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x0F, 0x0C, 0x01, 0xE0, 0xE0, 0x16,
  0x06, 0x07, 0x60, 0x78, 0xE6, 0x03, 0xF8, 0x40, 0x04, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x06, 0x1F, 0x06, 0x7E, 0x06, 0xE0, 0x06, 0x80, 0x05, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xC1, 0xC0, 0x41, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x40, 0x18, 0x38, 0x38, 0x1F, 0xF8, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x07, 0xF3, 0xFF,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x62, 0x07, 0xE0, 0x08, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x40, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x03, 0x86,
  0x00, 0xA0, 0xC0, 0x3C, 0x18, 0x0D, 0x81, 0xC7, 0x30, 0x1F, 0xC6, 0x00,
  0xC0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x01, 0x03, 0x00, 0x83, 0x00,
  0x41, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x03,
  0x60, 0x0F, 0x00, 0x6C, 0x01, 0xE0, 0x19, 0x80, 0x6C, 0x03, 0x30, 0x0D,
  0x80, 0xC6, 0x01, 0x30, 0x18, 0xC0, 0x66, 0x03, 0x18, 0x0C, 0xC0, 0xC3,
  0x03, 0x18, 0x18, 0x60, 0x63, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C,
  0x10, 0x30, 0x41, 0x86, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x06, 0x30, 0x18,
  0xC0, 0xC6, 0x03, 0x18, 0x18, 0x80, 0x66, 0x03, 0x30, 0x0C, 0xC0, 0x66,
  0x01, 0x90, 0x0D, 0x80, 0x36, 0x01, 0xB0, 0x06, 0xC0, 0x34, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x0E, 0x00, 0x40, 0x60, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3,
  0x00, 0x03, 0x30, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0,
  0x00, 0xE6, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x30,
  0x10, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x18, 0x00, 0xC1,
  0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x03,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xFC, 0x01, 0xE0, 0xF0, 0x3C, 0x03, 0xFE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 37, 11, 1, -37 },
  { 48, 12, 13, 15, 5, -37 },
  { 68, 23, 37, 23, 1, -37 },
  { 175, 22, 42, 21, 0, -39 },
  { 291, 26, 39, 32, 3, -38 },
  { 418, 22, 39, 23, 0, -38 },
  { 526, 5, 13, 8, 5, -37 },
  { 535, 15, 45, 13, 1, -37 },
  { 620, 15, 45, 13, -4, -37 },
  { 705, 16, 16, 20, 6, -39 },
  { 737, 20, 24, 24, 2, -30 },
  { 797, 7, 12, 9, -2, -5 },
  { 808, 12, 2, 14, 1, -15 },
  { 811, 3, 4, 9, 1, -4 },
  { 813, 22, 37, 16, -2, -37 },
  { 915, 19, 39, 21, 2, -38 },
  { 1008, 10, 37, 21, 7, -37 },
  { 1055, 22, 38, 21, -1, -38 },
  { 1160, 21, 39, 21, 0, -38 },
  { 1263, 22, 37, 21, -1, -37 },
  { 1365, 21, 38, 21, 0, -37 },
  { 1465, 20, 39, 21, 2, -38 },
  { 1563, 20, 37, 21, 3, -37 },
  { 1656, 22, 39, 21, 0, -38 },
  { 1764, 20, 39, 21, 1, -38 },
  { 1862, 8, 28, 9, 1, -28 },
  { 1890, 11, 35, 9, -2, -28 },
  { 1939, 20, 23, 24, 2, -30 },
  { 1997, 20, 13, 24, 2, -25 },
  { 2030, 20, 23, 24, 2, -30 },
  { 2088, 15, 38, 16, 2, -38 },
  { 2160, 29, 42, 32, 2, -37 },
  { 2313, 21, 37, 21, -3, -37 },
  { 2411, 22, 37, 23, 1, -37 },
  { 2513, 22, 39, 22, 3, -38 },
  { 2621, 24, 37, 26, 1, -37 },
  { 2732, 22, 37, 21, 1, -37 },
  { 2834, 22, 37, 19, 1, -37 },
  { 2936, 25, 39, 27, 3, -38 },
  { 3058, 26, 37, 27, 1, -37 },
  { 3179, 16, 37, 11, -2, -37 },
  { 3253, 19, 46, 10, -8, -37 },
  { 3363, 25, 37, 22, 1, -37 },
  { 3479, 14, 37, 19, 1, -37 },
  { 3544, 34, 37, 34, 1, -37 },
  { 3702, 27, 37, 28, 1, -37 },
  { 3827, 24, 39, 28, 2, -38 },
  { 3944, 21, 37, 22, 1, -37 },
  { 4042, 24, 47, 28, 2, -38 },
  { 4183, 21, 37, 22, 1, -37 },
  { 4281, 23, 39, 20, -1, -38 },
  { 4394, 19, 37, 19, 4, -37 },
  { 4482, 25, 38, 27, 2, -37 },
  { 4601, 20, 37, 21, 5, -37 },
  { 4694, 34, 37, 35, 5, -37 },
  { 4852, 26, 37, 19, -3, -37 },
  { 4973, 19, 37, 19, 4, -37 },
  { 5061, 24, 37, 20, -2, -37 },
  { 5172, 19, 45, 15, -1, -37 },
  { 5279, 8, 37, 17, 5, -37 },
  { 5316, 19, 45, 15, -3, -37 },
  { 5423, 20, 19, 23, 2, -37 },
  { 5471, 16, 2, 16, -4, 5 },
  { 5475, 5, 8, 11, 8, -40 },
  { 5480, 20, 29, 23, 2, -28 },
  { 5553, 20, 41, 23, 1, -40 },
  { 5656, 16, 29, 17, 2, -28 },
  { 5714, 23, 41, 23, 2, -40 },
  { 5832, 17, 29, 20, 2, -28 },
  { 5894, 25, 52, 11, -7, -40 },
  { 6057, 22, 40, 23, 0, -28 },
  { 6167, 19, 40, 22, 1, -40 },
  { 6262, 10, 37, 9, 1, -37 },
  { 6309, 18, 49, 9, -7, -37 },
  { 6420, 19, 40, 18, 1, -40 },
  { 6515, 10, 40, 9, 1, -40 },
  { 6565, 31, 28, 34, 1, -28 },
  { 6674, 19, 28, 22, 1, -28 },
  { 6741, 18, 29, 22, 2, -28 },
  { 6807, 23, 40, 23, -2, -28 },
  { 6922, 20, 40, 23, 2, -28 },
  { 7022, 16, 28, 15, 1, -28 },
  { 7078, 17, 29, 17, 0, -28 },
  { 7140, 12, 35, 12, 1, -34 },
  { 7193, 19, 29, 22, 2, -28 },
  { 7262, 17, 28, 17, 3, -28 },
  { 7322, 27, 28, 28, 3, -28 },
  { 7417, 21, 28, 18, -2, -28 },
  { 7491, 26, 41, 18, -6, -28 },
  { 7625, 18, 28, 16, -1, -28 },
  { 7688, 18, 45, 17, 2, -37 },
  { 7790, 2, 53, 21, 10, -40 },
  { 7804, 18, 45, 17, -3, -37 },
  { 7906, 20, 5, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC52PT7B_H_
