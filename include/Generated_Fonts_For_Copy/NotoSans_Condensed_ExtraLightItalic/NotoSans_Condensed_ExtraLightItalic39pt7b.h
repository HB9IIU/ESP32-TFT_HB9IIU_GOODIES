#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x21, 0x21, 0x63, 0x63, 0x42, 0x42, 0x42,
  0xC6, 0x84, 0x84, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x04,
  0x00, 0xC1, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x06, 0x08, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x10, 0x40, 0x0C, 0x30, 0x02, 0x08, 0x00, 0x82, 0x00, 0x60,
  0x80, 0x10, 0x60, 0x04, 0x10, 0x03, 0x04, 0x4F, 0xFF, 0xE0, 0x20, 0x80,
  0x08, 0x20, 0x06, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00, 0x30, 0x40, 0x08,
  0x30, 0x02, 0x08, 0x01, 0x86, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x01, 0xFE, 0x03, 0x23, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x20,
  0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x0C, 0x40, 0x06, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xB0, 0x01, 0x18, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x30, 0xC2, 0x60,
  0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x80,
  0x61, 0x88, 0x04, 0x10, 0xC0, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x0C,
  0x30, 0x60, 0xC2, 0x04, 0x08, 0x60, 0x40, 0x84, 0x04, 0x08, 0x80, 0xC1,
  0x98, 0x0C, 0x11, 0x1E, 0xC1, 0x33, 0x3C, 0x32, 0x63, 0xC2, 0x64, 0x14,
  0x44, 0xC1, 0x78, 0x88, 0x10, 0x18, 0x81, 0x01, 0x18, 0x30, 0x31, 0x03,
  0x02, 0x10, 0x20, 0x61, 0x02, 0x04, 0x10, 0x60, 0xC1, 0x04, 0x18, 0x10,
  0x41, 0x01, 0x0C, 0x30, 0x19, 0x82, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0x8C,
  0x03, 0x04, 0x03, 0x04, 0x02, 0x04, 0x02, 0x04, 0x06, 0x0C, 0x02, 0x0C,
  0x02, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x60, 0x01, 0x80, 0x03, 0x80,
  0x06, 0x80, 0x08, 0xC0, 0x10, 0xC1, 0x30, 0x43, 0x60, 0x62, 0x40, 0x26,
  0x40, 0x34, 0xC0, 0x3C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0x40, 0x6C,
  0x60, 0xCC, 0x3F, 0x86, 0x25, 0xB4, 0x96, 0x90, 0x00, 0x60, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x18, 0x00, 0x02, 0x00, 0x40, 0x08, 0x43, 0x0C,
  0x40, 0x68, 0x43, 0xF8, 0x60, 0x12, 0x04, 0x41, 0x0C, 0x40, 0x80, 0x18,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x21,
  0x84, 0x30, 0x82, 0x10, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x18,
  0x18, 0x10, 0x20, 0x20, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x88, 0x03, 0x30,
  0x06, 0x60, 0x0C, 0x80, 0x11, 0x00, 0x26, 0x00, 0x4C, 0x00, 0x90, 0x03,
  0x20, 0x06, 0x40, 0x08, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x18,
  0x06, 0x30, 0x08, 0x60, 0x30, 0x40, 0x40, 0xC1, 0x81, 0x86, 0x01, 0xF8,
  0x00, 0x03, 0x07, 0x1E, 0x32, 0x62, 0xC6, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x00, 0xFC, 0x01, 0xC3, 0x00, 0x80, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0x0E, 0x04, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x80, 0xC0, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x1A, 0x00, 0x16, 0x00,
  0x26, 0x00, 0x64, 0x00, 0x44, 0x00, 0x84, 0x01, 0x8C, 0x03, 0x0C, 0x02,
  0x08, 0x06, 0x08, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x10, 0x30, 0x10, 0x20,
  0x10, 0x60, 0x30, 0xC0, 0x30, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1B, 0x80, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x80, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xC1, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x23, 0xE0, 0x2E, 0x30, 0x78, 0x18, 0x70, 0x08, 0x60,
  0x08, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x10, 0x40, 0x30, 0x40, 0x20, 0x60, 0x60, 0x30, 0xC0, 0x1F,
  0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x86, 0x06, 0x03,
  0x04, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x0C, 0x02,
  0x04, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x60,
  0x0C, 0x30, 0x30, 0x10, 0x20, 0x18, 0x60, 0x08, 0x40, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60,
  0x1F, 0xC0, 0x00, 0xF8, 0x03, 0x8C, 0x06, 0x06, 0x04, 0x02, 0x0C, 0x02,
  0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x06, 0x10, 0x06, 0x10, 0x0E, 0x18, 0x1E, 0x0C, 0x34, 0x07, 0xE4,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x83, 0x80, 0xFE, 0x00, 0x04, 0x1C,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x87, 0x0C, 0x00, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F, 0xC1,
  0x86, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE3, 0x80, 0x0C, 0x03,
  0x00, 0x60, 0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x42,
  0x00, 0x01, 0x18, 0x1F, 0x84, 0x40, 0xC6, 0x13, 0x06, 0x10, 0x48, 0x30,
  0x41, 0x20, 0x81, 0x05, 0x86, 0x0C, 0x14, 0x10, 0x20, 0xD0, 0x40, 0x83,
  0x43, 0x06, 0x09, 0x0C, 0x18, 0x2C, 0x20, 0x41, 0xB0, 0x83, 0x04, 0xC2,
  0x0C, 0x33, 0x0C, 0x51, 0x8C, 0x1F, 0x3C, 0x30, 0x30, 0x40, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x20, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xA0, 0x03, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0x46, 0x01,
  0x8C, 0x02, 0x18, 0x0C, 0x30, 0x10, 0x60, 0x60, 0xC0, 0x81, 0x83, 0x03,
  0x07, 0xFE, 0x1F, 0xFC, 0x30, 0x18, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x4C,
  0x00, 0x90, 0x01, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x07,
  0xF8, 0x07, 0xFE, 0x06, 0x03, 0x04, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x0C,
  0x01, 0x08, 0x01, 0x08, 0x03, 0x08, 0x03, 0x18, 0x06, 0x18, 0x0C, 0x10,
  0x38, 0x1F, 0xE0, 0x30, 0x38, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20,
  0x04, 0x60, 0x04, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0,
  0x18, 0xC0, 0x30, 0x81, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xE0, 0xC0,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0E, 0x08, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0x81, 0xC0, 0x80, 0x60, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x02, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x46, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x10, 0x01, 0x88, 0x00, 0xCC,
  0x00, 0x46, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0x80, 0x30, 0xC0, 0x30,
  0x60, 0x70, 0x21, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x3F, 0xF8, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x38, 0x1C, 0x0C, 0x00, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xE6, 0x00,
  0x08, 0xC0, 0x01, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00,
  0x21, 0x80, 0x04, 0x30, 0x01, 0x82, 0x00, 0x30, 0x60, 0x04, 0x06, 0x00,
  0x80, 0xE0, 0x30, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x30, 0x60, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x40,
  0x80, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x08,
  0x10, 0x00, 0x81, 0xFF, 0xF8, 0x30, 0x01, 0x83, 0x00, 0x10, 0x30, 0x01,
  0x02, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0x80,
  0x04, 0x08, 0x00, 0xC0, 0x03, 0xF8, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x01,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x03,
  0xF0, 0x07, 0x00, 0x00, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x08, 0x60,
  0x02, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x13, 0x00, 0x05, 0xC0, 0x03,
  0xD8, 0x00, 0xE6, 0x00, 0x30, 0x80, 0x08, 0x30, 0x02, 0x0C, 0x01, 0x81,
  0x00, 0x60, 0x40, 0x10, 0x18, 0x04, 0x06, 0x01, 0x00, 0x80, 0xC0, 0x30,
  0x30, 0x0C, 0x08, 0x01, 0x02, 0x00, 0x60, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x03, 0xFF, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xA0, 0x00, 0xF0, 0x50, 0x00, 0x50, 0x68, 0x00,
  0x68, 0x34, 0x00, 0x2C, 0x12, 0x00, 0x36, 0x09, 0x00, 0x12, 0x04, 0x80,
  0x19, 0x06, 0x60, 0x08, 0x83, 0x30, 0x0C, 0xC1, 0x18, 0x04, 0x60, 0x8C,
  0x06, 0x20, 0xC6, 0x02, 0x10, 0x61, 0x03, 0x08, 0x20, 0x81, 0x0C, 0x10,
  0x41, 0x86, 0x08, 0x20, 0x82, 0x0C, 0x10, 0xC1, 0x06, 0x08, 0x41, 0x82,
  0x04, 0x60, 0xC1, 0x03, 0x20, 0x60, 0x81, 0xB0, 0x20, 0xC0, 0xD0, 0x10,
  0x60, 0x78, 0x18, 0x20, 0x38, 0x0C, 0x10, 0x0C, 0x04, 0x00, 0x06, 0x00,
  0x10, 0x70, 0x03, 0x07, 0x00, 0x30, 0x50, 0x03, 0x05, 0x00, 0x20, 0xD8,
  0x02, 0x0D, 0x80, 0x60, 0x88, 0x06, 0x08, 0x80, 0x40, 0x8C, 0x04, 0x18,
  0xC0, 0x41, 0x84, 0x0C, 0x10, 0x40, 0xC1, 0x06, 0x08, 0x30, 0x60, 0x83,
  0x02, 0x08, 0x30, 0x21, 0x82, 0x03, 0x18, 0x20, 0x31, 0x06, 0x01, 0x10,
  0x60, 0x13, 0x04, 0x01, 0xB0, 0x40, 0x1B, 0x04, 0x00, 0xA0, 0xC0, 0x0A,
  0x0C, 0x00, 0xE0, 0x80, 0x0E, 0x08, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x61,
  0xC0, 0x70, 0x18, 0x10, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x31, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40,
  0x00, 0xD0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x30, 0x40, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x06, 0x06, 0x04, 0x02, 0x04, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x08, 0x03, 0x08, 0x03, 0x08, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10,
  0x0C, 0x10, 0x18, 0x30, 0x70, 0x3F, 0xE0, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x61, 0xC0,
  0x70, 0x18, 0x10, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x31, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00,
  0x30, 0x40, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0x7F, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x06, 0x06, 0x04, 0x02, 0x04, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x08, 0x02, 0x18, 0x06,
  0x18, 0x06, 0x10, 0x0C, 0x10, 0x18, 0x3F, 0xF0, 0x3F, 0x80, 0x30, 0xC0,
  0x20, 0xC0, 0x20, 0x40, 0x60, 0x40, 0x60, 0x60, 0x60, 0x60, 0x40, 0x60,
  0x40, 0x20, 0xC0, 0x20, 0xC0, 0x30, 0x80, 0x30, 0x80, 0x10, 0x00, 0xFF,
  0x00, 0xE1, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x38, 0x18, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x61, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x20, 0xC0,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00,
  0x10, 0x40, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00,
  0x41, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0, 0xC0, 0x10, 0x18, 0x06,
  0x01, 0xC1, 0x80, 0x1F, 0xE0, 0x00, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x34,
  0x00, 0x68, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x18, 0x80, 0x21, 0x00,
  0xC2, 0x01, 0x04, 0x06, 0x08, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40, 0x80,
  0xC3, 0x01, 0x84, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x00, 0x36,
  0x00, 0x68, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80,
  0x08, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x50, 0x07, 0x00, 0x68,
  0x02, 0x80, 0x24, 0x01, 0x40, 0x32, 0x01, 0xA0, 0x19, 0x00, 0x90, 0x08,
  0x80, 0xC8, 0x0C, 0x40, 0x44, 0x04, 0x20, 0x62, 0x06, 0x10, 0x21, 0x02,
  0x08, 0x10, 0x81, 0x04, 0x18, 0x41, 0x82, 0x08, 0x20, 0x81, 0x0C, 0x10,
  0xC0, 0x84, 0x08, 0x40, 0x42, 0x04, 0x60, 0x23, 0x02, 0x30, 0x11, 0x01,
  0x10, 0x09, 0x80, 0x98, 0x04, 0x80, 0x48, 0x02, 0xC0, 0x2C, 0x01, 0x40,
  0x14, 0x00, 0xA0, 0x0A, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x60, 0x20, 0x08, 0x04, 0x03, 0x00, 0xC0,
  0x40, 0x18, 0x18, 0x01, 0x06, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0xCC,
  0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x66, 0x00, 0x08, 0xC0,
  0x03, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x06, 0x06, 0x00, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x01, 0x01, 0x00, 0x20, 0x60, 0x06, 0x00, 0xC0, 0x05,
  0x00, 0x34, 0x01, 0x90, 0x04, 0x60, 0x31, 0x80, 0x86, 0x06, 0x08, 0x10,
  0x20, 0xC0, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x32, 0x00, 0xD8, 0x01, 0x40,
  0x07, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x83,
  0xFF, 0xC0, 0x00, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0xFE, 0x00, 0x82, 0x0C, 0x30, 0x41, 0x04, 0x10,
  0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x61, 0x82,
  0x08, 0x20, 0x83, 0x00, 0xFE, 0x02, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0x20, 0x03, 0x30, 0x02, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x08,
  0x08, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x06, 0xC0,
  0x03, 0xFF, 0xF0, 0x8C, 0x46, 0x23, 0x01, 0xE2, 0x0E, 0x64, 0x30, 0x28,
  0x40, 0x71, 0x80, 0xE6, 0x01, 0x8C, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0x00, 0x22, 0x00, 0x44, 0x01, 0x98, 0x03, 0x30, 0x04, 0x60, 0x18,
  0xC0, 0x30, 0x80, 0xE1, 0x03, 0xC3, 0x0D, 0x03, 0xF2, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x78, 0x04, 0xCE, 0x0D, 0x06, 0x0E, 0x02,
  0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02,
  0x10, 0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x0C,
  0x60, 0x08, 0x70, 0x18, 0x50, 0x30, 0x58, 0x60, 0xCF, 0xC0, 0x01, 0xF8,
  0x3C, 0x83, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x61, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x78, 0xC0, 0x73, 0xA0, 0x30, 0x28,
  0x08, 0x0A, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x10, 0x20, 0x04, 0x18,
  0x03, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x04, 0x05, 0x01, 0x83, 0xC0,
  0x61, 0xB0, 0x0F, 0xC8, 0x00, 0x01, 0xE0, 0x39, 0x83, 0x06, 0x10, 0x11,
  0x80, 0x98, 0x0C, 0x80, 0x64, 0x06, 0x60, 0x63, 0x0E, 0x1F, 0xC0, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0x81, 0xCE,
  0x81, 0x81, 0x40, 0x80, 0xA0, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x20,
  0x04, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x10, 0x14, 0x08, 0x1E,
  0x06, 0x1B, 0x01, 0xF9, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x08, 0x18, 0x07, 0xF8, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0xF0, 0x17, 0x30, 0x78, 0x30, 0xE0,
  0x21, 0x80, 0x43, 0x00, 0x84, 0x03, 0x18, 0x06, 0x30, 0x08, 0x40, 0x10,
  0x80, 0x61, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x04, 0x20, 0x18, 0xC0,
  0x31, 0x80, 0x42, 0x00, 0x84, 0x01, 0x18, 0x06, 0x00, 0x03, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x0F,
  0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x0C, 0x10, 0x10, 0x60,
  0x40, 0xC1, 0x81, 0x06, 0x02, 0x18, 0x04, 0x60, 0x19, 0x80, 0x32, 0x00,
  0x4C, 0x00, 0xAC, 0x03, 0xD8, 0x07, 0x10, 0x0C, 0x20, 0x10, 0x60, 0x20,
  0xC0, 0xC0, 0x81, 0x81, 0x02, 0x03, 0x04, 0x06, 0x18, 0x04, 0x00, 0x01,
  0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0x04, 0x78, 0x3C, 0x05, 0x9C, 0xC6, 0x0F,
  0x05, 0x82, 0x0E, 0x05, 0x03, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x03, 0x08,
  0x04, 0x02, 0x18, 0x04, 0x02, 0x18, 0x0C, 0x06, 0x10, 0x0C, 0x06, 0x10,
  0x08, 0x06, 0x30, 0x08, 0x04, 0x30, 0x18, 0x04, 0x30, 0x18, 0x0C, 0x20,
  0x18, 0x0C, 0x20, 0x10, 0x08, 0x60, 0x10, 0x08, 0x60, 0x30, 0x08, 0x60,
  0x30, 0x18, 0x40, 0x20, 0x18, 0xC0, 0x20, 0x10, 0x04, 0x78, 0x0B, 0x98,
  0x3C, 0x18, 0x50, 0x10, 0xC0, 0x21, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18,
  0x04, 0x20, 0x08, 0x40, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x08, 0x02,
  0x10, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x03, 0x00,
  0x01, 0xF0, 0x1C, 0xE0, 0xC0, 0x82, 0x03, 0x18, 0x04, 0xC0, 0x13, 0x00,
  0x48, 0x01, 0x60, 0x05, 0x80, 0x14, 0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00,
  0x2C, 0x01, 0xB0, 0x04, 0xC0, 0x31, 0x00, 0x86, 0x06, 0x1C, 0x30, 0x3F,
  0x80, 0x02, 0x3C, 0x01, 0x33, 0x01, 0xA0, 0xC0, 0xE0, 0x20, 0x70, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00,
  0x41, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x20, 0x0C, 0x30,
  0x04, 0x1C, 0x06, 0x0A, 0x06, 0x05, 0x86, 0x02, 0x7E, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE3, 0x07, 0x3A, 0x0C, 0x0A, 0x08,
  0x0A, 0x18, 0x06, 0x30, 0x06, 0x30, 0x04, 0x20, 0x04, 0x60, 0x0C, 0x60,
  0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x30, 0xC0, 0x30, 0x40, 0x50, 0x40, 0xF0, 0x61, 0xB0, 0x3F, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x04, 0x78, 0x2E, 0x83, 0xC0, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x73, 0xC6, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x21, 0x03,
  0x0F, 0xF0, 0x00, 0x04, 0x02, 0x03, 0x01, 0x80, 0x81, 0xFD, 0xFE, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3C, 0x00, 0x08, 0x06, 0x30,
  0x0C, 0x60, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x01, 0x8C, 0x03, 0x18, 0x04,
  0x20, 0x08, 0x40, 0x10, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x08, 0x02, 0x10,
  0x0C, 0x20, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x02, 0x83, 0x09, 0x07, 0xE6,
  0x00, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x23, 0x03,
  0x18, 0x10, 0x41, 0x82, 0x08, 0x10, 0xC0, 0x84, 0x04, 0x60, 0x22, 0x01,
  0x30, 0x09, 0x00, 0x58, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x20, 0x1C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x0E, 0x02, 0xC0, 0xA0,
  0x6C, 0x0A, 0x04, 0xC1, 0x20, 0xCC, 0x12, 0x08, 0xC3, 0x20, 0x8C, 0x22,
  0x18, 0xC6, 0x21, 0x0C, 0x42, 0x30, 0xCC, 0x22, 0x0C, 0x82, 0x20, 0x48,
  0x26, 0x05, 0x82, 0x40, 0x50, 0x2C, 0x07, 0x02, 0x80, 0x60, 0x28, 0x06,
  0x03, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01, 0x83, 0x01, 0x80, 0x81, 0x80,
  0x40, 0x80, 0x30, 0xC0, 0x08, 0xC0, 0x04, 0x40, 0x03, 0x60, 0x01, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x34, 0x00, 0x12, 0x00, 0x19,
  0x80, 0x18, 0x40, 0x08, 0x20, 0x08, 0x18, 0x0C, 0x0C, 0x0C, 0x02, 0x0C,
  0x01, 0x00, 0x01, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x02, 0x03, 0x00, 0x40, 0x40, 0x08, 0x18, 0x01, 0x82, 0x00,
  0x30, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00,
  0x24, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0xF8, 0x03, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x78, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x38, 0x07, 0x80, 0x00, 0x10, 0x00, 0xFC,
  0x06, 0x0F, 0x34, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 28, 8, 1, -28 },
  { 29, 8, 10, 11, 4, -28 },
  { 39, 18, 28, 18, 0, -28 },
  { 102, 16, 32, 16, 0, -30 },
  { 166, 20, 28, 24, 2, -28 },
  { 236, 16, 28, 17, 0, -28 },
  { 292, 3, 10, 6, 4, -28 },
  { 296, 11, 34, 10, 1, -28 },
  { 343, 11, 34, 10, -3, -28 },
  { 390, 11, 13, 15, 5, -30 },
  { 408, 15, 18, 18, 2, -23 },
  { 442, 6, 9, 7, -2, -4 },
  { 449, 9, 1, 11, 1, -11 },
  { 451, 2, 3, 7, 1, -3 },
  { 452, 17, 28, 12, -2, -28 },
  { 512, 15, 28, 16, 1, -28 },
  { 565, 8, 28, 16, 5, -28 },
  { 593, 17, 28, 16, -1, -28 },
  { 653, 16, 28, 16, 0, -28 },
  { 709, 16, 28, 16, 0, -28 },
  { 765, 16, 28, 16, 0, -28 },
  { 821, 16, 28, 16, 1, -28 },
  { 877, 15, 28, 16, 2, -28 },
  { 930, 16, 28, 16, 0, -28 },
  { 986, 16, 28, 16, 0, -28 },
  { 1042, 7, 21, 7, 0, -21 },
  { 1061, 9, 26, 7, -2, -21 },
  { 1091, 15, 17, 18, 2, -22 },
  { 1123, 15, 10, 18, 2, -19 },
  { 1142, 15, 17, 18, 2, -22 },
  { 1174, 12, 28, 12, 1, -28 },
  { 1216, 22, 31, 24, 1, -28 },
  { 1302, 15, 28, 16, -2, -28 },
  { 1355, 16, 28, 18, 1, -28 },
  { 1411, 17, 28, 16, 2, -28 },
  { 1471, 17, 28, 19, 1, -28 },
  { 1531, 16, 28, 16, 1, -28 },
  { 1587, 16, 28, 14, 1, -28 },
  { 1643, 19, 28, 21, 2, -28 },
  { 1710, 20, 28, 20, 1, -28 },
  { 1780, 13, 28, 8, -2, -28 },
  { 1826, 14, 35, 7, -6, -28 },
  { 1888, 18, 28, 16, 1, -28 },
  { 1951, 10, 28, 14, 1, -28 },
  { 1986, 25, 28, 26, 1, -28 },
  { 2074, 20, 28, 21, 1, -28 },
  { 2144, 18, 28, 21, 2, -28 },
  { 2207, 16, 28, 16, 1, -28 },
  { 2263, 18, 35, 21, 2, -28 },
  { 2342, 16, 28, 17, 1, -28 },
  { 2398, 17, 28, 15, -1, -28 },
  { 2458, 14, 28, 14, 3, -28 },
  { 2507, 19, 28, 20, 2, -28 },
  { 2574, 15, 28, 16, 4, -28 },
  { 2627, 25, 28, 26, 4, -28 },
  { 2715, 19, 28, 14, -2, -28 },
  { 2782, 14, 28, 14, 3, -28 },
  { 2831, 18, 28, 15, -1, -28 },
  { 2894, 15, 34, 11, -1, -28 },
  { 2958, 6, 28, 13, 4, -28 },
  { 2979, 15, 34, 11, -3, -28 },
  { 3043, 16, 15, 17, 1, -28 },
  { 3073, 12, 1, 12, -3, 4 },
  { 3075, 4, 6, 9, 6, -30 },
  { 3078, 15, 21, 17, 1, -21 },
  { 3118, 16, 30, 17, 0, -30 },
  { 3178, 13, 21, 13, 1, -21 },
  { 3213, 18, 30, 17, 1, -30 },
  { 3281, 13, 21, 15, 1, -21 },
  { 3316, 18, 39, 9, -5, -30 },
  { 3404, 17, 30, 17, 0, -21 },
  { 3468, 15, 30, 17, 0, -30 },
  { 3525, 8, 28, 7, 0, -28 },
  { 3553, 13, 37, 7, -5, -28 },
  { 3614, 15, 30, 14, 0, -30 },
  { 3671, 8, 30, 7, 0, -30 },
  { 3701, 24, 21, 25, 0, -21 },
  { 3764, 15, 21, 17, 0, -21 },
  { 3804, 14, 21, 17, 1, -21 },
  { 3841, 17, 30, 17, -1, -21 },
  { 3905, 16, 30, 17, 1, -21 },
  { 3965, 13, 21, 11, 0, -21 },
  { 4000, 13, 21, 13, 0, -21 },
  { 4035, 9, 26, 9, 1, -26 },
  { 4065, 15, 21, 17, 1, -21 },
  { 4105, 13, 21, 13, 2, -21 },
  { 4140, 20, 21, 21, 2, -21 },
  { 4193, 17, 21, 14, -2, -21 },
  { 4238, 19, 30, 13, -4, -21 },
  { 4310, 14, 21, 12, -1, -21 },
  { 4347, 14, 34, 12, 1, -28 },
  { 4407, 2, 39, 16, 7, -30 },
  { 4417, 13, 34, 12, -2, -28 },
  { 4473, 15, 4, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC39PT7B_H_
