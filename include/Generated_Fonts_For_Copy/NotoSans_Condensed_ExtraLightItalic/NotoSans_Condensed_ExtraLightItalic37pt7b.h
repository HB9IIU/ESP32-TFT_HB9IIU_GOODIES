#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x80,
  0x63, 0x62, 0x42, 0x46, 0x46, 0xC4, 0x84, 0x84, 0x8C, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x30, 0x80, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x04, 0x10,
  0x3F, 0xFF, 0x1F, 0xFF, 0x81, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x61,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x18, 0x60, 0xFF, 0xFE, 0x7F, 0xFF, 0x06,
  0x18, 0x02, 0x08, 0x01, 0x04, 0x00, 0x86, 0x00, 0xC2, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x30, 0x80, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x0F,
  0xE0, 0x32, 0xE0, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x22, 0x00, 0x64, 0x00, 0x68, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0x60, 0x02, 0x60, 0x04, 0x40, 0x08, 0xC0, 0x21, 0x80, 0x42, 0x00, 0x84,
  0x01, 0x18, 0xC6, 0x60, 0xFF, 0x80, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x43, 0xB0, 0x10, 0x42, 0x06, 0x18, 0x40, 0x82,
  0x08, 0x20, 0xC1, 0x04, 0x10, 0x21, 0x02, 0x0C, 0x60, 0x41, 0x88, 0x18,
  0x23, 0x03, 0x04, 0x40, 0x40, 0x99, 0xE8, 0x22, 0x67, 0x04, 0x98, 0x71,
  0x32, 0x0B, 0x64, 0xC1, 0x31, 0x90, 0x20, 0x22, 0x0C, 0x0C, 0xC1, 0x81,
  0x18, 0x20, 0x42, 0x04, 0x18, 0x40, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10,
  0x21, 0x86, 0x06, 0x61, 0x80, 0x78, 0x00, 0x00, 0x60, 0x01, 0xF8, 0x03,
  0x08, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x08, 0x06, 0x08, 0x06, 0x18, 0x06,
  0x10, 0x06, 0x30, 0x02, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0D,
  0x80, 0x18, 0x83, 0x30, 0xC2, 0x20, 0xC6, 0x40, 0x44, 0x40, 0x6C, 0xC0,
  0x28, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0x40, 0x58, 0x61, 0x88, 0x3F,
  0x0C, 0x6D, 0x25, 0xA4, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x08, 0x06, 0x00, 0x03, 0x00, 0x20, 0x02, 0x0C, 0x20, 0x32,
  0x00, 0xDF, 0x06, 0x00, 0xA0, 0x33, 0x06, 0x10, 0x41, 0x80, 0x08, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x46, 0x23, 0x10, 0x88, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x60, 0x81,
  0x03, 0x0C, 0x0C, 0x20, 0x11, 0x80, 0x44, 0x01, 0x30, 0x0C, 0x80, 0x32,
  0x00, 0xD8, 0x03, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x06, 0x40, 0x1B,
  0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x04, 0x30, 0x30,
  0x40, 0x81, 0x8C, 0x03, 0xE0, 0x00, 0x06, 0x34, 0xDB, 0x28, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x80, 0x00, 0x78, 0x03, 0xFC, 0x02, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x0F, 0xF8, 0x30, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x0E, 0x00,
  0xF8, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x61, 0x03, 0x83,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xA0, 0x03, 0x40,
  0x04, 0x80, 0x13, 0x00, 0x64, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x60, 0x30,
  0xC0, 0x41, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x20, 0x30, 0xC0, 0x41,
  0x00, 0x87, 0xFF, 0xEF, 0xFF, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x5E, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x81, 0xC1, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x3F, 0x06, 0xC3, 0x0E, 0x02, 0x18, 0x04, 0x30, 0x0C,
  0x40, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x30,
  0x08, 0x20, 0x30, 0x40, 0x40, 0xC3, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x18,
  0x18, 0x20, 0x10, 0xC0, 0x21, 0x80, 0x42, 0x00, 0x84, 0x01, 0x0C, 0x06,
  0x08, 0x18, 0x18, 0x60, 0x11, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x98, 0x0C,
  0x10, 0x30, 0x30, 0xC0, 0x31, 0x00, 0x66, 0x00, 0x4C, 0x00, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x08, 0x60, 0x30, 0x60, 0xC0, 0x7F, 0x00, 0x00, 0xF0,
  0x07, 0xF0, 0x18, 0x30, 0x20, 0x20, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x88,
  0x03, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x21, 0x00, 0xC2, 0x01,
  0x86, 0x07, 0x07, 0x76, 0x07, 0x88, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x06, 0x03, 0xF8,
  0x00, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x0E, 0x30, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0x20, 0x00, 0x07, 0x83, 0xF8, 0x41, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x03,
  0x00, 0x40, 0x0C, 0x04, 0x00, 0x20, 0x40, 0x01, 0x86, 0x00, 0x04, 0x20,
  0x00, 0x22, 0x03, 0xE1, 0x10, 0x63, 0x09, 0x06, 0x18, 0x48, 0x20, 0x82,
  0xC3, 0x04, 0x14, 0x10, 0x61, 0xA1, 0x82, 0x0D, 0x08, 0x10, 0x48, 0x40,
  0x82, 0xC2, 0x0C, 0x36, 0x10, 0x61, 0x30, 0x86, 0x19, 0x84, 0x38, 0x8C,
  0x36, 0x48, 0x60, 0xE3, 0x83, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xC0, 0x05, 0x80,
  0x13, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x30,
  0x40, 0x40, 0x81, 0x81, 0x02, 0x02, 0x0F, 0xFC, 0x18, 0x08, 0x20, 0x10,
  0xC0, 0x21, 0x00, 0x46, 0x00, 0x88, 0x01, 0x30, 0x03, 0x40, 0x07, 0x80,
  0x0E, 0x00, 0x18, 0x07, 0xFC, 0x04, 0x0E, 0x04, 0x06, 0x0C, 0x02, 0x0C,
  0x03, 0x08, 0x03, 0x08, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10, 0x0C, 0x10,
  0x18, 0x1F, 0xF0, 0x3F, 0xE0, 0x30, 0x30, 0x20, 0x18, 0x20, 0x08, 0x20,
  0x08, 0x60, 0x0C, 0x60, 0x08, 0x40, 0x08, 0x40, 0x18, 0x40, 0x18, 0xC0,
  0x30, 0xC0, 0x60, 0x81, 0xC0, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0x03,
  0x01, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x20, 0x1F,
  0xE0, 0x07, 0xF8, 0x02, 0x06, 0x01, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x10,
  0x40, 0x08, 0x20, 0x04, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x20,
  0x02, 0x30, 0x03, 0x18, 0x01, 0x08, 0x01, 0x84, 0x01, 0x82, 0x00, 0x83,
  0x00, 0xC1, 0x81, 0xC0, 0x87, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0x83, 0xFF, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x07, 0xFE,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0xF0, 0x30, 0x08, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x07, 0xF2, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80, 0x04, 0x30, 0x01,
  0x0C, 0x00, 0xC1, 0x00, 0x30, 0x60, 0x08, 0x0E, 0x06, 0x01, 0xFF, 0x00,
  0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C,
  0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x20,
  0x40, 0x04, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x60, 0x06, 0x08, 0x00, 0x81,
  0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x04,
  0x00, 0x40, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10,
  0x01, 0x00, 0x07, 0xE0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x1F, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x3F, 0x00, 0x20, 0x00,
  0x06, 0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x41,
  0x80, 0x20, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x04, 0xC0, 0x02,
  0xE0, 0x03, 0x70, 0x01, 0xC8, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x20, 0x80,
  0x30, 0x40, 0x18, 0x30, 0x08, 0x08, 0x04, 0x04, 0x02, 0x03, 0x03, 0x01,
  0x81, 0x80, 0x40, 0x80, 0x30, 0x40, 0x18, 0x00, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x7F, 0xE0, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x0E, 0x0F, 0x00, 0x0A, 0x0B, 0x00, 0x1E, 0x0B, 0x00, 0x16, 0x0B,
  0x00, 0x34, 0x19, 0x00, 0x24, 0x19, 0x00, 0x64, 0x11, 0x00, 0x4C, 0x11,
  0x00, 0xCC, 0x11, 0x00, 0x88, 0x31, 0x01, 0x88, 0x31, 0x01, 0x08, 0x21,
  0x03, 0x18, 0x21, 0x82, 0x18, 0x21, 0x86, 0x10, 0x61, 0x84, 0x10, 0x61,
  0x8C, 0x30, 0x40, 0x88, 0x30, 0x40, 0x98, 0x30, 0x40, 0x90, 0x20, 0xC0,
  0xA0, 0x20, 0x80, 0xA0, 0x60, 0x80, 0xC0, 0x60, 0x80, 0xC0, 0x40, 0x06,
  0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x80, 0x20, 0xD0, 0x04, 0x12,
  0x01, 0x82, 0x40, 0x30, 0xCC, 0x04, 0x18, 0x80, 0x82, 0x10, 0x10, 0x43,
  0x06, 0x08, 0x60, 0xC3, 0x04, 0x10, 0x60, 0x82, 0x08, 0x18, 0x41, 0x03,
  0x18, 0x20, 0x23, 0x0C, 0x04, 0x41, 0x80, 0xC8, 0x20, 0x19, 0x04, 0x01,
  0x60, 0x80, 0x2C, 0x30, 0x07, 0x06, 0x00, 0xE0, 0x80, 0x0C, 0x10, 0x01,
  0x80, 0x00, 0x70, 0x00, 0xFF, 0x01, 0x80, 0x81, 0x80, 0x60, 0x80, 0x10,
  0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x20, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x68, 0x00, 0x34, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x06, 0x80,
  0x03, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x63,
  0x00, 0x21, 0x80, 0x30, 0x60, 0x30, 0x18, 0x30, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x08, 0x18, 0x10, 0x10, 0x60, 0x30, 0xC0, 0x61, 0x00, 0x42, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x08, 0x40, 0x30, 0x80, 0x43, 0x03, 0x06,
  0x3C, 0x0F, 0xE0, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0x01, 0x80, 0x81, 0x80, 0x60, 0x80, 0x10, 0xC0,
  0x0C, 0x40, 0x06, 0x60, 0x03, 0x20, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x68,
  0x00, 0x34, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x06, 0x80, 0x03,
  0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x63, 0x00,
  0x21, 0x80, 0x30, 0x60, 0x30, 0x18, 0x30, 0x07, 0xE0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x07,
  0xF8, 0x08, 0x18, 0x10, 0x10, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC2, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x20, 0x08, 0x40, 0x30, 0x80, 0xC3, 0x03, 0x07,
  0xF8, 0x08, 0x60, 0x10, 0x40, 0x20, 0x80, 0xC1, 0x81, 0x83, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x10, 0x80, 0x21, 0x00, 0x60,
  0x00, 0x3C, 0x01, 0xFF, 0x03, 0x01, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x40, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x84, 0x00, 0x46, 0x00, 0x63, 0x00, 0x31, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x08, 0x00,
  0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0xC0,
  0x0C, 0x60, 0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0x82,
  0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x1F, 0xC0, 0x00, 0xC0, 0x07, 0x80,
  0x0B, 0x00, 0x36, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x10,
  0x40, 0x20, 0x80, 0xC1, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x30, 0x10,
  0x40, 0x21, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04, 0xC0,
  0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x10,
  0x03, 0x80, 0x30, 0x06, 0x80, 0x30, 0x04, 0x80, 0x70, 0x04, 0x80, 0x50,
  0x0C, 0x80, 0x50, 0x08, 0x80, 0x90, 0x18, 0x80, 0x90, 0x10, 0x81, 0x90,
  0x10, 0x81, 0x10, 0x30, 0x83, 0x10, 0x20, 0x82, 0x10, 0x60, 0x82, 0x10,
  0x40, 0x86, 0x10, 0xC0, 0x84, 0x10, 0x80, 0x8C, 0x10, 0x80, 0x88, 0x11,
  0x80, 0x98, 0x11, 0x00, 0x90, 0x13, 0x00, 0x90, 0x12, 0x00, 0xB0, 0x12,
  0x00, 0xA0, 0x16, 0x00, 0xE0, 0x14, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x04,
  0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x08, 0x40, 0x02, 0x20, 0x00, 0x98,
  0x00, 0x34, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x04, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30,
  0xC0, 0x18, 0x10, 0x04, 0x04, 0x03, 0x01, 0x01, 0x80, 0x60, 0x40, 0x18,
  0x30, 0x06, 0x00, 0xC0, 0x1F, 0x00, 0x44, 0x03, 0x10, 0x08, 0x40, 0x61,
  0x81, 0x06, 0x0C, 0x18, 0x60, 0x21, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x80,
  0x34, 0x00, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x3F, 0x80, 0x84, 0x21, 0x84, 0x21, 0x08, 0x43, 0x18,
  0x42, 0x10, 0x84, 0x31, 0x84, 0x21, 0x08, 0x63, 0x08, 0x40, 0x03, 0xF8,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x62, 0x00,
  0x86, 0x03, 0x04, 0x04, 0x08, 0x10, 0x18, 0x60, 0x10, 0x80, 0x33, 0x00,
  0x64, 0x00, 0x58, 0x00, 0xC0, 0xFF, 0xFF, 0xFC, 0xC6, 0x22, 0x11, 0x01,
  0xE6, 0x0E, 0xE8, 0x30, 0x50, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x88, 0x02,
  0x30, 0x04, 0x60, 0x18, 0x80, 0x31, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x60, 0x81, 0x41, 0x84, 0x81, 0xF3,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x78, 0x1B, 0x38, 0x3C, 0x10, 0x50, 0x30,
  0xC0, 0x61, 0x80, 0x46, 0x00, 0x8C, 0x03, 0x10, 0x06, 0x20, 0x0C, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0xC4, 0x01, 0x88, 0x02, 0x30, 0x0C, 0x60, 0x10,
  0xA0, 0x61, 0x61, 0x86, 0x7E, 0x00, 0x01, 0xE0, 0x73, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x83, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x01, 0xC6, 0x03, 0x9B, 0x03, 0x05, 0x03,
  0x01, 0x81, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x08,
  0x20, 0x0C, 0x10, 0x06, 0x18, 0x02, 0x0C, 0x01, 0x06, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x20, 0x50, 0x18, 0x48, 0x07, 0xC4, 0x00,
  0x01, 0xE0, 0x73, 0x0C, 0x11, 0x81, 0x10, 0x13, 0x01, 0x20, 0x36, 0x06,
  0x40, 0xC4, 0xF8, 0x78, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x41, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x02, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0x03, 0x9B, 0x06, 0x0A,
  0x0C, 0x06, 0x08, 0x06, 0x18, 0x06, 0x10, 0x04, 0x30, 0x04, 0x30, 0x04,
  0x20, 0x0C, 0x20, 0x0C, 0x60, 0x08, 0x60, 0x08, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x38, 0x60, 0x30, 0x20, 0x50, 0x30, 0x90, 0x1F, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x81, 0x80,
  0xE7, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x78, 0x36, 0x70, 0xE0, 0x43,
  0x81, 0x0C, 0x04, 0x20, 0x11, 0x80, 0x46, 0x03, 0x10, 0x0C, 0x40, 0x23,
  0x00, 0x8C, 0x02, 0x20, 0x18, 0x80, 0x62, 0x01, 0x18, 0x04, 0x60, 0x31,
  0x00, 0xC4, 0x02, 0x30, 0x08, 0x02, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x00, 0x10, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x2E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x04, 0x30,
  0x20, 0xC1, 0x82, 0x0C, 0x08, 0x60, 0x23, 0x01, 0x88, 0x04, 0x40, 0x13,
  0x00, 0x5C, 0x03, 0xD0, 0x0E, 0x60, 0x31, 0x80, 0x82, 0x02, 0x08, 0x18,
  0x30, 0x60, 0xC1, 0x01, 0x04, 0x04, 0x30, 0x18, 0x03, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0,
  0x04, 0xF0, 0x78, 0x36, 0x67, 0x70, 0xA0, 0xF0, 0x43, 0x03, 0x81, 0x0C,
  0x0C, 0x04, 0x20, 0x30, 0x11, 0x80, 0xC0, 0x46, 0x02, 0x03, 0x10, 0x08,
  0x0C, 0x40, 0x60, 0x23, 0x01, 0x80, 0x8C, 0x04, 0x02, 0x20, 0x10, 0x18,
  0x80, 0x40, 0x62, 0x03, 0x01, 0x18, 0x0C, 0x04, 0x60, 0x20, 0x11, 0x00,
  0x80, 0xC4, 0x06, 0x03, 0x30, 0x18, 0x08, 0x04, 0xF8, 0x36, 0x70, 0xA0,
  0x43, 0x81, 0x0C, 0x04, 0x20, 0x11, 0x80, 0x46, 0x03, 0x10, 0x0C, 0x40,
  0x23, 0x00, 0x8C, 0x02, 0x20, 0x18, 0x80, 0x42, 0x01, 0x18, 0x04, 0x60,
  0x31, 0x00, 0xC4, 0x02, 0x30, 0x08, 0x01, 0xE0, 0x1C, 0xC0, 0xC1, 0x86,
  0x02, 0x10, 0x08, 0xC0, 0x22, 0x00, 0xD8, 0x02, 0x60, 0x09, 0x00, 0x24,
  0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x4C, 0x03, 0x30, 0x08, 0xC0, 0x61,
  0x01, 0x06, 0x18, 0x0F, 0xC0, 0x02, 0x3C, 0x06, 0xCE, 0x05, 0x82, 0x05,
  0x03, 0x06, 0x03, 0x06, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x08, 0x03, 0x08,
  0x03, 0x18, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x30,
  0x0C, 0x30, 0x08, 0x28, 0x18, 0x2C, 0x30, 0x27, 0xE0, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x01, 0xE2, 0x0E, 0xEC, 0x30, 0x50, 0xC0, 0x61, 0x00,
  0xC6, 0x01, 0x88, 0x03, 0x30, 0x04, 0x60, 0x08, 0x80, 0x31, 0x00, 0x62,
  0x00, 0x8C, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0x60, 0x81,
  0x41, 0x84, 0x81, 0xF3, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x70,
  0xDD, 0x0B, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x07, 0xC0, 0xC7, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x83, 0x0F, 0xE0, 0x04, 0x08,
  0x08, 0x08, 0x1F, 0x7F, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0x78, 0x18, 0x04,
  0x60, 0x31, 0x00, 0xC4, 0x02, 0x10, 0x08, 0xC0, 0x23, 0x01, 0x88, 0x06,
  0x20, 0x10, 0x80, 0x46, 0x01, 0x18, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x06,
  0x30, 0x18, 0xC0, 0xE3, 0x03, 0x84, 0x34, 0x1F, 0x90, 0x80, 0x38, 0x02,
  0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x08, 0xC0, 0x8C, 0x18, 0xC1, 0x0C, 0x30,
  0x42, 0x04, 0x60, 0x44, 0x04, 0xC0, 0x48, 0x05, 0x80, 0x50, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x0F, 0x03, 0x81, 0x60, 0x70,
  0x2C, 0x1E, 0x0D, 0x82, 0xC1, 0x30, 0x58, 0x66, 0x13, 0x08, 0xC2, 0x21,
  0x18, 0xC4, 0x63, 0x10, 0x88, 0x66, 0x13, 0x0C, 0x82, 0x41, 0xB0, 0x58,
  0x34, 0x0A, 0x06, 0x81, 0x40, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x10, 0x00, 0x04, 0x03, 0x06, 0x02, 0x02, 0x04, 0x02, 0x0C, 0x02,
  0x18, 0x03, 0x10, 0x01, 0x30, 0x01, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x0C, 0x40, 0x08, 0x60, 0x10,
  0x20, 0x30, 0x20, 0x20, 0x30, 0xC0, 0x30, 0x01, 0x00, 0x40, 0x40, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x30, 0x04,
  0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x98,
  0x00, 0x64, 0x00, 0x1B, 0x00, 0x06, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x02, 0x60, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0xFF, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x1C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xE0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x01, 0xE0, 0x18, 0x00, 0x38,
  0x07, 0xB8, 0x18, 0x3F, 0xA0, 0x18,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 9, 11, 4, -26 },
  { 33, 17, 26, 17, 0, -26 },
  { 89, 15, 30, 15, 0, -28 },
  { 146, 19, 27, 23, 2, -27 },
  { 211, 16, 27, 16, 0, -27 },
  { 265, 3, 9, 6, 4, -26 },
  { 269, 10, 32, 9, 1, -26 },
  { 309, 11, 32, 9, -3, -26 },
  { 353, 12, 12, 14, 4, -28 },
  { 371, 14, 17, 17, 2, -22 },
  { 401, 5, 9, 6, -2, -4 },
  { 407, 8, 2, 10, 1, -11 },
  { 409, 2, 3, 7, 1, -3 },
  { 410, 16, 26, 11, -2, -26 },
  { 462, 14, 27, 15, 1, -27 },
  { 510, 7, 26, 15, 5, -26 },
  { 533, 16, 27, 15, -1, -27 },
  { 587, 15, 27, 15, 0, -27 },
  { 638, 15, 27, 15, 0, -27 },
  { 689, 15, 26, 15, 0, -26 },
  { 738, 15, 27, 15, 1, -27 },
  { 789, 14, 26, 15, 2, -26 },
  { 835, 15, 27, 15, 0, -27 },
  { 886, 15, 27, 15, 0, -27 },
  { 937, 6, 20, 7, 0, -20 },
  { 952, 8, 25, 7, -2, -20 },
  { 977, 14, 16, 17, 2, -21 },
  { 1005, 14, 9, 17, 2, -18 },
  { 1021, 14, 16, 17, 2, -21 },
  { 1049, 11, 27, 11, 1, -27 },
  { 1087, 21, 29, 23, 1, -26 },
  { 1164, 15, 27, 15, -2, -27 },
  { 1215, 16, 26, 17, 1, -26 },
  { 1267, 16, 27, 16, 2, -27 },
  { 1321, 17, 26, 18, 1, -26 },
  { 1377, 15, 26, 15, 1, -26 },
  { 1426, 15, 26, 14, 1, -26 },
  { 1475, 18, 27, 20, 2, -27 },
  { 1536, 19, 26, 19, 1, -26 },
  { 1598, 11, 26, 8, -1, -26 },
  { 1634, 14, 33, 7, -6, -26 },
  { 1692, 17, 26, 15, 1, -26 },
  { 1748, 10, 26, 13, 1, -26 },
  { 1781, 24, 26, 25, 1, -26 },
  { 1859, 19, 26, 20, 1, -26 },
  { 1921, 17, 27, 20, 2, -27 },
  { 1979, 15, 26, 16, 1, -26 },
  { 2028, 17, 33, 20, 2, -27 },
  { 2099, 15, 26, 16, 1, -26 },
  { 2148, 16, 27, 15, -1, -27 },
  { 2202, 13, 26, 13, 3, -26 },
  { 2245, 17, 26, 19, 2, -26 },
  { 2301, 15, 26, 15, 3, -26 },
  { 2350, 24, 26, 25, 4, -26 },
  { 2428, 18, 26, 14, -2, -26 },
  { 2487, 14, 26, 13, 3, -26 },
  { 2533, 17, 26, 14, -1, -26 },
  { 2589, 14, 32, 10, -1, -26 },
  { 2645, 5, 26, 12, 4, -26 },
  { 2662, 13, 32, 10, -2, -26 },
  { 2714, 15, 14, 16, 1, -26 },
  { 2741, 11, 2, 11, -3, 3 },
  { 2744, 4, 6, 8, 5, -28 },
  { 2747, 15, 20, 16, 1, -20 },
  { 2785, 15, 28, 16, 0, -28 },
  { 2838, 12, 20, 12, 1, -20 },
  { 2868, 17, 28, 16, 1, -28 },
  { 2928, 12, 20, 14, 1, -20 },
  { 2958, 18, 37, 8, -5, -28 },
  { 3042, 16, 29, 16, 0, -20 },
  { 3100, 14, 28, 16, 0, -28 },
  { 3149, 8, 27, 7, 0, -27 },
  { 3176, 13, 36, 7, -5, -27 },
  { 3235, 14, 28, 13, 0, -28 },
  { 3284, 8, 28, 6, 0, -28 },
  { 3312, 22, 20, 24, 0, -20 },
  { 3367, 14, 20, 16, 0, -20 },
  { 3402, 14, 20, 16, 1, -20 },
  { 3437, 16, 29, 16, -1, -20 },
  { 3495, 15, 29, 16, 1, -20 },
  { 3550, 12, 20, 10, 0, -20 },
  { 3580, 12, 20, 12, 0, -20 },
  { 3610, 8, 24, 8, 1, -24 },
  { 3634, 14, 20, 16, 1, -20 },
  { 3669, 12, 20, 12, 2, -20 },
  { 3699, 19, 20, 20, 2, -20 },
  { 3747, 16, 20, 13, -2, -20 },
  { 3787, 18, 29, 13, -4, -20 },
  { 3853, 13, 20, 11, -1, -20 },
  { 3886, 13, 32, 12, 1, -26 },
  { 3938, 1, 37, 15, 7, -28 },
  { 3943, 13, 32, 12, -2, -26 },
  { 3995, 14, 4, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC37PT7B_H_
