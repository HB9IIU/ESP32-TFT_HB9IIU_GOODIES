#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x00, 0x7C, 0xF7, 0x9F, 0xF9, 0xFF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x3C, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xF1,
  0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78,
  0x03, 0x8F, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0,
  0x0E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00,
  0x71, 0xC0, 0x1E, 0x38, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x3F, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1E, 0xCC, 0x1F, 0x62,
  0x0F, 0xB0, 0x07, 0xD0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x27, 0x84,
  0x13, 0xC3, 0x0B, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x81, 0xE0, 0x7F, 0x03, 0x81, 0xFE, 0x0F, 0x03, 0x9C, 0x1C, 0x0F,
  0x3C, 0x78, 0x1C, 0x70, 0xE0, 0x38, 0xE3, 0xC0, 0xF1, 0xC7, 0x01, 0xE7,
  0x9E, 0x03, 0x8F, 0x78, 0x07, 0x1C, 0xE3, 0xEE, 0x7B, 0xCF, 0xDE, 0xE7,
  0x3F, 0xFF, 0xDE, 0xF3, 0xBF, 0x39, 0xC7, 0x38, 0xF3, 0x8E, 0x01, 0xCF,
  0x1C, 0x07, 0x9C, 0x78, 0x0E, 0x38, 0xF0, 0x3C, 0x71, 0xC0, 0xF0, 0xE3,
  0x81, 0xC3, 0xCF, 0x07, 0x83, 0x9C, 0x0E, 0x07, 0xF8, 0x3C, 0x0F, 0xE0,
  0x70, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E,
  0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC7,
  0xC7, 0xFC, 0xF9, 0xFF, 0x9E, 0x3D, 0xF7, 0xCF, 0x9F, 0xF3, 0xE3, 0xFE,
  0x7C, 0x3F, 0x8F, 0x87, 0xF1, 0xF0, 0xFC, 0x3E, 0x3F, 0x87, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFB, 0xE0, 0xFE, 0x7E, 0x00, 0x7D, 0xE7, 0xBE, 0xFB,
  0xCF, 0x3C, 0xF0, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F,
  0x04, 0x78, 0x19, 0xE0, 0x7F, 0x9B, 0xFF, 0xEF, 0xFF, 0xC7, 0xFF, 0x0F,
  0x80, 0x7F, 0x07, 0xDE, 0x1F, 0x78, 0x39, 0xF0, 0x43, 0x80, 0x08, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x1F,
  0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xF7, 0xFF,
  0xFE, 0x11, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE7, 0xC7, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3E, 0x78, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0x83, 0xFF,
  0x07, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xC3, 0xE7, 0x87,
  0xCF, 0x0F, 0x1E, 0x3E, 0x3C, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFC, 0xFF, 0xBF, 0xF7,
  0xBE, 0x67, 0xC8, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x38, 0x7C, 0x18, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x83, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x0C, 0x0F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xDE, 0x01, 0xFE, 0x03, 0xBC, 0x07, 0x3C, 0x07,
  0x3C, 0x0E, 0x7C, 0x1E, 0x7C, 0x1C, 0x78, 0x38, 0x78, 0x78, 0xF8, 0x70,
  0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0xEF,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x88, 0x0F, 0x86, 0x0F, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xE2, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9,
  0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0xF9, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F,
  0x07, 0x8F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7E, 0x7C, 0x3E, 0x3E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F,
  0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xBC, 0x06, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x87, 0xC7,
  0xE3, 0xF1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7E,
  0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3,
  0x8F, 0x90, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x83,
  0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x8F, 0x07, 0x87,
  0x1C, 0x3F, 0xCE, 0x78, 0xFF, 0x1C, 0xE3, 0xCE, 0x3B, 0xCF, 0x1C, 0x77,
  0x1C, 0x79, 0xEE, 0x38, 0xE3, 0x9C, 0xF1, 0xC7, 0x79, 0xC3, 0x8E, 0xE3,
  0x8F, 0x1D, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0xE7, 0x1C, 0xF3, 0x8E, 0x3F,
  0x7E, 0x1C, 0x7E, 0xFC, 0x38, 0x70, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xF0, 0x18, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x1F, 0x1E,
  0x0F, 0x0F, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1E, 0x7F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x0F, 0x87, 0xC3,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xE3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x3E, 0x1E, 0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x03, 0xF0, 0x41, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE1, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x87, 0xC7, 0xE0, 0xFB, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0x0C, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x3F, 0xC7, 0xC3, 0xF8, 0x7C, 0x7F, 0x8F, 0xC7, 0xF8,
  0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F,
  0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x05, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x78, 0x7C, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x0F, 0x83,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0xF7, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0x78,
  0xF7, 0x81, 0xEF, 0x1E, 0xF0, 0x3D, 0xE7, 0xBE, 0x0F, 0xBC, 0xF7, 0xC1,
  0xF7, 0xBC, 0xF8, 0x3C, 0xF7, 0x9E, 0x07, 0x9F, 0xE3, 0xC1, 0xF3, 0xFC,
  0xF8, 0x3E, 0x7F, 0x9F, 0x07, 0x8F, 0xE3, 0xC0, 0xF1, 0xFC, 0x78, 0x1E,
  0x3F, 0x0F, 0x07, 0xC7, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1E, 0x0F, 0x0F,
  0x00, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0x81, 0xF8, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F,
  0xF0, 0xF0, 0x7F, 0xC7, 0xC1, 0xE7, 0x9F, 0x07, 0x9E, 0x78, 0x1E, 0x79,
  0xE0, 0x79, 0xE7, 0x83, 0xE7, 0xBE, 0x0F, 0x9E, 0xF8, 0x3C, 0x3F, 0xC0,
  0xF0, 0xFF, 0x07, 0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFE, 0x07, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xC0, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F,
  0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F,
  0x3F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x7E,
  0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xF3,
  0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1,
  0xF8, 0x7C, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF1, 0xE0, 0x7C, 0x7C, 0x1E,
  0x1F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF0,
  0x40, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x10, 0x1F,
  0x07, 0x0F, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xEF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x9F, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x1E, 0x07, 0xFE, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3E,
  0xF8, 0x7E, 0x0F, 0x3E, 0x1F, 0x87, 0xCF, 0x87, 0xE1, 0xE3, 0xE3, 0xF8,
  0xF8, 0xF0, 0xFE, 0x3E, 0x3C, 0x7F, 0x8F, 0x0F, 0x1F, 0xE7, 0xC3, 0xC7,
  0x79, 0xE0, 0xF3, 0xDE, 0xF8, 0x3C, 0xF7, 0xBE, 0x0F, 0x79, 0xEF, 0x03,
  0xDE, 0x7F, 0xC0, 0xF7, 0x1F, 0xF0, 0x3F, 0xC7, 0x78, 0x0F, 0xF1, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E,
  0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF0, 0x7D,
  0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x9F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x11, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0xBC,
  0x0F, 0x3C, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F,
  0xF8, 0x0F, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFC, 0xF8, 0xF1, 0xF1, 0xE1,
  0xC0, 0x01, 0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7E, 0xF0, 0x7C, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x98, 0x0F,
  0x7E, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x0F, 0x1E,
  0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xF7,
  0xF0, 0xF3, 0xE0, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0xF8, 0x47, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x43, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x04, 0x3C, 0x07, 0xCF,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFD, 0xFC, 0x3E, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xE1,
  0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xE3, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xF7, 0x01, 0xFB, 0xC0, 0x00, 0x40, 0x1F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x3E, 0x3C, 0xF8, 0xF7, 0xC3, 0xDF, 0x0F, 0x78, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x13, 0xF1, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x9F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x7E, 0xF0, 0x3F, 0xBC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0xF0, 0x1F, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x80, 0xF8, 0x38, 0x7E, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x98,
  0x0F, 0x7E, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x9F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0x0F, 0x0F, 0x83, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0xF8, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x00, 0x18, 0x08, 0x0F, 0x7E, 0x7E, 0x0E, 0xFE, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1F, 0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x1E, 0x3C, 0x3E, 0x1E,
  0x3C, 0x3E, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x7C, 0x3C,
  0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x7C, 0xF8, 0x78, 0x7C, 0xF8, 0x78, 0x78,
  0xF8, 0xF8, 0x78, 0xF0, 0xF8, 0xF8, 0x00, 0x08, 0x0E, 0x7E, 0x0E, 0xFF,
  0x1E, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0xF8,
  0x00, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xDF,
  0x0F, 0xBE, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x87,
  0xDE, 0x0F, 0xBC, 0x1F, 0x78, 0x7C, 0xF9, 0xF9, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x03, 0xF8, 0x00, 0x00, 0x02, 0x00, 0xF7, 0xE0, 0x3B, 0xFC, 0x1E,
  0xFF, 0x07, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83,
  0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3C, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0x00, 0x07, 0xEF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3F, 0x7F, 0x3E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFE, 0xF0, 0x7C, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x08, 0x3D, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x80, 0x1F, 0xE1, 0xFF, 0xC7, 0xFE, 0x3F, 0x38, 0xF8, 0x43,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x83, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x00, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xFE, 0xFF, 0xDF, 0xF3,
  0xFE, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1E,
  0x1F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8,
  0x78, 0xF8, 0xF8, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFE,
  0xF0, 0x7C, 0xF0, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF, 0x8F,
  0x9F, 0x1E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE0, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x3F, 0xF1, 0xF8, 0x7B, 0xE3,
  0xF1, 0xF7, 0xC7, 0xE3, 0xCF, 0x9F, 0xCF, 0x9E, 0x3F, 0x9E, 0x3C, 0xFF,
  0x3C, 0x79, 0xFE, 0xF8, 0xF3, 0xBD, 0xE1, 0xEF, 0x7B, 0xC3, 0xDC, 0xEF,
  0x07, 0xB9, 0xDE, 0x0F, 0xF3, 0xBC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7,
  0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF0, 0xF0,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x3C,
  0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xF1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x00,
  0x7C, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x3E, 0x01, 0x7F, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 26, 9, 0, -26 },
  { 37, 12, 9, 15, 4, -26 },
  { 51, 19, 26, 18, 0, -26 },
  { 113, 17, 30, 16, 0, -28 },
  { 177, 23, 27, 26, 2, -27 },
  { 255, 19, 27, 19, 0, -27 },
  { 320, 6, 9, 9, 4, -26 },
  { 327, 12, 32, 10, 1, -26 },
  { 375, 13, 33, 10, -3, -27 },
  { 429, 14, 15, 15, 3, -28 },
  { 456, 15, 18, 17, 2, -22 },
  { 490, 8, 10, 9, -2, -5 },
  { 500, 10, 4, 11, 0, -12 },
  { 505, 6, 6, 9, 0, -6 },
  { 510, 19, 27, 14, -2, -27 },
  { 575, 15, 27, 16, 1, -27 },
  { 626, 11, 26, 16, 4, -26 },
  { 662, 17, 27, 16, -1, -27 },
  { 720, 18, 27, 16, -1, -27 },
  { 781, 16, 27, 16, 0, -27 },
  { 835, 17, 26, 16, 0, -26 },
  { 891, 16, 27, 16, 1, -27 },
  { 945, 17, 26, 16, 1, -26 },
  { 1001, 17, 27, 16, 0, -27 },
  { 1059, 16, 27, 16, 0, -27 },
  { 1113, 9, 20, 9, 0, -20 },
  { 1136, 11, 25, 9, -2, -20 },
  { 1171, 16, 18, 17, 1, -22 },
  { 1207, 16, 12, 17, 1, -19 },
  { 1231, 15, 18, 17, 2, -22 },
  { 1265, 13, 27, 12, 1, -27 },
  { 1309, 23, 30, 24, 1, -27 },
  { 1396, 17, 27, 17, -2, -27 },
  { 1454, 18, 26, 18, 0, -26 },
  { 1513, 18, 27, 16, 1, -27 },
  { 1574, 19, 26, 19, 0, -26 },
  { 1636, 17, 26, 15, 0, -26 },
  { 1692, 17, 26, 14, 0, -26 },
  { 1748, 20, 27, 19, 1, -27 },
  { 1816, 21, 26, 20, 0, -26 },
  { 1885, 16, 26, 12, -2, -26 },
  { 1937, 16, 34, 9, -6, -26 },
  { 2005, 20, 26, 17, 0, -26 },
  { 2070, 12, 26, 14, 0, -26 },
  { 2109, 27, 26, 26, 0, -26 },
  { 2197, 22, 26, 21, 0, -26 },
  { 2269, 19, 27, 20, 1, -27 },
  { 2334, 18, 26, 17, 0, -26 },
  { 2393, 19, 33, 20, 1, -27 },
  { 2472, 18, 26, 17, 0, -26 },
  { 2531, 18, 27, 15, -1, -27 },
  { 2592, 15, 26, 15, 3, -26 },
  { 2641, 19, 26, 19, 1, -26 },
  { 2703, 17, 26, 17, 3, -26 },
  { 2759, 26, 26, 26, 3, -26 },
  { 2844, 21, 26, 16, -2, -26 },
  { 2913, 16, 26, 16, 3, -26 },
  { 2965, 18, 26, 14, -1, -26 },
  { 3024, 14, 32, 10, -1, -26 },
  { 3080, 7, 27, 14, 4, -27 },
  { 3104, 15, 32, 10, -3, -26 },
  { 3164, 16, 15, 16, 0, -26 },
  { 3194, 13, 3, 12, -4, 3 },
  { 3199, 7, 6, 11, 5, -28 },
  { 3205, 16, 21, 17, 1, -21 },
  { 3247, 16, 28, 17, 0, -28 },
  { 3303, 14, 21, 14, 1, -21 },
  { 3340, 18, 28, 17, 1, -28 },
  { 3403, 14, 21, 16, 1, -21 },
  { 3440, 19, 37, 10, -4, -28 },
  { 3528, 18, 30, 17, -1, -21 },
  { 3596, 16, 28, 17, 0, -28 },
  { 3652, 10, 28, 8, 0, -28 },
  { 3687, 15, 37, 8, -5, -28 },
  { 3757, 18, 28, 16, 0, -28 },
  { 3820, 10, 28, 8, 0, -28 },
  { 3855, 24, 21, 25, 0, -21 },
  { 3918, 16, 21, 17, 0, -21 },
  { 3960, 15, 21, 17, 1, -21 },
  { 4000, 18, 30, 17, -2, -21 },
  { 4068, 16, 30, 17, 1, -21 },
  { 4128, 14, 21, 12, 0, -21 },
  { 4165, 14, 21, 13, 0, -21 },
  { 4202, 11, 24, 11, 1, -24 },
  { 4235, 16, 20, 17, 1, -20 },
  { 4275, 15, 20, 15, 2, -20 },
  { 4313, 23, 20, 23, 2, -20 },
  { 4371, 19, 20, 15, -2, -20 },
  { 4419, 20, 29, 15, -3, -20 },
  { 4492, 15, 20, 13, -1, -20 },
  { 4530, 15, 32, 13, 0, -26 },
  { 4590, 4, 36, 14, 5, -28 },
  { 4608, 14, 32, 13, -2, -26 },
  { 4664, 16, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC37PT7B_H_
