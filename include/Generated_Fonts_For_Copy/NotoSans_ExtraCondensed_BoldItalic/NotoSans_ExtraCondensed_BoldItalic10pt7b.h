#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0x30, 0xF4, 0x29, 0x9E, 0xAF, 0x32, 0x80, 0x11, 0xD4,
  0xC3, 0x1B, 0xC8, 0x40, 0xCB, 0x4D, 0x3F, 0x35, 0x59, 0x80, 0x32, 0x9C,
  0xDB, 0xDB, 0xE0, 0xE0, 0x29, 0x29, 0x24, 0xC0, 0x23, 0x32, 0x22, 0x64,
  0x80, 0x6D, 0x7A, 0x22, 0xF2, 0x20, 0x78, 0xE0, 0xB0, 0x0C, 0x61, 0x0C,
  0x21, 0x0C, 0x00, 0x35, 0x5D, 0x9A, 0xE0, 0x7F, 0xA4, 0xB0, 0x75, 0x12,
  0x6C, 0xE0, 0x71, 0x16, 0x33, 0xE0, 0x13, 0x57, 0xFF, 0x20, 0x74, 0x67,
  0x1B, 0xE0, 0x3B, 0x1D, 0xAD, 0x79, 0x80, 0x78, 0x84, 0x42, 0x23, 0x00,
  0x75, 0x56, 0xD9, 0xE0, 0x75, 0x57, 0x12, 0xE0, 0x50, 0xB0, 0x24, 0x02,
  0xB0, 0x13, 0xC3, 0x10, 0xF0, 0xF0, 0x83, 0x06, 0xC8, 0x00, 0x71, 0x24,
  0x40, 0xC0, 0x3D, 0x17, 0xEB, 0xB6, 0xA8, 0x1C, 0x18, 0xCA, 0x57, 0xA7,
  0x20, 0x7A, 0x56, 0xED, 0x6B, 0x80, 0x3B, 0x11, 0x8C, 0x61, 0xC0, 0x7A,
  0x52, 0x9D, 0xEB, 0x80, 0x74, 0x47, 0xCC, 0xE0, 0x74, 0x47, 0xCC, 0x80,
  0x3D, 0x84, 0x36, 0xDB, 0x67, 0x00, 0x6D, 0x24, 0x9E, 0xDB, 0x49, 0x00,
  0x72, 0x64, 0x44, 0xE0, 0x18, 0x84, 0x21, 0x18, 0x84, 0xE0, 0x6D, 0x47,
  0x18, 0x73, 0xC9, 0x00, 0x69, 0x2D, 0xB8, 0x66, 0xCD, 0xAB, 0x77, 0xD6,
  0xAD, 0x00, 0x65, 0xB6, 0x9E, 0x5A, 0x69, 0x80, 0x3B, 0x53, 0x9C, 0xED,
  0xC0, 0x7A, 0x52, 0xEC, 0x62, 0x00, 0x3B, 0x53, 0x9C, 0xED, 0xC6, 0x30,
  0x72, 0xD6, 0xE6, 0x7A, 0x40, 0x7A, 0x10, 0xC3, 0x5B, 0x80, 0xF4, 0x4C,
  0xC8, 0x80, 0x6D, 0x24, 0x96, 0xDB, 0x47, 0x00, 0x9C, 0xA9, 0x4E, 0x63,
  0x00, 0x97, 0x6A, 0xD6, 0xCD, 0x9B, 0x24, 0x00, 0x2C, 0xE3, 0x84, 0x31,
  0xCD, 0x80, 0xBA, 0xEC, 0xC8, 0x80, 0x78, 0x88, 0xC4, 0x43, 0x80, 0x74,
  0x44, 0xC8, 0x88, 0xC0, 0xAB, 0x54, 0x31, 0x12, 0x22, 0x26, 0xC0, 0x23,
  0x59, 0xE0, 0xD0, 0x23, 0xF5, 0xAF, 0x78, 0x26, 0x57, 0x5D, 0xDE, 0x27,
  0xCC, 0xCE, 0x08, 0x4E, 0xE5, 0x6A, 0x5E, 0x25, 0xDE, 0x86, 0x19, 0xC8,
  0xE2, 0x11, 0x88, 0x46, 0x00, 0x2B, 0x95, 0xAF, 0x78, 0x9C, 0x26, 0x57,
  0x5D, 0xDB, 0x2C, 0x25, 0xB4, 0x13, 0x02, 0x26, 0x64, 0x4C, 0x23, 0x12,
  0xA6, 0x72, 0x96, 0x2D, 0x25, 0xB4, 0x14, 0xFD, 0x56, 0xA9, 0x55, 0x80,
  0x17, 0x5D, 0x9B, 0x27, 0xDD, 0x96, 0x09, 0xCA, 0xD6, 0xB9, 0x18, 0x2B,
  0x95, 0xA9, 0x78, 0x84, 0x16, 0x4C, 0xC8, 0x27, 0x46, 0x2E, 0x2B, 0xA5,
  0xB0, 0x5A, 0xB5, 0x6F, 0x00, 0xBE, 0xCC, 0x80, 0xAF, 0xAF, 0x2C, 0xB0,
  0x56, 0x6E, 0xA0, 0x2C, 0xE3, 0x0C, 0x20, 0x8C, 0x00, 0x72, 0x4C, 0xE0,
  0x32, 0x26, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x31, 0x33, 0x32, 0x6E, 0x80,
  0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 4, 0, -8 },
  { 16, 6, 7, 7, 1, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 2, 2, 2, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 4, 9, 3, -1, -7 },
  { 37, 4, 4, 4, 1, -8 },
  { 39, 4, 5, 5, 0, -6 },
  { 42, 3, 2, 2, -1, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 2, 2, 2, 0, -2 },
  { 45, 6, 7, 4, -1, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 3, 7, 4, 1, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 5, 7, 4, 0, -7 },
  { 79, 5, 7, 4, 0, -7 },
  { 84, 4, 7, 4, 0, -7 },
  { 88, 4, 7, 4, 0, -7 },
  { 92, 2, 6, 2, 0, -6 },
  { 94, 3, 7, 2, -1, -6 },
  { 97, 4, 5, 5, 0, -6 },
  { 100, 4, 3, 5, 0, -5 },
  { 102, 5, 5, 5, 0, -6 },
  { 106, 4, 7, 3, 0, -7 },
  { 110, 6, 8, 6, 0, -7 },
  { 116, 5, 7, 5, -1, -7 },
  { 121, 5, 7, 5, 0, -7 },
  { 126, 5, 7, 4, 0, -7 },
  { 131, 5, 7, 5, 0, -7 },
  { 136, 4, 7, 4, 0, -7 },
  { 140, 4, 7, 4, 0, -7 },
  { 144, 6, 7, 5, 0, -7 },
  { 150, 6, 7, 5, 0, -7 },
  { 156, 4, 7, 3, 0, -7 },
  { 160, 5, 9, 2, -2, -7 },
  { 166, 6, 7, 5, 0, -7 },
  { 172, 3, 7, 4, 0, -7 },
  { 175, 7, 7, 7, 0, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 5, 7, 5, 0, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 5, 9, 5, 0, -7 },
  { 204, 5, 7, 5, 0, -7 },
  { 209, 5, 7, 4, 0, -7 },
  { 214, 4, 7, 4, 1, -7 },
  { 218, 6, 7, 5, 0, -7 },
  { 224, 5, 7, 5, 1, -7 },
  { 229, 7, 7, 7, 1, -7 },
  { 236, 6, 7, 4, -1, -7 },
  { 242, 4, 7, 4, 1, -7 },
  { 246, 5, 7, 4, 0, -7 },
  { 251, 4, 9, 3, 0, -7 },
  { 256, 2, 7, 4, 1, -7 },
  { 258, 4, 9, 3, -1, -7 },
  { 263, 4, 4, 4, 0, -7 },
  { 265, 3, 1, 3, -1, 1 },
  { 266, 2, 2, 3, 1, -8 },
  { 267, 5, 6, 5, 0, -6 },
  { 271, 4, 8, 5, 0, -8 },
  { 275, 4, 6, 4, 0, -6 },
  { 278, 5, 8, 5, 0, -8 },
  { 283, 4, 6, 4, 0, -6 },
  { 286, 5, 10, 3, -1, -8 },
  { 293, 5, 8, 5, 0, -6 },
  { 298, 4, 8, 5, 0, -8 },
  { 302, 3, 8, 2, 0, -8 },
  { 305, 4, 10, 2, -1, -8 },
  { 310, 5, 8, 4, 0, -8 },
  { 315, 3, 8, 2, 0, -8 },
  { 318, 7, 6, 7, 0, -6 },
  { 324, 4, 6, 5, 0, -6 },
  { 327, 4, 6, 4, 0, -6 },
  { 330, 5, 8, 5, -1, -6 },
  { 335, 5, 8, 5, 0, -6 },
  { 340, 4, 6, 3, 0, -6 },
  { 343, 4, 6, 4, 0, -6 },
  { 346, 3, 7, 3, 0, -7 },
  { 349, 5, 5, 5, 0, -5 },
  { 353, 4, 5, 4, 1, -5 },
  { 356, 6, 5, 6, 1, -5 },
  { 360, 4, 5, 4, 0, -5 },
  { 363, 6, 7, 4, -1, -5 },
  { 369, 4, 5, 3, 0, -5 },
  { 372, 4, 9, 3, 0, -7 },
  { 377, 1, 10, 4, 1, -8 },
  { 379, 4, 9, 3, -1, -7 },
  { 384, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC10PT7B_H_
