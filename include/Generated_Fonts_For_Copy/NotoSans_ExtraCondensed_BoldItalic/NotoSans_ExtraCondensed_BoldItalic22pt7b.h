#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x30, 0xC7, 0x00, 0x03, 0x8E,
  0x38, 0x77, 0x66, 0x66, 0xEE, 0xEE, 0xCC, 0x06, 0x60, 0xD8, 0x33, 0x06,
  0x60, 0xC8, 0x7F, 0xDF, 0xF8, 0xCC, 0x1B, 0x06, 0x63, 0xFF, 0x7F, 0xC6,
  0x60, 0xCC, 0x1B, 0x06, 0x60, 0x02, 0x00, 0x80, 0xF8, 0x7F, 0x3F, 0x8F,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x2E, 0x8B, 0x3B, 0xCF, 0xF1,
  0xF8, 0x10, 0x04, 0x00, 0x1C, 0x30, 0xF0, 0xC6, 0xC6, 0x1B, 0x38, 0xCC,
  0xC3, 0x36, 0x0C, 0xD9, 0xB6, 0xDF, 0xFB, 0x6D, 0xDB, 0x30, 0x6C, 0xC3,
  0x33, 0x0C, 0xD8, 0x63, 0x61, 0x8F, 0x0C, 0x3C, 0x07, 0x01, 0xF0, 0x77,
  0x0C, 0xC1, 0x98, 0x3F, 0x07, 0xC0, 0xF0, 0x3E, 0xEF, 0xDD, 0x9F, 0x73,
  0xEE, 0x79, 0xCF, 0x3F, 0xE3, 0xEE, 0x77, 0x66, 0xEE, 0x07, 0x0E, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x70, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0xE0, 0x1C,
  0x18, 0xD8, 0xFF, 0x7F, 0x38, 0x7C, 0xEE, 0x4C, 0x1C, 0x0E, 0x07, 0x03,
  0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3B, 0x9C, 0xCE, 0x60,
  0x7F, 0xF0, 0xFF, 0x80, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0x07, 0x03, 0xE1, 0xF8, 0xE6, 0x39, 0xCC, 0x67, 0x19, 0xCE,
  0x73, 0x98, 0xEE, 0x3B, 0x9C, 0xE7, 0x1B, 0x87, 0xE1, 0xF0, 0x06, 0x3C,
  0xFB, 0xEE, 0xCB, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38,
  0x07, 0x81, 0xF8, 0x7F, 0x84, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0x3F, 0xC7, 0xF8, 0x0F, 0x07,
  0xE1, 0xFC, 0x47, 0x01, 0xC0, 0xE0, 0x70, 0x78, 0x1F, 0x09, 0xC0, 0x70,
  0x1C, 0x07, 0x23, 0xCF, 0xE3, 0xF0, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x0F,
  0x82, 0xE1, 0xB0, 0xCC, 0x37, 0x19, 0xCF, 0xFB, 0xFE, 0xFF, 0x83, 0x80,
  0xE0, 0x38, 0x1F, 0xC7, 0xF1, 0xF8, 0x60, 0x38, 0x0E, 0x03, 0xE0, 0xFC,
  0x7F, 0x01, 0xE0, 0x30, 0x1C, 0x07, 0x33, 0xCF, 0xE3, 0xF0, 0x07, 0x87,
  0xC7, 0xE7, 0x07, 0x03, 0x83, 0xB9, 0xFE, 0xF7, 0x73, 0xB1, 0xD8, 0xEC,
  0xE7, 0x73, 0xF0, 0xF0, 0x3F, 0xDF, 0xE7, 0xF8, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0x0F, 0x07, 0xE3, 0x9C, 0xE7, 0x39, 0xCE, 0xE3, 0xF8, 0x78, 0x3E, 0x1D,
  0xCE, 0x33, 0x8E, 0xE3, 0x39, 0xCF, 0xE1, 0xF0, 0x0F, 0x07, 0xE3, 0xF8,
  0xE7, 0x31, 0xDC, 0x67, 0x39, 0xCE, 0x7F, 0x8F, 0xE0, 0x30, 0x1C, 0x07,
  0x27, 0x8F, 0xC3, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x39, 0xC0,
  0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x1C, 0x63, 0x8C, 0x00,
  0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x07,
  0xC0, 0xF8, 0x3C, 0x7C, 0xF8, 0xF0, 0x60, 0x00, 0x1E, 0x3F, 0x37, 0x03,
  0x03, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x30, 0x00, 0x00, 0x70, 0xF0, 0x60,
  0x01, 0xE0, 0x1F, 0xE0, 0xE1, 0xC6, 0x03, 0x19, 0xCC, 0xCF, 0xB3, 0x66,
  0xD9, 0x93, 0x6C, 0xCD, 0xB3, 0x24, 0xCD, 0x93, 0x76, 0xCF, 0xF1, 0x00,
  0x06, 0x00, 0x1C, 0x10, 0x3F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xF0, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0xFC, 0xFF, 0x71,
  0xDC, 0x7E, 0x1F, 0x87, 0x1F, 0x03, 0xF8, 0x7F, 0x8C, 0x73, 0x8E, 0x73,
  0x8E, 0xF1, 0xF8, 0x3F, 0x8E, 0x71, 0xC6, 0x39, 0xC6, 0x39, 0xCF, 0x3F,
  0xC7, 0xF0, 0x07, 0x87, 0xF3, 0xF8, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3D, 0x8F, 0xE1, 0xF8, 0x1F, 0x03,
  0xF8, 0x7F, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xC7, 0x30, 0xEE, 0x3D,
  0xC7, 0x38, 0xE7, 0x39, 0xFF, 0x3F, 0xC7, 0xE0, 0x1F, 0xC7, 0xF1, 0xF8,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xFC, 0x3F, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3F, 0x8F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF1, 0xF8, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xFC, 0x3F, 0x1F, 0xC7, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0x07, 0xC1, 0xFC, 0x7F, 0x1C, 0x27, 0x80, 0xE0, 0x3C, 0x07, 0x3E, 0xE7,
  0xDC, 0xFB, 0x8E, 0x71, 0xCE, 0x39, 0xE7, 0x1F, 0xE1, 0xF8, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x8E, 0x38, 0xE3, 0xFE, 0x3F, 0xE7,
  0x0C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0x1F, 0xC7,
  0xE0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x0F, 0xE3, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x1C, 0x1C, 0x3E, 0x1E, 0x0E, 0x00, 0x1C, 0x71, 0xCE, 0x1C, 0xE1, 0x9C,
  0x3B, 0x83, 0xB8, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x77, 0x07, 0x70,
  0x67, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E,
  0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x1F, 0xFF, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x36, 0x6C,
  0x36, 0x6C, 0x76, 0xDC, 0x76, 0xDC, 0x77, 0xDC, 0x67, 0x98, 0xE7, 0x98,
  0xE7, 0x38, 0xE7, 0x38, 0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x63, 0xE3,
  0x1F, 0x38, 0xD9, 0xC6, 0xEE, 0x37, 0x63, 0x9B, 0x1C, 0xF8, 0xC7, 0xC6,
  0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x38, 0x07, 0x83, 0xF8, 0xFF, 0x1C, 0x77,
  0x0E, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xEE, 0x39,
  0xEE, 0x3F, 0xC3, 0xE0, 0x1F, 0x83, 0xF8, 0x7F, 0x8C, 0x73, 0x8E, 0x71,
  0xCE, 0x39, 0xCE, 0x3F, 0x8F, 0xE1, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x1C, 0x77, 0x0E, 0xE1, 0xFC, 0x3F,
  0x07, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xEE, 0x39, 0xEF, 0x3F, 0xC3, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x1F, 0x07, 0xF1, 0xFC, 0x67, 0x39,
  0xCE, 0x73, 0x9C, 0xCE, 0x3F, 0x9F, 0x87, 0x71, 0xDC, 0x67, 0x39, 0xCE,
  0x3B, 0x8E, 0x0F, 0x87, 0xF3, 0xF8, 0xE2, 0x38, 0x0E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x70, 0x1C, 0x87, 0x3F, 0xCF, 0xE3, 0xF0, 0xFF, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x67, 0x1C, 0xE3, 0x9C, 0x73,
  0x8E, 0xE3, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x71, 0xDE, 0x3F, 0x83, 0xE0,
  0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x39, 0xCE, 0x63, 0xB8, 0xEE, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0x71, 0xC7, 0x71, 0xC7,
  0x71, 0xC6, 0x73, 0xCE, 0x63, 0xCE, 0x67, 0xCC, 0x67, 0xDC, 0x67, 0xDC,
  0x6F, 0xF8, 0x6D, 0xB8, 0x7D, 0xB0, 0x79, 0xF0, 0x79, 0xF0, 0x79, 0xE0,
  0x71, 0xE0, 0xF1, 0xC0, 0x1C, 0x70, 0xC7, 0x0C, 0xE0, 0xEC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB0, 0x3B, 0x87,
  0x38, 0x73, 0x8E, 0x38, 0xE3, 0xF1, 0xF9, 0xDC, 0xE6, 0xE3, 0x61, 0xF0,
  0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0xE3,
  0xFC, 0x7F, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0x87, 0xC3, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x3C, 0x3E, 0x1F, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0x8E,
  0x73, 0x9C, 0x63, 0x18, 0xE7, 0x0F, 0x87, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x3C, 0x1E, 0x1F, 0x00, 0x02, 0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x06, 0xE3,
  0x39, 0xC6, 0x61, 0xB8, 0x70, 0xFE, 0xE7, 0x73, 0x1E, 0xCF, 0xF3, 0xBD,
  0xC7, 0x71, 0x9C, 0xE6, 0x3B, 0x8E, 0xE7, 0xBD, 0xC7, 0xF1, 0xFC, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0F, 0xE3, 0xF8, 0xE7, 0x31, 0xDC, 0x77,
  0x1D, 0xC6, 0x73, 0x9C, 0xEF, 0x73, 0xFC, 0xDE, 0x00, 0x0F, 0x8F, 0x8E,
  0x4E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x39, 0x1F, 0x87, 0x80, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x3F, 0x8F, 0xF1, 0xDE, 0x71, 0xCE,
  0x31, 0xCE, 0x31, 0xCE, 0x39, 0xC6, 0x39, 0xC3, 0xF8, 0x7B, 0x00, 0x0F,
  0x0F, 0xCE, 0x6E, 0x37, 0x3B, 0xF9, 0xF1, 0xC0, 0xE0, 0x30, 0x9F, 0x87,
  0xC0, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x38, 0x03, 0x80, 0x7C, 0x0F, 0xC0,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0x63,
  0xFC, 0x77, 0x9C, 0x73, 0x8C, 0x73, 0x8C, 0x73, 0x8E, 0x73, 0xCF, 0x70,
  0xFE, 0x1F, 0xC0, 0x38, 0x06, 0x21, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0F, 0xE3, 0xF8, 0xEF, 0x39, 0x9C, 0x67, 0x39,
  0xCE, 0x73, 0x98, 0xCE, 0x33, 0x9C, 0xE7, 0x00, 0x0C, 0x71, 0xC0, 0x00,
  0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE0, 0x01, 0x81, 0xC0,
  0xE0, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x0F, 0x87, 0x80, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x73, 0xB8, 0xCE, 0x37, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x19, 0x8E, 0x73, 0x9C, 0xE7, 0x00, 0x1C, 0x71, 0xC7, 0x38,
  0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE0, 0x3F, 0xBC, 0xFF,
  0xF3, 0xBD, 0xCC, 0x67, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0xD8, 0xC6, 0x63,
  0x3B, 0x9C, 0xEE, 0x73, 0xB9, 0xCC, 0x37, 0x8D, 0xE3, 0x9C, 0xE6, 0x71,
  0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x38, 0xCE, 0x73, 0x9C, 0x0F, 0x1F, 0xCE,
  0xEE, 0x37, 0x1B, 0x8D, 0x8F, 0xC7, 0xE3, 0xBB, 0x9F, 0x87, 0x80, 0x1F,
  0xC3, 0x7C, 0x73, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x31, 0xCE, 0x39, 0xCF,
  0x71, 0xFE, 0x3F, 0x86, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1E,
  0xC7, 0xF3, 0xBD, 0xC7, 0x71, 0x9C, 0xE6, 0x3B, 0x8E, 0xE3, 0x3D, 0xC7,
  0xF1, 0xFC, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3F, 0x37, 0x3E,
  0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x1F, 0x3F, 0x72,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x0E, 0x9E, 0xFC, 0xF8, 0x18, 0x63, 0x1F,
  0xFD, 0xC7, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0xCF, 0x00, 0x39, 0xCE, 0x73,
  0x1C, 0xC6, 0x73, 0x9C, 0xE7, 0x39, 0x8C, 0x67, 0x39, 0xC7, 0xF1, 0xFC,
  0xE3, 0xF1, 0xB9, 0xDC, 0xCE, 0xE7, 0x61, 0xF0, 0xF8, 0x78, 0x3C, 0x1C,
  0x0E, 0x00, 0xE7, 0x1F, 0x9C, 0xEE, 0x73, 0xBB, 0xCC, 0xEF, 0x73, 0xFD,
  0x8F, 0xB6, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0x18,
  0xE3, 0xB8, 0x76, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3F, 0x06,
  0xE1, 0xDC, 0x71, 0x80, 0x1C, 0x71, 0xC6, 0x0C, 0xE0, 0xCC, 0x0D, 0xC0,
  0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x8F, 0xC8, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x38, 0x38, 0x3F, 0x9F, 0xC0, 0x01, 0x83, 0xC3, 0xE1,
  0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x38, 0x3C, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x18, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0E, 0x07, 0x0F, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0x20, 0xFE, 0x7F, 0xF1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 8, 6, 9, 2, -16 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 18, 9, 0, -17 },
  { 64, 14, 16, 15, 1, -16 },
  { 92, 11, 16, 11, 0, -16 },
  { 114, 4, 6, 5, 2, -16 },
  { 117, 8, 19, 6, 0, -16 },
  { 136, 8, 19, 6, -2, -16 },
  { 155, 8, 9, 9, 2, -17 },
  { 164, 9, 10, 10, 1, -13 },
  { 176, 5, 6, 5, -1, -3 },
  { 180, 6, 2, 6, 0, -7 },
  { 182, 3, 3, 5, 0, -3 },
  { 184, 11, 16, 8, -1, -16 },
  { 206, 10, 16, 9, 0, -16 },
  { 226, 7, 16, 10, 2, -16 },
  { 240, 11, 16, 9, -1, -16 },
  { 262, 10, 16, 9, 0, -16 },
  { 282, 10, 16, 10, 0, -16 },
  { 302, 10, 16, 9, 0, -16 },
  { 322, 9, 16, 9, 1, -16 },
  { 340, 10, 16, 9, 1, -16 },
  { 360, 10, 16, 9, 0, -16 },
  { 380, 10, 16, 9, 0, -16 },
  { 400, 5, 12, 5, 0, -12 },
  { 408, 6, 15, 5, -1, -12 },
  { 420, 9, 10, 10, 1, -13 },
  { 432, 9, 7, 10, 1, -11 },
  { 440, 9, 10, 10, 1, -13 },
  { 452, 8, 16, 7, 0, -16 },
  { 468, 14, 18, 14, 0, -16 },
  { 500, 10, 16, 10, -1, -16 },
  { 520, 11, 16, 10, 0, -16 },
  { 542, 10, 16, 10, 1, -16 },
  { 562, 11, 16, 11, 0, -16 },
  { 584, 10, 16, 9, 0, -16 },
  { 604, 10, 16, 8, 0, -16 },
  { 624, 11, 16, 12, 1, -16 },
  { 646, 12, 16, 12, 0, -16 },
  { 670, 10, 16, 7, -1, -16 },
  { 690, 9, 21, 5, -3, -16 },
  { 714, 12, 16, 10, 0, -16 },
  { 738, 7, 16, 8, 0, -16 },
  { 752, 16, 16, 15, 0, -16 },
  { 784, 13, 16, 12, 0, -16 },
  { 810, 11, 16, 12, 1, -16 },
  { 832, 11, 16, 10, 0, -16 },
  { 854, 11, 20, 12, 1, -16 },
  { 882, 10, 16, 10, 0, -16 },
  { 902, 10, 16, 9, 0, -16 },
  { 922, 8, 16, 9, 2, -16 },
  { 938, 11, 16, 11, 1, -16 },
  { 960, 10, 16, 10, 2, -16 },
  { 980, 16, 16, 15, 1, -16 },
  { 1012, 12, 16, 10, -1, -16 },
  { 1036, 9, 16, 9, 2, -16 },
  { 1054, 11, 16, 9, -1, -16 },
  { 1076, 9, 20, 6, -1, -16 },
  { 1099, 5, 16, 8, 2, -16 },
  { 1109, 9, 20, 6, -2, -16 },
  { 1132, 10, 10, 10, 0, -16 },
  { 1145, 7, 1, 7, -2, 2 },
  { 1146, 4, 4, 7, 3, -17 },
  { 1148, 10, 12, 10, 0, -12 },
  { 1163, 10, 17, 10, 0, -17 },
  { 1185, 9, 12, 8, 0, -12 },
  { 1199, 11, 17, 10, 0, -17 },
  { 1223, 9, 12, 9, 0, -12 },
  { 1237, 12, 22, 6, -3, -17 },
  { 1270, 11, 17, 10, -1, -12 },
  { 1294, 10, 17, 10, 0, -17 },
  { 1316, 6, 17, 5, 0, -17 },
  { 1329, 9, 22, 5, -3, -17 },
  { 1354, 10, 17, 9, 0, -17 },
  { 1376, 6, 17, 5, 0, -17 },
  { 1389, 14, 12, 15, 0, -12 },
  { 1410, 10, 12, 10, 0, -12 },
  { 1425, 9, 12, 10, 0, -12 },
  { 1439, 11, 17, 10, -1, -12 },
  { 1463, 10, 17, 10, 0, -12 },
  { 1485, 8, 12, 7, 0, -12 },
  { 1497, 8, 12, 8, 0, -12 },
  { 1509, 6, 15, 6, 1, -15 },
  { 1521, 10, 12, 10, 0, -12 },
  { 1536, 9, 12, 9, 1, -12 },
  { 1550, 14, 12, 13, 1, -12 },
  { 1571, 11, 12, 9, -1, -12 },
  { 1588, 12, 17, 9, -2, -12 },
  { 1614, 9, 12, 7, -1, -12 },
  { 1628, 9, 19, 7, 0, -16 },
  { 1650, 2, 22, 8, 3, -17 },
  { 1656, 8, 19, 7, -1, -16 },
  { 1675, 9, 4, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC22PT7B_H_
