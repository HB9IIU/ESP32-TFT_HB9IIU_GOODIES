#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0x80, 0x00, 0xE7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E, 0x70,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x81, 0xCE, 0x01, 0xC7, 0x00, 0xE7,
  0x00, 0x73, 0x81, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x01, 0xE7, 0x00,
  0x00, 0x20, 0x00, 0x40, 0x01, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87,
  0xF6, 0x0F, 0x64, 0x1E, 0x80, 0x3D, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x06, 0xF1, 0x09, 0xE3,
  0x17, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x0E, 0x01, 0xC1, 0xF0, 0x38, 0x3F, 0x83, 0x87, 0xB8,
  0x70, 0x73, 0x87, 0x07, 0x38, 0xE0, 0xE3, 0x9E, 0x0E, 0x39, 0xC0, 0xE7,
  0xBC, 0x0E, 0x73, 0x80, 0xE7, 0x73, 0xEE, 0xE7, 0x7F, 0xFE, 0xE7, 0x7F,
  0xCE, 0xE7, 0x79, 0xCE, 0x70, 0x1C, 0xE7, 0x03, 0x9C, 0x70, 0x39, 0xC7,
  0x07, 0x1C, 0x70, 0xF1, 0xCE, 0x0E, 0x1C, 0xE1, 0xE1, 0xFC, 0x1C, 0x1F,
  0xC3, 0x80, 0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80,
  0x71, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x79, 0xFF, 0x79, 0xF7, 0xBC, 0xF3,
  0xFC, 0xF1, 0xFE, 0x78, 0x7E, 0x3C, 0x3F, 0x1E, 0x1F, 0x0F, 0x9F, 0xC7,
  0xFF, 0xE1, 0xFE, 0xF0, 0x7E, 0x7C, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x3C,
  0xF0, 0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x0F, 0x80, 0x07, 0x80, 0x70,
  0x47, 0x0E, 0x70, 0xFF, 0xFF, 0xFF, 0x3F, 0xF1, 0xF0, 0x3F, 0x07, 0xB8,
  0xFB, 0xC3, 0x3C, 0x21, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x1E, 0x3E,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0xDF, 0xFF, 0xE0, 0x7B, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF1,
  0xE7, 0x9F, 0x3C, 0xF1, 0xE7, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF8, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xF7, 0x8F, 0x3C, 0xF9,
  0xE7, 0x8F, 0xFC, 0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x7C, 0x1F,
  0x07, 0xE1, 0xFC, 0x7F, 0xBF, 0xE3, 0xBC, 0x67, 0x80, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF0, 0xF1, 0xE0, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xC3, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xC0, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC4, 0x0F, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0x78, 0x0C, 0xF0, 0x3B, 0xC0, 0xE7, 0x81, 0xCF, 0x07,
  0x1E, 0x1C, 0x3C, 0x38, 0xF2, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC4, 0x0F, 0x8F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xEF, 0x87, 0xFF,
  0x1F, 0xFC, 0xFD, 0xF3, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x1F, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E,
  0x7C, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xFE, 0x1F, 0x3C,
  0x3C, 0x7C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x9F, 0x1F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7,
  0xCF, 0x3F, 0x3F, 0xFC, 0xFF, 0xE1, 0xF7, 0x83, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0xCF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x0F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0xFC, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0x0E, 0x00, 0x20, 0x00, 0x07,
  0x81, 0xFE, 0x3F, 0xE3, 0xFE, 0x21, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x0E, 0x0F, 0x00, 0x70,
  0xE0, 0x07, 0x1C, 0x18, 0x73, 0x87, 0xF7, 0x38, 0xFE, 0x77, 0x1C, 0xE7,
  0x73, 0x8E, 0x77, 0x38, 0xE7, 0xE3, 0x1C, 0x7E, 0x71, 0xC6, 0xE7, 0x1C,
  0x6E, 0x71, 0xCE, 0xE7, 0x38, 0xCE, 0x77, 0xDC, 0xE7, 0xFF, 0x8E, 0x3C,
  0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x81, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xCE,
  0x07, 0x9C, 0x0F, 0x38, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0xF8, 0x79, 0xE0, 0xF7, 0xC1, 0xEF, 0x03,
  0xDE, 0x07, 0xFC, 0x0F, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0xFC, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0x84, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x20, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xF3, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C,
  0x78, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x30,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x0F, 0xE7, 0x8F, 0xE7, 0xC7, 0xF3, 0xE3, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x8F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0x83, 0xC1, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x3C, 0x0F,
  0x1F, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF8, 0x07, 0xBC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xF7, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF8, 0x3E, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F,
  0xE3, 0xBC, 0x1D, 0xE7, 0xBC, 0x3D, 0xE7, 0x78, 0x3D, 0xEF, 0x78, 0x3D,
  0xEF, 0x78, 0x3D, 0xEE, 0x78, 0x39, 0xFE, 0x78, 0x79, 0xFC, 0xF0, 0x79,
  0xFC, 0xF0, 0x79, 0xF8, 0xF0, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE0, 0xF0, 0xE1, 0xE0, 0x07, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0xC1,
  0xE0, 0xFC, 0x1E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F, 0xE3, 0xC1, 0xFE,
  0x3C, 0x1F, 0xE3, 0xC1, 0xFE, 0x3C, 0x1E, 0xE3, 0x81, 0xCE, 0x78, 0x3C,
  0xF7, 0x83, 0xCF, 0x78, 0x3C, 0xF7, 0x83, 0xC7, 0x70, 0x38, 0x7F, 0x07,
  0x87, 0xF0, 0x78, 0x7F, 0x07, 0x87, 0xF0, 0x78, 0x7E, 0x0F, 0x03, 0xE0,
  0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x0F,
  0x1F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1E, 0x0F, 0x1F,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3D, 0xE0, 0x3D, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0, 0x78,
  0x00, 0x7C, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xCE, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xF8, 0x60, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x80,
  0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3C,
  0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x78,
  0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D,
  0xE0, 0x7B, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x1C, 0x0F, 0x78, 0x3C, 0x1F,
  0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x3C,
  0x78, 0xFC, 0x7C, 0x78, 0xFC, 0x78, 0x78, 0xFC, 0x78, 0x79, 0xDC, 0xF0,
  0x79, 0xFC, 0xF0, 0x7B, 0xFC, 0xF0, 0x7B, 0xBD, 0xE0, 0x73, 0xBD, 0xE0,
  0x77, 0xBF, 0xC0, 0xF7, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x0F,
  0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xEF,
  0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF8, 0xF1,
  0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0xF1, 0xE1, 0xC3,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDE, 0x0E, 0x78, 0x78, 0xE3,
  0xC3, 0x8E, 0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x01, 0xC0, 0xFF, 0xFF, 0xFC,
  0xF9, 0xE7, 0x8F, 0x3C, 0x0F, 0x9E, 0x3F, 0xF8, 0xFF, 0xF1, 0xF7, 0xE7,
  0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3E, 0x3E, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFB, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xFC, 0x1E, 0xFC, 0x3F, 0xF8, 0x7C, 0xF8, 0xF1,
  0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79,
  0xE1, 0xF3, 0xC3, 0xC7, 0xCF, 0x9F, 0x9E, 0x3F, 0xFC, 0x7F, 0xF0, 0xE7,
  0xC0, 0x07, 0xF1, 0xFF, 0x1F, 0xE3, 0xE6, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFB, 0x8F,
  0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x0F, 0xBC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3E, 0xFC, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x78,
  0xF7, 0x87, 0xBC, 0x39, 0xE3, 0xDF, 0xFC, 0xFF, 0xE7, 0xFC, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xA0, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE7, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xBF, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7C, 0x3C, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x3F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xF1, 0xF7, 0xC7, 0x8F,
  0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF0, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0x60, 0x00, 0x00, 0x3E, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xF0,
  0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7D, 0xE0,
  0x79, 0xE0, 0x79, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x87,
  0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x1E, 0xF8, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3E, 0xFE, 0xF1, 0xE3, 0xE7, 0x9F, 0x1E, 0x3C, 0xF0, 0xF1, 0xE7,
  0x8F, 0x0F, 0x3C, 0x78, 0x79, 0xE3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xF1,
  0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x7B, 0xE3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0,
  0xF1, 0xE7, 0x8F, 0x0F, 0x00, 0x0E, 0x78, 0x7F, 0xF1, 0xDF, 0xC7, 0xDF,
  0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xC0, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0xFB,
  0xEF, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x07, 0x9E, 0x03, 0xDF, 0x81,
  0xFF, 0xC0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0, 0xF1,
  0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x9C, 0x7F, 0xF1, 0xFF, 0xCF, 0xBF, 0x7C, 0x79,
  0xE1, 0xE7, 0x87, 0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC7, 0xCF, 0xBE, 0x3F, 0xF8, 0xFF, 0xE1, 0xF7, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0xF1, 0xEF, 0x1F, 0xF1, 0xFE, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xE6, 0x3C, 0x03,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xC8,
  0x3C, 0xEF, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x07, 0x03, 0x80, 0xE0, 0x78,
  0x3F, 0xDF, 0xE7, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x23, 0xF8, 0xFE, 0x1F, 0x80, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F,
  0x3E, 0x3F, 0xF8, 0xFF, 0xE1, 0xF7, 0x00, 0xF0, 0x7F, 0x87, 0xBC, 0x3D,
  0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0x87, 0xBC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x00, 0xF0, 0xF0, 0xFF, 0x1F, 0x1E, 0xF1, 0xF1, 0xEF, 0x3F, 0x1E, 0xF3,
  0xF3, 0xCF, 0x3F, 0x3C, 0xF7, 0x73, 0x8F, 0x77, 0x78, 0xFF, 0x77, 0x8F,
  0xE7, 0xF0, 0xEE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0x0F, 0x8F,
  0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x78, 0xF0, 0x7C, 0x78, 0x7C, 0x3C,
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00,
  0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x04, 0x03, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x04, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80,
  0x00, 0x7E, 0x07, 0xFF, 0x7F, 0xFF, 0xF1, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 24, 8, 0, -24 },
  { 31, 12, 9, 13, 3, -24 },
  { 45, 17, 24, 16, 0, -24 },
  { 96, 15, 27, 14, 0, -25 },
  { 147, 20, 24, 23, 2, -24 },
  { 207, 17, 24, 17, 0, -24 },
  { 258, 6, 9, 8, 3, -24 },
  { 265, 11, 29, 9, 0, -24 },
  { 305, 11, 29, 9, -3, -24 },
  { 345, 12, 13, 14, 3, -25 },
  { 365, 14, 16, 15, 1, -20 },
  { 393, 8, 8, 8, -2, -4 },
  { 401, 9, 4, 10, 0, -11 },
  { 406, 5, 5, 8, 0, -5 },
  { 410, 17, 24, 12, -2, -24 },
  { 461, 13, 24, 14, 1, -24 },
  { 500, 11, 24, 14, 3, -24 },
  { 533, 15, 24, 14, -1, -24 },
  { 578, 15, 24, 14, 0, -24 },
  { 623, 15, 24, 14, 0, -24 },
  { 668, 15, 24, 14, 0, -24 },
  { 713, 14, 24, 14, 1, -24 },
  { 755, 15, 24, 14, 1, -24 },
  { 800, 15, 24, 14, 0, -24 },
  { 845, 14, 24, 14, 0, -24 },
  { 887, 8, 18, 8, 0, -18 },
  { 905, 10, 22, 8, -2, -18 },
  { 933, 14, 16, 15, 1, -20 },
  { 961, 14, 10, 15, 1, -17 },
  { 979, 14, 16, 15, 1, -20 },
  { 1007, 12, 24, 11, 1, -24 },
  { 1043, 20, 27, 21, 1, -24 },
  { 1111, 15, 24, 16, -2, -24 },
  { 1156, 16, 24, 16, 0, -24 },
  { 1204, 16, 24, 14, 1, -24 },
  { 1252, 17, 24, 17, 0, -24 },
  { 1303, 15, 24, 13, 0, -24 },
  { 1348, 15, 24, 13, 0, -24 },
  { 1393, 17, 24, 17, 1, -24 },
  { 1444, 19, 24, 18, 0, -24 },
  { 1501, 14, 24, 10, -1, -24 },
  { 1543, 14, 31, 8, -5, -24 },
  { 1598, 18, 24, 15, 0, -24 },
  { 1652, 11, 24, 13, 0, -24 },
  { 1685, 24, 24, 23, 0, -24 },
  { 1757, 20, 24, 19, 0, -24 },
  { 1817, 17, 24, 18, 1, -24 },
  { 1868, 16, 24, 15, 0, -24 },
  { 1916, 17, 30, 18, 1, -24 },
  { 1980, 16, 24, 15, 0, -24 },
  { 2028, 16, 24, 14, -1, -24 },
  { 2076, 14, 24, 13, 2, -24 },
  { 2118, 17, 24, 17, 1, -24 },
  { 2169, 15, 24, 15, 3, -24 },
  { 2214, 24, 24, 23, 2, -24 },
  { 2286, 19, 24, 14, -2, -24 },
  { 2343, 14, 24, 14, 3, -24 },
  { 2385, 16, 24, 13, -1, -24 },
  { 2433, 13, 29, 9, -1, -24 },
  { 2481, 7, 24, 12, 3, -24 },
  { 2502, 13, 29, 9, -2, -24 },
  { 2550, 14, 15, 14, 0, -24 },
  { 2577, 11, 2, 11, -3, 3 },
  { 2580, 6, 5, 10, 5, -25 },
  { 2584, 15, 18, 15, 1, -18 },
  { 2618, 15, 25, 15, 0, -25 },
  { 2665, 12, 18, 12, 1, -18 },
  { 2692, 16, 25, 15, 1, -25 },
  { 2742, 13, 18, 14, 1, -18 },
  { 2772, 17, 33, 9, -4, -25 },
  { 2843, 16, 26, 15, -1, -18 },
  { 2895, 14, 25, 15, 0, -25 },
  { 2939, 9, 25, 8, 0, -25 },
  { 2968, 13, 33, 8, -4, -25 },
  { 3022, 16, 25, 14, 0, -25 },
  { 3072, 9, 25, 7, 0, -25 },
  { 3101, 21, 18, 22, 0, -18 },
  { 3149, 14, 18, 15, 0, -18 },
  { 3181, 13, 18, 15, 1, -18 },
  { 3211, 17, 26, 15, -2, -18 },
  { 3267, 14, 26, 15, 1, -18 },
  { 3313, 12, 18, 11, 0, -18 },
  { 3340, 12, 18, 12, 0, -18 },
  { 3367, 10, 22, 10, 1, -22 },
  { 3395, 14, 18, 15, 1, -18 },
  { 3427, 13, 18, 13, 2, -18 },
  { 3457, 20, 18, 20, 2, -18 },
  { 3502, 17, 18, 13, -2, -18 },
  { 3541, 18, 26, 13, -3, -18 },
  { 3600, 13, 18, 11, -1, -18 },
  { 3630, 14, 29, 11, 0, -24 },
  { 3681, 4, 32, 12, 4, -25 },
  { 3697, 13, 29, 11, -2, -24 },
  { 3745, 14, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC33PT7B_H_
