#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xC2, 0x00,
  0x0C, 0x3C, 0x78, 0xE0, 0x77, 0xBB, 0x9D, 0xCC, 0xEE, 0x67, 0x30, 0x07,
  0x70, 0x66, 0x06, 0x60, 0x6E, 0x0C, 0xC3, 0xFF, 0x3F, 0xF1, 0x98, 0x19,
  0x81, 0x98, 0xFF, 0xEF, 0xFC, 0x33, 0x07, 0x70, 0x66, 0x06, 0x60, 0xEE,
  0x00, 0x01, 0x00, 0x20, 0x3F, 0x8F, 0xE3, 0xEC, 0x74, 0x0E, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0xB8, 0x97, 0x3F, 0xE7, 0xF8, 0x7E,
  0x02, 0x00, 0x40, 0x00, 0x1E, 0x1C, 0x7C, 0x71, 0xD8, 0xC3, 0x33, 0x86,
  0x66, 0x1D, 0xD8, 0x33, 0x32, 0x66, 0xCF, 0xFD, 0xBE, 0xF6, 0xEC, 0x1D,
  0x98, 0x33, 0x30, 0xEE, 0x61, 0x9D, 0xC7, 0x3B, 0x0C, 0x3E, 0x30, 0x78,
  0x07, 0xC0, 0xFC, 0x1C, 0xC1, 0xCC, 0x1D, 0xC1, 0xD8, 0x1F, 0x80, 0xF0,
  0x3E, 0x73, 0xF7, 0x77, 0xEE, 0x7E, 0xE3, 0xCE, 0x3C, 0xF7, 0xCF, 0xFC,
  0x7D, 0xE0, 0x77, 0x76, 0x6E, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0x0C,
  0x4E, 0x3F, 0x3F, 0xF7, 0xF9, 0xE1, 0xF9, 0xCE, 0x26, 0x02, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0, 0x6F, 0xFE, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x83, 0xF1, 0xFC, 0xF7, 0x39, 0xCE, 0x77, 0x1D, 0xC7, 0x71, 0xDC,
  0x77, 0x3B, 0x8E, 0xE3, 0xB9, 0xC7, 0xF1, 0xF8, 0x3C, 0x00, 0x07, 0x0F,
  0x3E, 0x7E, 0xFE, 0x6E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x07, 0xC1, 0xFC, 0x7F, 0x84, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1F, 0xE7,
  0xFC, 0xFF, 0x80, 0x0F, 0xC3, 0xF8, 0x7F, 0x88, 0xF0, 0x1C, 0x03, 0x80,
  0xE0, 0xF8, 0x1F, 0x03, 0xF0, 0x0E, 0x01, 0xC0, 0x39, 0x0F, 0x3F, 0xC7,
  0xF8, 0xFC, 0x00, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x1B, 0x06,
  0xE0, 0xDC, 0x33, 0x8C, 0x71, 0x9C, 0x7F, 0xEF, 0xFC, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0E, 0x01, 0x80, 0x70, 0x0F,
  0xC1, 0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0x0F, 0x3F, 0xC7,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF1, 0xE4, 0xE0, 0x38, 0x1C, 0x07, 0xF3,
  0xFC, 0xFF, 0xB8, 0xEE, 0x3B, 0x9E, 0xE7, 0x39, 0xCF, 0xF3, 0xF8, 0x7C,
  0x00, 0x3F, 0xE7, 0xF9, 0xFF, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x00, 0x0F, 0xC3, 0xF8, 0x77, 0x9C, 0x73, 0x8E, 0x73, 0x87, 0xE0, 0xF8,
  0x1F, 0x0F, 0xF1, 0xCE, 0x71, 0xCE, 0x39, 0xC7, 0x3D, 0xE7, 0xF8, 0x7E,
  0x00, 0x0F, 0x87, 0xF3, 0xDC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCF, 0x7F,
  0xCF, 0xF3, 0xB8, 0x0E, 0x07, 0x81, 0xCD, 0xE3, 0xF8, 0xF8, 0x00, 0x1C,
  0xF3, 0x84, 0x00, 0x00, 0x00, 0x00, 0x8F, 0x3C, 0xE0, 0x0E, 0x3C, 0x70,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0x00,
  0xC0, 0xF0, 0xFC, 0xFC, 0xF8, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0,
  0x0C, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0xF8, 0xF8, 0xF8, 0x38, 0x08, 0x00,
  0x3E, 0x7F, 0x67, 0x07, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0x60,
  0x00, 0x40, 0xE0, 0xE0, 0xE0, 0x03, 0xF0, 0x3F, 0xE1, 0xC0, 0xCE, 0x03,
  0x31, 0xCD, 0x9F, 0xB6, 0x66, 0xF3, 0x33, 0xCC, 0xCF, 0x33, 0x3D, 0xDC,
  0xF6, 0x76, 0xDF, 0xF3, 0x3B, 0xCC, 0x00, 0x30, 0x00, 0xE0, 0x81, 0xFE,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x1D, 0xC3,
  0xB8, 0x67, 0x1C, 0xE3, 0x9C, 0xFF, 0x9F, 0xF7, 0xFE, 0xE1, 0xDC, 0x3F,
  0x07, 0xE0, 0xE0, 0x1F, 0xC1, 0xFE, 0x1D, 0xF1, 0xCF, 0x1C, 0xF3, 0x8E,
  0x39, 0xE3, 0xFC, 0x3F, 0x87, 0xBC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C,
  0xFF, 0x8F, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xFC, 0x7B, 0x1E, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C,
  0x73, 0xC7, 0x38, 0x73, 0x87, 0x38, 0xF7, 0x8F, 0x78, 0xE7, 0x1E, 0x71,
  0xE7, 0x3C, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xFC, 0x3F, 0x8F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3F, 0xC7, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xFC, 0x3F, 0x8F, 0xE1, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x1F, 0xE3,
  0xC0, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x3E, 0xF3, 0xEE, 0x3E, 0xE1, 0xCE,
  0x1C, 0xE1, 0xCF, 0x1C, 0xFF, 0xC7, 0xF8, 0x3F, 0x80, 0x1E, 0x3C, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0F, 0xFC, 0x3F,
  0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38,
  0x70, 0xE1, 0xC0, 0x1F, 0xC7, 0xF0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x83, 0xF8, 0xFE,
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x38, 0xE3, 0x87,
  0x38, 0x39, 0xC1, 0xDC, 0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x70, 0xE3, 0xC0,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xFF, 0xFF, 0xFE, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0xFC, 0x7E, 0x6E, 0x3F, 0x77,
  0x1B, 0xBF, 0x1D, 0xDB, 0x8E, 0xFD, 0xC7, 0x7C, 0xE3, 0xBE, 0x73, 0x9E,
  0x71, 0xC7, 0x38, 0xE3, 0x1C, 0x00, 0x1E, 0x1C, 0x78, 0x71, 0xE1, 0xC7,
  0xC6, 0x1F, 0x38, 0xFC, 0xE3, 0xF3, 0x8E, 0xCE, 0x3B, 0x30, 0xCF, 0xC7,
  0x3F, 0x1C, 0xFC, 0x73, 0xF1, 0xC7, 0x8E, 0x1E, 0x38, 0x78, 0xE1, 0xE0,
  0x07, 0xC1, 0xFE, 0x1F, 0xF3, 0x8F, 0x78, 0x77, 0x07, 0x70, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF0,
  0x3E, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xC7, 0x1C, 0x73, 0xC7, 0x38,
  0xF3, 0x8E, 0x3F, 0xE7, 0xFC, 0x7F, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x1F, 0xF3, 0x8F, 0x78, 0x77,
  0x07, 0x70, 0xFF, 0x0F, 0xF0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE,
  0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xC3, 0xFC, 0x77, 0x8E, 0x71, 0xCE, 0x71, 0xCE, 0x39, 0xCE, 0x3F,
  0xC7, 0xE1, 0xDC, 0x3B, 0x87, 0x38, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0xC0,
  0x0F, 0xE3, 0xFC, 0xFF, 0x1E, 0x23, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x79, 0x0F, 0x3F, 0xC7, 0xF0, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE3, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x00, 0x3C, 0x73, 0x87, 0x38,
  0xF3, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xE1,
  0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xFF, 0x8F, 0xF0, 0x7E, 0x00, 0xE0, 0xFC,
  0x3F, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xEF, 0x1D, 0xC3,
  0xB8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0xE1, 0xC3,
  0xF0, 0xE3, 0xB8, 0xF1, 0xDC, 0x79, 0xCE, 0x7C, 0xE7, 0x3E, 0x73, 0x9F,
  0x71, 0xDF, 0xB8, 0xED, 0x9C, 0x7E, 0xDC, 0x3F, 0x6E, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0x00, 0x0E,
  0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCF, 0x1E,
  0x38, 0xE1, 0xC0, 0xE1, 0xF8, 0xEE, 0x39, 0xDC, 0x77, 0x1F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x7F, 0x8F,
  0xF8, 0xFF, 0x80, 0x0F, 0xC3, 0xE0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xE3, 0x18, 0xE7, 0x39, 0xCE, 0x71,
  0x8C, 0x73, 0x9C, 0xE7, 0x18, 0x07, 0xC3, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x03, 0x01, 0xC0, 0x78,
  0x3E, 0x1F, 0x86, 0x63, 0x9D, 0xC7, 0x71, 0xF8, 0x30, 0xFF, 0xFF, 0xF3,
  0x8E, 0x1E, 0xE3, 0xFC, 0xF7, 0x9C, 0xF7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E,
  0xF3, 0x9E, 0x71, 0xDE, 0x3F, 0xC7, 0xB8, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x77, 0x8F, 0xF1, 0xEF, 0x38, 0xE7, 0x1D, 0xC7, 0x38, 0xE7,
  0x1C, 0xE3, 0x9C, 0xE7, 0xFC, 0xFF, 0x1B, 0xC0, 0x0F, 0xC7, 0xE3, 0xD8,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x1C, 0x07, 0xE1, 0xF8, 0x3E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0xFE, 0x1F, 0xE3,
  0xDE, 0x39, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xF3, 0x87,
  0x78, 0x7F, 0x87, 0xB8, 0x0F, 0x87, 0xF3, 0x9C, 0xE7, 0x71, 0xDF, 0xE7,
  0xF1, 0x80, 0xE0, 0x18, 0x07, 0x11, 0xFC, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0xD0, 0x38, 0x03, 0x80, 0x7E, 0x0F, 0xE0, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x0E, 0x00, 0x07, 0xF0, 0xFF,
  0x1E, 0xF1, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x79, 0xC7, 0x9C,
  0x7B, 0xC3, 0xFC, 0x3D, 0xC0, 0x38, 0x03, 0x88, 0x78, 0xFF, 0x0F, 0xF0,
  0x3C, 0x00, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0xF3, 0xFC, 0xF7,
  0x39, 0xCE, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0xE7, 0x3B, 0x8E, 0xE3, 0xB9,
  0xE0, 0x0E, 0x3C, 0x70, 0x00, 0x07, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87,
  0x0E, 0x1C, 0x70, 0xE1, 0xC0, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x3E, 0x0F, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x71, 0xCE, 0x71, 0xDC, 0x3B, 0x86,
  0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xEE, 0x19, 0xC7, 0x38, 0xE7, 0x9C, 0x70,
  0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E,
  0x1C, 0x70, 0xE1, 0xC0, 0x3B, 0xDE, 0x3F, 0xFE, 0x3D, 0xEF, 0x39, 0xC7,
  0x39, 0xCE, 0x71, 0xCE, 0x71, 0xCE, 0x73, 0x8E, 0x73, 0x8C, 0x63, 0x9C,
  0xE3, 0x9C, 0xE3, 0x1C, 0xE7, 0x1C, 0x1B, 0xCF, 0xF3, 0xDC, 0xE7, 0x39,
  0xDC, 0x77, 0x1D, 0xC7, 0x73, 0x9C, 0xEE, 0x3B, 0x8E, 0xE7, 0x80, 0x0F,
  0x87, 0xF3, 0xDC, 0xE7, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0xF3, 0xDC, 0xE7,
  0xF9, 0xFC, 0x3E, 0x00, 0x1D, 0xE1, 0xFE, 0x1E, 0xF1, 0xC7, 0x1C, 0x73,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x7F, 0xC7, 0xF8, 0x77, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xE3, 0xFC,
  0xF7, 0x9C, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0xF1, 0x9E, 0x73, 0xDE,
  0x3F, 0xC7, 0xB8, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x00,
  0x3B, 0x9F, 0x8F, 0xC7, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x00, 0x1F, 0x9F, 0xDE, 0x4E, 0x07, 0x81, 0xE0, 0xF8, 0x3C,
  0x0E, 0x07, 0x37, 0x9F, 0xCF, 0xC0, 0x18, 0x30, 0xE3, 0xFF, 0xCE, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1D, 0x3E, 0x7C, 0x71, 0xDC, 0x77, 0x19,
  0xCE, 0x73, 0xB8, 0xEE, 0x3B, 0x9C, 0xE7, 0x39, 0xCE, 0xF3, 0xFC, 0xF6,
  0x00, 0xE1, 0xF8, 0xE6, 0x39, 0x9C, 0x67, 0x1B, 0x86, 0xE1, 0xB0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0x70, 0x00, 0x63, 0x8F, 0xCF, 0x3B, 0x9E, 0x77,
  0x3C, 0xEE, 0xFB, 0x9D, 0xB7, 0x3B, 0x6C, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3,
  0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x00, 0x1C, 0xF1, 0xCE, 0x1D, 0xC1,
  0xDC, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x73, 0x87,
  0x38, 0xE3, 0x80, 0x0C, 0x38, 0x63, 0x83, 0x1C, 0x19, 0xC0, 0xCE, 0x06,
  0x60, 0x37, 0x01, 0xB8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x38, 0x00, 0x1F, 0xC7,
  0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03,
  0xFC, 0xFE, 0x00, 0x03, 0xC1, 0xE0, 0xF8, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0E, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xC1, 0xE3, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x3E,
  0x1E, 0x0C, 0x00, 0xFC, 0x7F, 0xF8, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 9, 6, 9, 2, -17 },
  { 23, 12, 17, 11, 0, -17 },
  { 49, 11, 19, 10, 0, -18 },
  { 76, 15, 17, 17, 1, -17 },
  { 108, 12, 17, 12, 0, -17 },
  { 134, 4, 6, 6, 2, -17 },
  { 137, 8, 21, 6, 0, -17 },
  { 158, 8, 21, 7, -2, -17 },
  { 179, 9, 10, 10, 2, -18 },
  { 191, 10, 11, 11, 1, -14 },
  { 205, 5, 6, 6, -1, -3 },
  { 209, 7, 3, 7, 0, -8 },
  { 212, 4, 4, 6, 0, -4 },
  { 214, 12, 17, 9, -1, -17 },
  { 240, 10, 17, 10, 0, -17 },
  { 262, 8, 17, 10, 2, -17 },
  { 279, 11, 17, 10, -1, -17 },
  { 303, 11, 17, 10, 0, -17 },
  { 327, 11, 17, 10, 0, -17 },
  { 351, 11, 17, 10, 0, -17 },
  { 375, 10, 17, 10, 1, -17 },
  { 397, 11, 17, 10, 1, -17 },
  { 421, 11, 17, 10, 0, -17 },
  { 445, 10, 17, 10, 0, -17 },
  { 467, 6, 13, 6, 0, -13 },
  { 477, 7, 16, 6, -1, -13 },
  { 491, 10, 11, 11, 1, -14 },
  { 505, 10, 7, 11, 1, -12 },
  { 514, 10, 11, 11, 1, -14 },
  { 528, 8, 17, 8, 1, -17 },
  { 545, 14, 19, 16, 1, -17 },
  { 579, 11, 17, 11, -1, -17 },
  { 603, 12, 17, 11, 0, -17 },
  { 629, 11, 17, 11, 1, -17 },
  { 653, 12, 17, 12, 0, -17 },
  { 679, 11, 17, 10, 0, -17 },
  { 703, 11, 17, 9, 0, -17 },
  { 727, 12, 17, 13, 1, -17 },
  { 753, 14, 17, 13, 0, -17 },
  { 783, 10, 17, 8, -1, -17 },
  { 805, 11, 22, 6, -4, -17 },
  { 836, 13, 17, 11, 0, -17 },
  { 864, 8, 17, 9, 0, -17 },
  { 881, 17, 17, 17, 0, -17 },
  { 918, 14, 17, 13, 0, -17 },
  { 948, 12, 17, 13, 1, -17 },
  { 974, 12, 17, 11, 0, -17 },
  { 1000, 12, 21, 13, 1, -17 },
  { 1032, 11, 17, 11, 0, -17 },
  { 1056, 11, 17, 10, 0, -17 },
  { 1080, 9, 17, 10, 2, -17 },
  { 1100, 12, 17, 12, 1, -17 },
  { 1126, 11, 17, 11, 2, -17 },
  { 1150, 17, 17, 17, 2, -17 },
  { 1187, 13, 17, 11, -1, -17 },
  { 1215, 10, 17, 10, 2, -17 },
  { 1237, 12, 17, 9, -1, -17 },
  { 1263, 10, 21, 7, -1, -17 },
  { 1290, 5, 17, 9, 2, -17 },
  { 1301, 10, 21, 7, -2, -17 },
  { 1328, 10, 10, 10, 0, -17 },
  { 1341, 8, 2, 8, -2, 2 },
  { 1343, 5, 3, 7, 3, -18 },
  { 1345, 11, 13, 11, 0, -13 },
  { 1363, 11, 18, 11, 0, -18 },
  { 1388, 10, 13, 9, 0, -13 },
  { 1405, 12, 18, 11, 0, -18 },
  { 1432, 10, 13, 10, 0, -13 },
  { 1449, 12, 24, 7, -3, -18 },
  { 1485, 12, 19, 11, -1, -13 },
  { 1514, 10, 18, 11, 0, -18 },
  { 1537, 7, 18, 6, 0, -18 },
  { 1553, 10, 24, 6, -3, -18 },
  { 1583, 11, 18, 10, 0, -18 },
  { 1608, 7, 18, 5, 0, -18 },
  { 1624, 16, 13, 16, 0, -13 },
  { 1650, 10, 13, 11, 0, -13 },
  { 1667, 10, 13, 11, 0, -13 },
  { 1684, 12, 19, 11, -1, -13 },
  { 1713, 11, 19, 11, 0, -13 },
  { 1740, 9, 13, 8, 0, -13 },
  { 1755, 9, 13, 9, 0, -13 },
  { 1770, 7, 16, 7, 1, -16 },
  { 1784, 10, 13, 11, 1, -13 },
  { 1801, 10, 13, 10, 1, -13 },
  { 1818, 15, 13, 15, 1, -13 },
  { 1843, 12, 13, 10, -1, -13 },
  { 1863, 13, 19, 10, -2, -13 },
  { 1894, 10, 13, 8, -1, -13 },
  { 1911, 10, 21, 8, 0, -17 },
  { 1938, 3, 23, 9, 3, -18 },
  { 1947, 9, 21, 8, -1, -17 },
  { 1971, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC24PT7B_H_
