#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0x86, 0xC0, 0x5D, 0xFA, 0x14, 0xF2, 0x9F, 0x2B, 0xEF,
  0x94, 0xA0, 0x11, 0xDE, 0xC3, 0x1E, 0xFE, 0x42, 0x00, 0x45, 0x4A, 0xA5,
  0xCD, 0x7F, 0x4A, 0xA5, 0xCC, 0x10, 0xA2, 0x8E, 0x31, 0xFD, 0xB6, 0xEC,
  0x7E, 0x12, 0x26, 0x4C, 0xCC, 0xCC, 0xC0, 0x31, 0x11, 0x13, 0x32, 0x64,
  0xC0, 0x2F, 0x7F, 0x60, 0x31, 0xBE, 0x63, 0x18, 0x6D, 0x60, 0xFC, 0xF0,
  0x06, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0xC0, 0x11, 0xDA, 0x95, 0xEF,
  0x5E, 0x60, 0x13, 0xFA, 0x26, 0x66, 0x40, 0x33, 0xD2, 0x31, 0x19, 0x98,
  0xF0, 0x33, 0xC2, 0x37, 0x0C, 0x76, 0xE0, 0x08, 0xCE, 0x75, 0x6B, 0xE6,
  0x30, 0x39, 0xD8, 0x87, 0x0C, 0x76, 0xE0, 0x1C, 0xE6, 0x14, 0x7B, 0x6D,
  0xB4, 0x70, 0x7D, 0xF0, 0x86, 0x10, 0xC2, 0x18, 0xC0, 0x33, 0xDA, 0xF3,
  0x2B, 0x7A, 0xF0, 0x33, 0xD2, 0x95, 0xBC, 0x46, 0xE0, 0x2C, 0x01, 0xB0,
  0x13, 0x00, 0x06, 0x64, 0xC0, 0x09, 0xF8, 0xE1, 0x84, 0xF8, 0x3F, 0xF0,
  0xC3, 0x86, 0x7E, 0x40, 0x33, 0xC4, 0x62, 0x20, 0x08, 0xC0, 0x0C, 0x32,
  0x21, 0x5D, 0x55, 0xAA, 0xAA, 0x94, 0x40, 0x78, 0x0C, 0x71, 0x47, 0x3C,
  0xF7, 0xD3, 0xCC, 0x30, 0xF6, 0xDB, 0x71, 0x6C, 0xB6, 0xF0, 0x18, 0xF6,
  0x18, 0x43, 0x0C, 0x12, 0x70, 0x30, 0xF6, 0xDB, 0x6D, 0x3C, 0xB6, 0xF0,
  0x39, 0xD8, 0xD7, 0x23, 0x18, 0xF0, 0x39, 0xD8, 0xC7, 0x3B, 0x18, 0xC0,
  0x0E, 0x79, 0x83, 0x05, 0xDB, 0xB3, 0x24, 0x78, 0x26, 0x4D, 0x93, 0x27,
  0xC9, 0xB2, 0x64, 0xD8, 0x3C, 0x61, 0x04, 0x30, 0xC2, 0x08, 0xF0, 0x08,
  0x46, 0x31, 0x88, 0x46, 0x31, 0x38, 0x80, 0x26, 0x59, 0xA3, 0xC7, 0x0E,
  0x34, 0x6C, 0xD8, 0x22, 0x66, 0x44, 0xCC, 0xF0, 0x31, 0x99, 0xDC, 0xCE,
  0xE5, 0x72, 0xFB, 0x69, 0xB4, 0x96, 0x00, 0x22, 0x6D, 0xDB, 0xA5, 0x4A,
  0xB7, 0x6E, 0x88, 0x18, 0xF6, 0x59, 0x47, 0x3C, 0xD6, 0x70, 0x38, 0xF6,
  0xDB, 0x59, 0xEC, 0x30, 0xC0, 0x18, 0xF6, 0x59, 0x47, 0x3C, 0xD6, 0x70,
  0x41, 0x80, 0x30, 0xF6, 0xDB, 0x79, 0xCD, 0x36, 0xD8, 0x1D, 0xE6, 0x18,
  0x70, 0xC1, 0x2C, 0xE0, 0xFF, 0x98, 0xC4, 0x23, 0x18, 0xC0, 0x26, 0x49,
  0x93, 0x64, 0xC9, 0xB2, 0x6C, 0x70, 0xCF, 0x2D, 0xB4, 0xF3, 0x8A, 0x38,
  0xC0, 0xC9, 0x99, 0x9B, 0xBA, 0xAE, 0xBC, 0xDC, 0xDC, 0xD8, 0x36, 0x6C,
  0x70, 0xC1, 0x87, 0x0A, 0x34, 0xC8, 0xCE, 0xF5, 0xC6, 0x21, 0x18, 0xC0,
  0x7B, 0xC6, 0x62, 0x31, 0x18, 0xF0, 0x33, 0x64, 0x44, 0xCC, 0x88, 0xC0,
  0xDB, 0x24, 0x92, 0x60, 0x39, 0xC4, 0x21, 0x18, 0xC4, 0x21, 0x38, 0x11,
  0x8C, 0xF4, 0xC4, 0xF0, 0xD0, 0x2D, 0xE4, 0xB6, 0xDB, 0x67, 0x00, 0x23,
  0x1E, 0xF4, 0xA7, 0x7B, 0xB0, 0x3B, 0x91, 0x8C, 0x69, 0xC0, 0x04, 0x32,
  0xDE, 0x4B, 0x2D, 0xB6, 0x70, 0x33, 0xD3, 0xEC, 0x61, 0xC0, 0x1C, 0x43,
  0x9E, 0x30, 0x82, 0x18, 0x61, 0x0C, 0x30, 0x3D, 0xE4, 0xB6, 0xDB, 0x6F,
  0x04, 0xB3, 0x80, 0x23, 0x1E, 0xF4, 0xAF, 0x7B, 0xD0, 0x25, 0xB4, 0xB6,
  0xC0, 0x08, 0x46, 0x31, 0x08, 0xC6, 0x31, 0x39, 0x80, 0x20, 0x86, 0xDE,
  0x51, 0xCF, 0x34, 0x90, 0x2D, 0xB4, 0xB6, 0xC0, 0x5A, 0x7F, 0x4B, 0x5B,
  0xDA, 0xD2, 0x96, 0x5B, 0xD2, 0xBD, 0xEF, 0x40, 0x33, 0xD3, 0x9D, 0xE9,
  0xC0, 0x2C, 0xF2, 0x49, 0x6D, 0xB5, 0x90, 0x43, 0x00, 0x3D, 0xE4, 0xB2,
  0xDB, 0x6F, 0x04, 0x30, 0xC0, 0x77, 0x64, 0xCC, 0xC0, 0x37, 0x46, 0x3B,
  0xE0, 0x23, 0x74, 0x44, 0xC6, 0x6D, 0xA4, 0x96, 0xDB, 0x4F, 0x00, 0x9B,
  0xAA, 0xEC, 0xC0, 0x93, 0x6E, 0xD7, 0xED, 0x9B, 0x26, 0x00, 0x24, 0xF3,
  0x84, 0x39, 0xED, 0x80, 0x24, 0x92, 0xCA, 0x38, 0xC3, 0x08, 0xE3, 0x00,
  0x77, 0x36, 0x4C, 0xE0, 0x09, 0xCC, 0x46, 0x61, 0x88, 0x42, 0x18, 0xFF,
  0xFF, 0xFF, 0x21, 0x84, 0x23, 0x0C, 0xC4, 0x23, 0x30, 0xFC, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 5, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 7, 9, 8, 1, -9 },
  { 29, 6, 9, 6, 0, -9 },
  { 36, 2, 4, 3, 1, -9 },
  { 37, 4, 11, 3, 0, -9 },
  { 43, 4, 11, 3, -1, -9 },
  { 49, 4, 5, 5, 1, -9 },
  { 52, 5, 6, 6, 0, -7 },
  { 56, 3, 4, 3, -1, -2 },
  { 58, 3, 2, 3, 0, -4 },
  { 59, 2, 2, 3, 0, -2 },
  { 60, 7, 9, 4, -1, -9 },
  { 68, 5, 9, 5, 0, -9 },
  { 74, 4, 9, 5, 1, -9 },
  { 79, 5, 9, 5, 0, -9 },
  { 85, 5, 9, 5, 0, -9 },
  { 91, 5, 9, 5, 0, -9 },
  { 97, 5, 9, 5, 0, -9 },
  { 103, 6, 9, 5, 0, -9 },
  { 110, 6, 9, 5, 0, -9 },
  { 117, 5, 9, 5, 0, -9 },
  { 123, 5, 9, 5, 0, -9 },
  { 129, 3, 7, 3, 0, -7 },
  { 132, 4, 9, 3, -1, -7 },
  { 137, 5, 6, 6, 0, -7 },
  { 141, 5, 4, 6, 0, -6 },
  { 144, 5, 6, 6, 0, -7 },
  { 148, 5, 9, 4, 0, -9 },
  { 154, 8, 10, 8, 0, -9 },
  { 164, 6, 9, 6, -1, -9 },
  { 171, 6, 9, 6, 0, -9 },
  { 178, 6, 9, 5, 0, -9 },
  { 185, 6, 9, 6, 0, -9 },
  { 192, 5, 9, 5, 0, -9 },
  { 198, 5, 9, 5, 0, -9 },
  { 204, 7, 9, 6, 0, -9 },
  { 212, 7, 9, 6, 0, -9 },
  { 220, 6, 9, 4, -1, -9 },
  { 227, 5, 12, 3, -2, -9 },
  { 235, 7, 9, 6, 0, -9 },
  { 243, 4, 9, 5, 0, -9 },
  { 248, 9, 9, 8, 0, -9 },
  { 259, 7, 9, 7, 0, -9 },
  { 267, 6, 9, 7, 0, -9 },
  { 274, 6, 9, 6, 0, -9 },
  { 281, 6, 11, 7, 0, -9 },
  { 290, 6, 9, 6, 0, -9 },
  { 297, 6, 9, 5, 0, -9 },
  { 304, 5, 9, 5, 1, -9 },
  { 310, 7, 9, 6, 0, -9 },
  { 318, 6, 9, 6, 1, -9 },
  { 325, 8, 9, 8, 1, -9 },
  { 334, 7, 9, 5, -1, -9 },
  { 342, 5, 9, 5, 1, -9 },
  { 348, 5, 9, 5, 0, -9 },
  { 354, 4, 11, 3, 0, -9 },
  { 360, 3, 9, 5, 1, -9 },
  { 364, 5, 11, 3, -1, -9 },
  { 371, 5, 6, 5, 0, -9 },
  { 375, 4, 1, 4, -1, 1 },
  { 376, 2, 2, 4, 2, -9 },
  { 377, 6, 7, 6, 0, -7 },
  { 383, 5, 9, 6, 0, -9 },
  { 389, 5, 7, 4, 0, -7 },
  { 394, 6, 9, 6, 0, -9 },
  { 401, 5, 7, 5, 0, -7 },
  { 406, 6, 12, 3, -1, -9 },
  { 415, 6, 10, 6, 0, -7 },
  { 423, 5, 9, 6, 0, -9 },
  { 429, 3, 9, 3, 0, -9 },
  { 433, 5, 12, 3, -2, -9 },
  { 441, 6, 9, 5, 0, -9 },
  { 448, 3, 9, 3, 0, -9 },
  { 452, 8, 7, 8, 0, -7 },
  { 459, 5, 7, 6, 0, -7 },
  { 464, 5, 7, 5, 0, -7 },
  { 469, 6, 10, 6, -1, -7 },
  { 477, 6, 10, 6, 0, -7 },
  { 485, 4, 7, 4, 0, -7 },
  { 489, 4, 7, 4, 0, -7 },
  { 493, 4, 8, 4, 0, -8 },
  { 497, 6, 7, 5, 0, -7 },
  { 503, 4, 7, 5, 1, -7 },
  { 507, 7, 7, 7, 1, -7 },
  { 514, 6, 7, 5, -1, -7 },
  { 520, 6, 10, 5, -1, -7 },
  { 528, 4, 7, 4, 0, -7 },
  { 532, 5, 11, 4, 0, -9 },
  { 539, 2, 12, 4, 1, -9 },
  { 542, 5, 11, 4, -1, -9 },
  { 549, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC12PT7B_H_
