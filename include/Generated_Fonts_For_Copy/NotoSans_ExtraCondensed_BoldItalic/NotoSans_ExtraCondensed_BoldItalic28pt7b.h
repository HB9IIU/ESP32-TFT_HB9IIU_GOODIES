#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x73, 0xB9, 0xFD,
  0xFC, 0xFE, 0x77, 0x3B, 0x9C, 0x03, 0x9C, 0x0E, 0x60, 0x33, 0x81, 0xCE,
  0x07, 0x30, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0E, 0x60, 0x33, 0x81, 0xCE,
  0x07, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x98, 0x0C, 0xE0, 0x73, 0x81, 0xCC,
  0x06, 0x70, 0x39, 0xC0, 0x00, 0xC0, 0x04, 0x01, 0xFC, 0x1F, 0xF1, 0xFF,
  0x0E, 0x90, 0x74, 0x03, 0xA0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x03, 0xF0, 0x17, 0x88, 0xBC, 0xE7, 0xC7, 0xFE, 0x3F, 0xE0, 0x7C,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x1F, 0x07, 0x07, 0xC3, 0x83, 0xB0,
  0xE1, 0xCC, 0x70, 0x73, 0x18, 0x18, 0xCE, 0x06, 0x73, 0x03, 0x9D, 0xC0,
  0xE6, 0x67, 0xBB, 0xBB, 0xF7, 0xCD, 0xDD, 0xE7, 0x77, 0x03, 0x99, 0xC0,
  0xEE, 0x70, 0x73, 0x9C, 0x1C, 0xE6, 0x0E, 0x3B, 0x83, 0x0E, 0xC1, 0xC3,
  0xF0, 0xE0, 0x78, 0x03, 0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x70,
  0x3B, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xF9, 0xCF, 0xEF,
  0x73, 0xBB, 0xCF, 0xEF, 0x1F, 0x38, 0x7C, 0xF3, 0xE3, 0xFF, 0xCF, 0xFF,
  0x1F, 0x9E, 0x7B, 0xBD, 0xEE, 0x73, 0x80, 0x03, 0xC1, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x83,
  0xC1, 0xC1, 0xC1, 0xE0, 0x08, 0x01, 0xE0, 0x38, 0x37, 0x07, 0xED, 0xFF,
  0x87, 0xF8, 0xF0, 0x3F, 0x0F, 0x70, 0xCE, 0x09, 0x80, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x38, 0xF1, 0xE3, 0x8F, 0x1C,
  0x78, 0x7F, 0x7E, 0xFE, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xFC, 0x7F,
  0x9E, 0x73, 0x8E, 0xF1, 0xDE, 0x3B, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0,
  0xEE, 0x3D, 0xC7, 0xB8, 0xE7, 0x3C, 0xE7, 0x1F, 0xE3, 0xF8, 0x3E, 0x00,
  0x07, 0x87, 0x87, 0xC7, 0xE7, 0xF7, 0xFB, 0x38, 0x9C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x00, 0x03,
  0xF0, 0x3F, 0xC7, 0xFE, 0x1C, 0xF0, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xFF, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0x1F,
  0xF0, 0x8F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x1F,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x83, 0xCF, 0xF8, 0xFF,
  0x0F, 0xE0, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x06,
  0xE0, 0xDE, 0x1D, 0xE1, 0x9C, 0x39, 0xC7, 0x1C, 0x63, 0xCF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x87, 0xCF, 0xF8, 0xFF,
  0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0xB8, 0x7F, 0xCF, 0xFC, 0xFB, 0xCF, 0x1C, 0xF1, 0xCE, 0x3C, 0xE3,
  0xCE, 0x3C, 0xF7, 0x8F, 0xF8, 0xFF, 0x07, 0xE0, 0x3F, 0xF9, 0xFF, 0x8F,
  0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x38, 0xF1,
  0xC7, 0x9E, 0x38, 0x73, 0xC3, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xE0, 0xFF,
  0x87, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xC7, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73, 0x87, 0x38,
  0xF3, 0x8F, 0x78, 0xF7, 0x9F, 0x3F, 0xE3, 0xEE, 0x1D, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x07, 0x8F, 0xF0, 0xFF, 0x0F, 0xC0, 0x1E, 0x3C, 0xF0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x1E, 0x3C, 0x00, 0x07, 0x83,
  0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x00, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7F, 0x1F, 0xC7, 0xE0, 0xF8, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x00, 0xC0,
  0x08, 0x00, 0x1F, 0x1F, 0xE3, 0xFC, 0x8F, 0x03, 0xC0, 0xE0, 0x78, 0x3C,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x3C,
  0x0F, 0x03, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xC1, 0xC1, 0xC0, 0x61,
  0xC0, 0x39, 0xC7, 0xCC, 0xC7, 0xE6, 0xE7, 0x73, 0x67, 0x31, 0xF3, 0x19,
  0xFB, 0x9C, 0xF9, 0xCE, 0x6C, 0xE7, 0x36, 0x77, 0x33, 0x3B, 0xB9, 0x9F,
  0xF8, 0xC7, 0x38, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x04, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x1C, 0x71, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE7, 0x87, 0x38, 0x3B, 0xC1, 0xDE, 0x0F, 0xE0, 0x70, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x87,
  0x1E, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1C, 0x3C, 0x71, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x03, 0xF0,
  0x3F, 0xC3, 0xFC, 0x3E, 0x23, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x87, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCE, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x1E, 0x7C, 0x73,
  0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x84, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xFC, 0x3F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0xF8, 0x43, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE3, 0xF3, 0xC7, 0xE7, 0x8F, 0xCF, 0x07, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF8, 0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x38, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x9E, 0x0F, 0xC0, 0xFC, 0x0F, 0x00,
  0x0F, 0x1E, 0x1C, 0x38, 0x38, 0xF0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07,
  0x78, 0x0E, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xBC,
  0x0F, 0x78, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x00, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xBB, 0x9C, 0x3B, 0xBB, 0xC7, 0xBF, 0x3C,
  0x73, 0xF3, 0x87, 0x3F, 0x38, 0x73, 0xE7, 0x8F, 0x3E, 0x78, 0xF3, 0xC7,
  0x0E, 0x3C, 0x70, 0x0F, 0x07, 0x87, 0x83, 0x83, 0xE1, 0xC3, 0xF0, 0xE1,
  0xF8, 0xF0, 0xFC, 0x70, 0x7E, 0x38, 0x3F, 0x1C, 0x3F, 0xDE, 0x1C, 0xEF,
  0x0E, 0x77, 0x07, 0x3B, 0x83, 0x9D, 0xC3, 0xCE, 0xE1, 0xC3, 0xF0, 0xE1,
  0xF0, 0x70, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1C, 0x1E, 0x00, 0x03, 0xF0,
  0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F,
  0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x3C, 0x3C, 0xF1, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC7, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x0F, 0x3C,
  0x78, 0xF3, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0xE0,
  0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C,
  0xF1, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x3C, 0xF1, 0xE3,
  0x8F, 0x1C, 0x71, 0xE3, 0x8F, 0x3C, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0x03,
  0xBC, 0x3D, 0xE1, 0xEF, 0x0E, 0x38, 0x71, 0xC7, 0x8F, 0x3C, 0x79, 0xE3,
  0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xC6, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x10, 0x78, 0x63, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0,
  0x7F, 0xEF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x1E, 0x1C, 0x70, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x8F, 0x1C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF3, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xEE, 0x3C,
  0xE3, 0xCE, 0x38, 0xE7, 0x8E, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x70, 0xFF,
  0x0F, 0x0E, 0xF0, 0xF0, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCF, 0x1F, 0x3C,
  0xF3, 0xF3, 0xCF, 0x3F, 0x38, 0xF7, 0x67, 0x8F, 0x76, 0x70, 0xF7, 0x6F,
  0x0E, 0xEE, 0xF0, 0xEE, 0xEE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0x07,
  0x8F, 0x07, 0x8E, 0x07, 0x9E, 0x03, 0x9C, 0x03, 0xBC, 0x03, 0xB8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0x70, 0xF0, 0x70, 0xF0, 0xF7, 0x0F, 0x71, 0xE7, 0x1E, 0x73, 0xC7, 0xB8,
  0x7F, 0x87, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xE0, 0xFC, 0x1F,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x3F, 0x07, 0xE0, 0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x78, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x3F, 0x07, 0xE0, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0xE7, 0x87, 0x70, 0x7E, 0x07, 0x7F,
  0xFF, 0xF0, 0xF3, 0xCE, 0x70, 0x02, 0x00, 0x7D, 0xC7, 0xFE, 0x7F, 0xF3,
  0xCF, 0x1C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x79, 0xE3,
  0xC7, 0x3E, 0x3F, 0xE1, 0xFF, 0x07, 0xB8, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE4, 0x1D, 0xE1, 0xFF, 0x3F, 0xF3, 0xC7, 0x3C, 0x73,
  0x87, 0x38, 0x77, 0x8F, 0x78, 0xF7, 0x8E, 0x79, 0xE7, 0x9E, 0xFF, 0xCF,
  0xF8, 0xEF, 0x00, 0x02, 0x07, 0xF3, 0xFC, 0xFE, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF1, 0x3F, 0x8F, 0xE1, 0xF8, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x08, 0xE0, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xF1, 0xE1, 0xC7, 0x87, 0xFC, 0x1F, 0xF0, 0x3D, 0xC0,
  0x02, 0x01, 0xF8, 0xFF, 0x1E, 0xE7, 0x9E, 0xE3, 0xBC, 0xF7, 0xFC, 0xFF,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFE, 0x3F, 0xC3, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x38, 0x00, 0x01,
  0x00, 0x1F, 0x70, 0xFF, 0xC3, 0xFF, 0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x79, 0xF0, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x39, 0xF0, 0xFF, 0x83,
  0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE4, 0x1D, 0xF1, 0xFF, 0x3F, 0xF3, 0xC7, 0x3C, 0xF3, 0x8F, 0x38, 0xF7,
  0x8E, 0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0xCF, 0x1C, 0xE3, 0xC0,
  0x0F, 0x0F, 0x0E, 0x0E, 0x00, 0x02, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x02, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xBE, 0x0F, 0xC0,
  0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x71, 0xE3, 0x9E, 0x3C, 0xE1, 0xEE, 0x0E, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x73, 0x83, 0x9E, 0x3C, 0xF1, 0xC7, 0x8E,
  0x1C, 0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x00,
  0x41, 0x07, 0x79, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0xF1, 0xCF, 0x3C,
  0x73, 0x8F, 0x3C, 0xE3, 0x8F, 0x78, 0xE3, 0x9E, 0x38, 0xE7, 0x1E, 0x39,
  0xC7, 0x1E, 0x71, 0xC7, 0xBC, 0x71, 0xCF, 0x3C, 0x73, 0x8F, 0x3C, 0x00,
  0x41, 0xDE, 0x1F, 0xF3, 0xFF, 0x3C, 0x73, 0xC7, 0x38, 0xF3, 0x8F, 0x78,
  0xE7, 0x8E, 0x70, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xF1, 0xCE, 0x3C, 0x02,
  0x03, 0xF0, 0xFF, 0x1F, 0xF7, 0x9E, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC,
  0x3B, 0x87, 0x71, 0xEE, 0x39, 0xFF, 0x3F, 0xC3, 0xF0, 0x00, 0x10, 0x1D,
  0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x1E, 0x78, 0xFF, 0xC3, 0xFE, 0x0E,
  0xF0, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x02, 0x00, 0x7D, 0xC7, 0xFE, 0x3F, 0xF3, 0xCF, 0x1C, 0x79,
  0xE3, 0xCF, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xE3, 0xC7, 0x1E, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0x47, 0x71, 0xFC, 0xFF, 0x3E, 0x4F, 0x03,
  0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0x06, 0x07, 0xF3, 0xFC, 0xF7, 0x38, 0x0E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x1E, 0x87, 0xBF, 0xCF, 0xF3, 0xF0, 0x0C, 0x0C, 0x1C, 0x1C,
  0x7F, 0x7F, 0xFF, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xFC, 0xFC, 0x7C, 0x38, 0xF3, 0x8E, 0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1E,
  0x71, 0xCF, 0x1C, 0xF1, 0xCE, 0x3C, 0xE3, 0xCE, 0x78, 0xFF, 0x8F, 0xF8,
  0xFB, 0x80, 0xE1, 0xFC, 0x7B, 0x8E, 0x71, 0xCE, 0x79, 0xCE, 0x3B, 0xC7,
  0x70, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x71,
  0xE3, 0xDC, 0x78, 0xE7, 0x3E, 0x79, 0xCF, 0x9C, 0x77, 0xEF, 0x1D, 0xFB,
  0x87, 0x6E, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0x00, 0x1E, 0x7C, 0x79,
  0xC0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xC7, 0x0F, 0x1C, 0x00,
  0x0E, 0x1E, 0x1C, 0x78, 0x38, 0xF0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03,
  0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x02, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x81, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0xF9,
  0xFF, 0x3F, 0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x01, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x7C, 0x0F, 0x80, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0xF0, 0x1F, 0x05, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0xC3, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7C,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 7, 11, 3, -20 },
  { 29, 14, 20, 13, 0, -20 },
  { 64, 13, 23, 12, 0, -21 },
  { 102, 18, 20, 20, 1, -20 },
  { 147, 14, 20, 14, 0, -20 },
  { 182, 5, 7, 7, 3, -20 },
  { 187, 10, 24, 8, 0, -20 },
  { 217, 9, 24, 8, -2, -20 },
  { 244, 11, 12, 11, 2, -22 },
  { 261, 12, 14, 13, 1, -17 },
  { 282, 7, 8, 7, -2, -4 },
  { 289, 8, 3, 8, 0, -9 },
  { 292, 4, 4, 7, 0, -4 },
  { 294, 15, 20, 10, -2, -20 },
  { 332, 11, 20, 12, 1, -20 },
  { 360, 9, 20, 12, 3, -20 },
  { 383, 13, 20, 12, -1, -20 },
  { 416, 12, 20, 12, 0, -20 },
  { 446, 12, 20, 12, 0, -20 },
  { 476, 12, 20, 12, 0, -20 },
  { 506, 12, 20, 12, 1, -20 },
  { 536, 13, 20, 12, 1, -20 },
  { 569, 13, 20, 12, 0, -20 },
  { 602, 12, 20, 12, 0, -20 },
  { 632, 7, 15, 7, 0, -15 },
  { 646, 9, 19, 7, -2, -15 },
  { 668, 12, 14, 13, 1, -17 },
  { 689, 12, 8, 13, 1, -14 },
  { 701, 12, 14, 13, 1, -17 },
  { 722, 10, 20, 9, 1, -20 },
  { 747, 17, 22, 18, 1, -20 },
  { 794, 13, 20, 13, -2, -20 },
  { 827, 14, 20, 13, 0, -20 },
  { 862, 13, 20, 12, 1, -20 },
  { 895, 14, 20, 14, 0, -20 },
  { 930, 13, 20, 11, 0, -20 },
  { 963, 12, 20, 11, 0, -20 },
  { 993, 15, 20, 15, 1, -20 },
  { 1031, 16, 20, 15, 0, -20 },
  { 1071, 12, 20, 9, -1, -20 },
  { 1101, 12, 26, 7, -4, -20 },
  { 1140, 15, 20, 13, 0, -20 },
  { 1178, 9, 20, 11, 0, -20 },
  { 1201, 20, 20, 19, 0, -20 },
  { 1251, 17, 20, 16, 0, -20 },
  { 1294, 14, 20, 15, 1, -20 },
  { 1329, 14, 20, 13, 0, -20 },
  { 1364, 14, 25, 15, 1, -20 },
  { 1408, 13, 20, 13, 0, -20 },
  { 1441, 14, 20, 12, -1, -20 },
  { 1476, 11, 20, 11, 2, -20 },
  { 1504, 14, 20, 14, 1, -20 },
  { 1539, 12, 20, 13, 3, -20 },
  { 1569, 20, 20, 20, 2, -20 },
  { 1619, 16, 20, 12, -2, -20 },
  { 1659, 12, 20, 12, 2, -20 },
  { 1689, 14, 20, 11, -1, -20 },
  { 1724, 11, 24, 8, -1, -20 },
  { 1757, 6, 20, 11, 3, -20 },
  { 1772, 11, 24, 8, -2, -20 },
  { 1805, 12, 12, 12, 0, -20 },
  { 1823, 10, 2, 9, -3, 2 },
  { 1826, 5, 4, 8, 4, -21 },
  { 1829, 13, 16, 13, 0, -16 },
  { 1855, 12, 21, 13, 0, -21 },
  { 1887, 10, 16, 10, 1, -16 },
  { 1907, 14, 21, 13, 0, -21 },
  { 1944, 11, 16, 12, 1, -16 },
  { 1966, 14, 28, 8, -3, -21 },
  { 2015, 14, 23, 13, -1, -16 },
  { 2056, 12, 21, 13, 0, -21 },
  { 2088, 8, 21, 6, 0, -21 },
  { 2109, 12, 28, 6, -4, -21 },
  { 2151, 13, 21, 12, 0, -21 },
  { 2186, 8, 21, 6, 0, -21 },
  { 2207, 18, 16, 19, 0, -16 },
  { 2243, 12, 16, 13, 0, -16 },
  { 2267, 11, 16, 12, 1, -16 },
  { 2289, 14, 23, 13, -2, -16 },
  { 2330, 13, 23, 13, 0, -16 },
  { 2368, 10, 16, 9, 0, -16 },
  { 2388, 10, 16, 10, 0, -16 },
  { 2408, 8, 19, 8, 1, -19 },
  { 2427, 12, 15, 13, 1, -15 },
  { 2450, 11, 15, 11, 2, -15 },
  { 2471, 18, 15, 17, 1, -15 },
  { 2505, 14, 15, 11, -1, -15 },
  { 2532, 15, 22, 11, -2, -15 },
  { 2574, 11, 15, 9, -1, -15 },
  { 2595, 11, 24, 9, 0, -20 },
  { 2628, 4, 28, 10, 3, -22 },
  { 2642, 11, 24, 9, -2, -20 },
  { 2675, 12, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC28PT7B_H_
