#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x00, 0xE3, 0x8E,
  0x00, 0x76, 0xDF, 0xBF, 0x6C, 0xC0, 0x06, 0xC1, 0x98, 0x33, 0x06, 0xC3,
  0xFE, 0xFF, 0x86, 0xC0, 0xD8, 0x33, 0x1F, 0xF3, 0xFE, 0x33, 0x06, 0x40,
  0xD8, 0x33, 0x00, 0x02, 0x01, 0x07, 0xE3, 0xF3, 0xD1, 0xA0, 0xF0, 0x78,
  0x1F, 0x07, 0x83, 0xD1, 0x6C, 0xF7, 0xF3, 0xF0, 0x20, 0x10, 0x00, 0x3C,
  0x73, 0xE3, 0x1B, 0x30, 0x99, 0x8C, 0xD8, 0x66, 0xC3, 0x6D, 0xFF, 0x6F,
  0x76, 0xD8, 0x36, 0xC3, 0x66, 0x33, 0x31, 0x9B, 0x18, 0xF8, 0xC3, 0x80,
  0x0F, 0x03, 0xF0, 0x66, 0x0C, 0xC1, 0xB8, 0x3E, 0x07, 0x81, 0xE7, 0x7E,
  0xCD, 0xFB, 0x9E, 0x73, 0xCE, 0x79, 0xFF, 0x1E, 0xF0, 0x76, 0xEE, 0xC0,
  0x06, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0x60, 0xC0, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x1C, 0x38, 0x61, 0xC3, 0x86, 0x1C, 0x31, 0xC0, 0x18, 0x33, 0x6F, 0xF3,
  0xEF, 0x3B, 0x27, 0x08, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x3B, 0x9C, 0xCE, 0x60, 0x7F, 0xEF, 0x80, 0x7F, 0x80, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x00, 0x0F, 0x0F, 0xC6, 0xE7,
  0x33, 0x3B, 0x9D, 0xCE, 0xC7, 0x63, 0x33, 0xB9, 0xDC, 0xEE, 0xE3, 0xE1,
  0xE0, 0x0E, 0x38, 0xF3, 0xEF, 0xCB, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x0E, 0x1C, 0x00, 0x07, 0x87, 0xF1, 0x9C, 0x47, 0x01, 0xC0, 0x70, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xCF, 0xF0, 0x1F, 0x1F,
  0xC4, 0xE0, 0x70, 0x38, 0x18, 0x78, 0x3C, 0x2F, 0x03, 0x81, 0xC0, 0xE8,
  0xE7, 0xF3, 0xF0, 0x03, 0x81, 0xC1, 0xE1, 0xF0, 0xF0, 0xD8, 0xDC, 0x6E,
  0x66, 0x63, 0x7F, 0xDF, 0xE0, 0xE0, 0x60, 0x30, 0x1F, 0x8F, 0xC7, 0xE7,
  0x03, 0x81, 0x80, 0xF8, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE8, 0xE7, 0xF3,
  0xF0, 0x07, 0xC3, 0xE1, 0xC0, 0x60, 0x38, 0x0D, 0x87, 0xF1, 0xFC, 0x73,
  0x18, 0xC6, 0x33, 0x9C, 0x67, 0x1F, 0x83, 0xC0, 0x7F, 0xBF, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03,
  0x80, 0x0F, 0x0F, 0xCE, 0x66, 0x33, 0xB9, 0xDC, 0x78, 0x7C, 0x7F, 0x33,
  0xB8, 0xDC, 0xEE, 0x77, 0xF1, 0xF0, 0x0F, 0x0F, 0xCE, 0xE6, 0x77, 0x3B,
  0x9D, 0xCE, 0xFF, 0x7F, 0x1B, 0x81, 0xC1, 0xC1, 0xE7, 0xE3, 0xE0, 0x11,
  0xCE, 0x60, 0x00, 0x00, 0x07, 0x39, 0xC0, 0x08, 0x71, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0xC7, 0x1C, 0x63, 0x8C, 0x00, 0x01, 0x03, 0x0F, 0x3E, 0xF8,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x1F, 0x7C, 0xF0, 0xC0, 0x1E, 0x3F,
  0x27, 0x07, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x30, 0x00, 0x00, 0x60, 0x70,
  0xE0, 0x03, 0xE0, 0x1D, 0xE0, 0xC1, 0x86, 0x02, 0x33, 0xEC, 0xDB, 0x36,
  0x6C, 0x9B, 0x32, 0x6C, 0xD9, 0x36, 0x64, 0xDB, 0x33, 0xB8, 0x44, 0x41,
  0x80, 0x06, 0x08, 0x0F, 0xE0, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0x61, 0xD8, 0x66, 0x39, 0xCF, 0xF3, 0xFD, 0xC7, 0x71, 0xF8,
  0x7E, 0x1C, 0x1F, 0x87, 0xF1, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xF8, 0xFC,
  0x73, 0x9C, 0xE7, 0x39, 0x8E, 0xE7, 0x3F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE3,
  0xC9, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE6, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF8, 0x6F, 0x1C, 0xF3, 0x8E, 0x71,
  0xCE, 0x39, 0x8E, 0x71, 0xCE, 0x39, 0xCE, 0x31, 0xCF, 0xF1, 0xFC, 0x3F,
  0x00, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x81, 0xC0, 0xFC, 0x7E, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x7E, 0x7E, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x0F,
  0xE3, 0xF8, 0xF3, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x17, 0x3C, 0xE7, 0x9C,
  0x73, 0x8E, 0x71, 0xCF, 0x31, 0xFE, 0x1F, 0xC0, 0x1C, 0x71, 0xC7, 0x18,
  0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xC3, 0xFC, 0x71, 0xC7, 0x1C, 0x71,
  0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x1F, 0x8F, 0xC3, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0xE3, 0xF0,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x7C, 0x3C, 0x00, 0x1C, 0xF1,
  0x8E, 0x19, 0xC3, 0xB8, 0x3B, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0x60, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE3, 0x80, 0x1C, 0x38, 0x61,
  0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x1F, 0xFF, 0x00, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xC6, 0xCD, 0x8D, 0x9F,
  0x1B, 0x7E, 0x76, 0xD8, 0xEF, 0xB1, 0x9E, 0xE3, 0x3D, 0xCE, 0x73, 0x9C,
  0xE6, 0x39, 0x8C, 0x00, 0x1C, 0x31, 0xC3, 0x1E, 0x73, 0xE7, 0x3E, 0x73,
  0x66, 0x36, 0x63, 0x6E, 0x77, 0xE7, 0x7C, 0x63, 0xC6, 0x3C, 0xE3, 0xCE,
  0x3C, 0xE3, 0x80, 0x0F, 0x87, 0xF3, 0x9D, 0xC7, 0x71, 0xD8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x3F, 0x87, 0xC0, 0x1F, 0x87,
  0xF1, 0x9C, 0xE3, 0x38, 0xCE, 0x73, 0x1C, 0xFE, 0x7F, 0x1F, 0x87, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0x9D, 0xC7, 0x71, 0xD8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x3F, 0x87, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0x07, 0xE1, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x38, 0xFE, 0x7E, 0x1D, 0x87, 0x61, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x0F, 0xC7, 0xE3, 0xD8, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0xCE, 0x3F, 0x8F, 0x80, 0x7F, 0xBF, 0xC7, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x80,
  0x38, 0xE7, 0x38, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x18, 0xE7, 0x1C, 0xE3,
  0x9C, 0x73, 0x8C, 0x73, 0x8E, 0xF1, 0xFC, 0x1F, 0x00, 0xE1, 0xF8, 0xEE,
  0x3B, 0x9C, 0xE7, 0x31, 0x8C, 0xE3, 0x30, 0xDC, 0x36, 0x0D, 0x83, 0xE0,
  0xF0, 0x3C, 0x0E, 0x00, 0x61, 0x87, 0x63, 0x8E, 0x63, 0x8E, 0x63, 0x8C,
  0x67, 0x9C, 0x67, 0x98, 0x67, 0xB8, 0x6D, 0xB8, 0x6D, 0xB0, 0x7D, 0xF0,
  0x79, 0xE0, 0x79, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0, 0xF1, 0xC0, 0x1C, 0x71,
  0xCE, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xE0, 0x0F, 0x01,
  0xF0, 0x1F, 0x03, 0xB0, 0x73, 0x06, 0x38, 0xE3, 0x80, 0xE3, 0xF3, 0xB9,
  0x9D, 0xCE, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x80, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0x87, 0x83, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x78, 0x7C, 0x00, 0xEE, 0xE6, 0x66, 0x66,
  0x77, 0x73, 0x33, 0x30, 0x0F, 0x87, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x78, 0x7C,
  0x00, 0x06, 0x03, 0x03, 0xC3, 0xE1, 0xB1, 0x99, 0xCE, 0xC7, 0xE1, 0x80,
  0xFE, 0xE6, 0x70, 0x0C, 0x07, 0xF3, 0xF9, 0xCE, 0x73, 0x9C, 0xE6, 0x3B,
  0x8C, 0xE7, 0x39, 0xC7, 0xF1, 0xDC, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0xB1,
  0xFC, 0xFE, 0x63, 0x71, 0xB9, 0xDC, 0xEC, 0x76, 0x37, 0xBB, 0xF9, 0xB8,
  0x06, 0x1F, 0x3F, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x64, 0x7C, 0x7C,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0xDC, 0x3F, 0x8F, 0xE1, 0x9C, 0x73,
  0x8E, 0x71, 0x8E, 0x71, 0x8E, 0x31, 0xCE, 0x1F, 0xC3, 0xF0, 0x06, 0x0F,
  0x8E, 0xE6, 0x77, 0x33, 0xF9, 0xF1, 0xC0, 0xE0, 0x31, 0x1F, 0x87, 0xC0,
  0x03, 0xC1, 0xF0, 0x70, 0x18, 0x06, 0x07, 0xE1, 0xF0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x0F, 0x03,
  0xC0, 0xE0, 0x00, 0x06, 0x01, 0xFC, 0x7F, 0x0C, 0xE3, 0x9C, 0x73, 0x8C,
  0x73, 0x8C, 0x73, 0x8E, 0x70, 0xFE, 0x1D, 0xC0, 0x30, 0x0E, 0x31, 0xC7,
  0xF0, 0x7C, 0x00, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0xB1, 0xFC, 0xFE, 0x77,
  0x73, 0xB9, 0xDC, 0xEC, 0x66, 0x77, 0x3B, 0x9D, 0xCC, 0x1C, 0x71, 0x80,
  0x00, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0x03, 0x81, 0xC0,
  0xC0, 0x00, 0x00, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x0C, 0x2E, 0x1E, 0x0F, 0x00, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x4E, 0x63, 0x30, 0xDC, 0x7E, 0x1F, 0x07, 0xE1, 0xF8,
  0x6E, 0x39, 0x8E, 0x63, 0x1C, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x71,
  0xC7, 0x18, 0x63, 0x8E, 0x38, 0x03, 0x10, 0xDF, 0xE3, 0xFF, 0xCC, 0xE7,
  0x73, 0x99, 0xCE, 0x67, 0x33, 0x98, 0xCE, 0x67, 0x3B, 0x9C, 0xCE, 0x63,
  0x31, 0x9C, 0x03, 0x1B, 0xCF, 0xE7, 0x77, 0x3B, 0x9D, 0xCE, 0xC6, 0x63,
  0x73, 0xB9, 0xDC, 0xC0, 0x0E, 0x0F, 0x8F, 0xEE, 0x77, 0x3B, 0x1D, 0x8F,
  0xC7, 0xE7, 0x33, 0x9F, 0x87, 0x80, 0x01, 0x86, 0xF1, 0xFC, 0x63, 0x38,
  0xCE, 0x73, 0x9C, 0xC7, 0x31, 0x9E, 0xE7, 0xF1, 0xFC, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0xF3, 0xF8, 0xCE, 0x73, 0x98, 0xE6,
  0x3B, 0x8C, 0xE3, 0x39, 0xC7, 0xF1, 0xDC, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x00, 0x03, 0x37, 0x3E, 0x38, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0xE0, 0x1C, 0x3F, 0x7E, 0x70, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x9C,
  0xFC, 0xF8, 0x18, 0xC3, 0x3F, 0xF9, 0x86, 0x38, 0xE3, 0x8C, 0x30, 0xF3,
  0xC0, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x31, 0x9C, 0xE7,
  0x1F, 0xC7, 0x60, 0xE7, 0xE7, 0xE6, 0xEE, 0xEC, 0xFC, 0xF8, 0xF8, 0x70,
  0x70, 0x70, 0xE7, 0x3F, 0x79, 0xBB, 0xDD, 0xDE, 0xCF, 0xB6, 0x7D, 0xF3,
  0x6F, 0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x39, 0xE0, 0x39, 0xC6, 0x61, 0xF8,
  0x7C, 0x0E, 0x07, 0x81, 0xE0, 0xF8, 0x37, 0x1D, 0xCE, 0x70, 0x1C, 0x71,
  0xCE, 0x1C, 0xC0, 0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0x9F,
  0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x3F, 0x3F, 0x80, 0x07,
  0x87, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x78, 0x78, 0x1C, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0F, 0x0F,
  0x1E, 0x38, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 8, 2, -15 },
  { 18, 11, 15, 10, 0, -15 },
  { 39, 9, 17, 9, 0, -16 },
  { 59, 13, 15, 15, 1, -15 },
  { 84, 11, 15, 11, 0, -15 },
  { 105, 4, 5, 5, 2, -15 },
  { 108, 7, 18, 6, 0, -15 },
  { 124, 7, 18, 6, -2, -15 },
  { 140, 7, 9, 9, 2, -16 },
  { 148, 8, 10, 10, 1, -12 },
  { 158, 5, 6, 5, -1, -3 },
  { 162, 6, 3, 6, 0, -7 },
  { 165, 3, 3, 5, 0, -3 },
  { 167, 11, 15, 8, -1, -15 },
  { 188, 9, 15, 9, 0, -15 },
  { 205, 7, 15, 9, 2, -15 },
  { 219, 10, 15, 9, -1, -15 },
  { 238, 9, 15, 9, 0, -15 },
  { 255, 9, 15, 9, 0, -15 },
  { 272, 9, 15, 9, 0, -15 },
  { 289, 10, 15, 9, 0, -15 },
  { 308, 9, 15, 9, 1, -15 },
  { 325, 9, 15, 9, 0, -15 },
  { 342, 9, 15, 9, 0, -15 },
  { 359, 5, 12, 5, 0, -12 },
  { 367, 6, 15, 5, -1, -12 },
  { 379, 8, 10, 10, 1, -13 },
  { 389, 8, 7, 10, 1, -11 },
  { 396, 8, 10, 10, 1, -13 },
  { 406, 8, 15, 7, 0, -15 },
  { 421, 14, 17, 14, 0, -15 },
  { 451, 10, 15, 10, -1, -15 },
  { 470, 10, 15, 10, 0, -15 },
  { 489, 10, 15, 9, 1, -15 },
  { 508, 11, 15, 11, 0, -15 },
  { 529, 9, 15, 8, 0, -15 },
  { 546, 9, 15, 8, 0, -15 },
  { 563, 11, 15, 11, 1, -15 },
  { 584, 12, 15, 11, 0, -15 },
  { 607, 9, 15, 7, -1, -15 },
  { 624, 9, 19, 5, -3, -15 },
  { 646, 12, 15, 10, 0, -15 },
  { 669, 7, 15, 8, 0, -15 },
  { 683, 15, 15, 15, 0, -15 },
  { 712, 12, 15, 12, 0, -15 },
  { 735, 10, 15, 11, 1, -15 },
  { 754, 10, 15, 10, 0, -15 },
  { 773, 10, 19, 11, 1, -15 },
  { 797, 10, 15, 10, 0, -15 },
  { 816, 10, 15, 9, 0, -15 },
  { 835, 9, 15, 8, 1, -15 },
  { 852, 11, 15, 11, 1, -15 },
  { 873, 10, 15, 10, 2, -15 },
  { 892, 16, 15, 15, 1, -15 },
  { 922, 12, 15, 9, -1, -15 },
  { 945, 9, 15, 9, 2, -15 },
  { 962, 11, 15, 8, -1, -15 },
  { 983, 9, 18, 6, -1, -15 },
  { 1004, 4, 15, 8, 2, -15 },
  { 1012, 9, 18, 6, -2, -15 },
  { 1033, 9, 9, 9, 0, -15 },
  { 1044, 7, 1, 7, -2, 2 },
  { 1045, 4, 3, 6, 3, -16 },
  { 1047, 10, 12, 10, 0, -12 },
  { 1062, 9, 16, 10, 0, -16 },
  { 1080, 8, 12, 8, 0, -12 },
  { 1092, 11, 16, 10, 0, -16 },
  { 1114, 9, 12, 9, 0, -12 },
  { 1128, 10, 21, 6, -2, -16 },
  { 1155, 11, 17, 10, -1, -12 },
  { 1179, 9, 16, 10, 0, -16 },
  { 1197, 6, 16, 5, 0, -16 },
  { 1209, 9, 21, 5, -3, -16 },
  { 1233, 10, 16, 9, 0, -16 },
  { 1253, 6, 16, 5, 0, -16 },
  { 1265, 14, 12, 14, 0, -12 },
  { 1286, 9, 12, 10, 0, -12 },
  { 1300, 9, 12, 9, 0, -12 },
  { 1314, 10, 17, 10, -1, -12 },
  { 1336, 10, 17, 10, 0, -12 },
  { 1358, 8, 12, 7, 0, -12 },
  { 1370, 8, 12, 8, 0, -12 },
  { 1382, 6, 14, 6, 1, -14 },
  { 1393, 10, 11, 9, 0, -11 },
  { 1407, 8, 11, 8, 1, -11 },
  { 1418, 13, 11, 13, 1, -11 },
  { 1436, 10, 11, 9, -1, -11 },
  { 1450, 12, 16, 8, -2, -11 },
  { 1474, 9, 11, 7, -1, -11 },
  { 1487, 9, 18, 7, 0, -15 },
  { 1508, 2, 21, 8, 3, -16 },
  { 1514, 8, 18, 7, -1, -15 },
  { 1532, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC21PT7B_H_
