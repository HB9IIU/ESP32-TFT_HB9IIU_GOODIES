#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00,
  0x3E, 0x3E, 0x7C, 0xFD, 0xF9, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x1E, 0x3C, 0x7C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFB, 0x30, 0x3E,
  0x40, 0x07, 0xC8, 0x00, 0xFB, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x01, 0xBF, 0x00, 0x37, 0xE2, 0x06, 0xFC, 0x40, 0xDF, 0x8E, 0x13,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F,
  0xF8, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x78, 0xF0, 0xF0, 0x1E, 0x1C, 0x1E,
  0x03, 0xC7, 0x87, 0x80, 0x78, 0xF1, 0xF0, 0x0F, 0x1E, 0x3C, 0x03, 0xC3,
  0xCF, 0x00, 0x78, 0x79, 0xE0, 0x0F, 0x1E, 0x78, 0x79, 0xE3, 0xCF, 0x3F,
  0xBC, 0xF3, 0xCF, 0xFF, 0xFE, 0x79, 0xFF, 0x7F, 0x9E, 0x79, 0xEF, 0xE3,
  0xCF, 0x3C, 0xF8, 0xF3, 0xC7, 0x80, 0x3E, 0x78, 0xF0, 0x07, 0x8F, 0x1E,
  0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x78, 0x78, 0x0F, 0x0F, 0x1E, 0x01, 0xE1,
  0xE3, 0xC0, 0x78, 0x3C, 0x78, 0x0F, 0x07, 0x9E, 0x03, 0xC0, 0xF7, 0xC0,
  0x78, 0x1F, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0x0F, 0xF8, 0xFC, 0x7F, 0xF3, 0xE3,
  0xE7, 0xDF, 0x9F, 0x9F, 0xFC, 0x7C, 0x7F, 0xF3, 0xF0, 0xFF, 0x8F, 0x83,
  0xFE, 0x3E, 0x0F, 0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC7, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xDF, 0x83, 0xFC, 0x7F, 0x00,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x21, 0xE0, 0x31, 0xE0, 0x7D,
  0xE3, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7E, 0xF8, 0x3E, 0x7C, 0x1C, 0x7C, 0x08, 0x30, 0x00,
  0x20, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x8F,
  0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x00,
  0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0, 0x08, 0xF9, 0xFF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x83,
  0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC1, 0xF3,
  0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8,
  0xFC, 0x3E, 0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF8,
  0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0xFD, 0xF1, 0xE7, 0xC3, 0x3F, 0x08, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xF1, 0xFC, 0x07, 0x07, 0xE0, 0x20, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x18, 0x3F, 0x01,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x8C, 0x03,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0x7C, 0x00, 0xF7, 0xC0, 0x1E, 0xFC, 0x01, 0xCF, 0x80, 0x3C,
  0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x1F, 0x81, 0xE1, 0xF0, 0x1E,
  0x1F, 0x03, 0xC1, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0E, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x80, 0x7F, 0x18, 0x1F, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x9E, 0x03, 0xEF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0x3F, 0x1F, 0xC3, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1,
  0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x7E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0x83, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xBE, 0x07, 0xEF, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x83, 0x9F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0x81,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xC1, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x3F, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x0F, 0xC0,
  0x1F, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x0E, 0x0F, 0x07, 0xE1, 0xE3, 0xC1, 0xFF, 0x3C, 0x78, 0x7F, 0xC7, 0x9E,
  0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x70, 0xE1, 0xE3, 0x9E, 0x3C, 0x38,
  0x73, 0xC7, 0x8F, 0x0E, 0x79, 0xE1, 0xE3, 0xCE, 0x3C, 0x3C, 0x7B, 0xC7,
  0x87, 0x0E, 0x78, 0xF1, 0xE1, 0xCF, 0x1E, 0x3C, 0x79, 0xE3, 0xCF, 0x8E,
  0x3C, 0x79, 0xF3, 0x87, 0x8F, 0xFF, 0xF0, 0xF1, 0xFD, 0xFC, 0x1E, 0x1F,
  0x1F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x80, 0x0F, 0x80, 0x60, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x03,
  0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8,
  0x0F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF,
  0xF0, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xF8, 0xFE, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF8, 0x30, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x20, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0x9F, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E,
  0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07,
  0xE1, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3,
  0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x1F, 0xC1, 0xF9, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC1, 0xC0, 0xFE, 0x01,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x3F, 0x0F,
  0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0x83, 0xF8, 0x3E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03,
  0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x07,
  0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F,
  0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xF7, 0xC0, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0x87, 0xFF, 0x07, 0xDF, 0x1F, 0x7C, 0x0F, 0xBE, 0x3E, 0xF8, 0x1F,
  0x3C, 0x79, 0xF0, 0x3E, 0x79, 0xF7, 0xE0, 0x7C, 0xF3, 0xCF, 0x81, 0xF1,
  0xEF, 0x9F, 0x03, 0xE3, 0xDE, 0x3E, 0x07, 0xC7, 0xFC, 0x7C, 0x0F, 0x8F,
  0xF1, 0xF8, 0x3F, 0x1F, 0xE3, 0xE0, 0x7C, 0x3F, 0xC7, 0xC0, 0xF8, 0x7F,
  0x0F, 0x81, 0xF0, 0xFE, 0x3F, 0x03, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x3E, 0x03,
  0xF8, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C,
  0x07, 0xFC, 0x1F, 0x03, 0xFF, 0x0F, 0xC0, 0xFF, 0xC3, 0xE0, 0x3E, 0xF0,
  0xF8, 0x0F, 0xBE, 0x3E, 0x03, 0xEF, 0x8F, 0x81, 0xF3, 0xE7, 0xE0, 0x7C,
  0xF9, 0xF0, 0x1F, 0x3E, 0x7C, 0x07, 0xC7, 0x9F, 0x01, 0xF1, 0xF7, 0xC0,
  0xF8, 0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x0F, 0x87, 0xFE, 0x03, 0xE0, 0xFF,
  0x81, 0xF8, 0x3F, 0xE0, 0x7C, 0x0F, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0xC0,
  0xFF, 0x01, 0xF0, 0x3F, 0xC0, 0xF8, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0xFE, 0x03,
  0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0xFE, 0x03,
  0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xFC, 0x1F,
  0x8F, 0xC1, 0xF8, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0xF0, 0x1F, 0x81,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x40, 0x3F, 0x03,
  0x83, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF4, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8,
  0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x7E, 0xF8, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0x01, 0xF3, 0xE0, 0x7E,
  0x07, 0xE7, 0xC0, 0xFC, 0x0F, 0x8F, 0x83, 0xF8, 0x3F, 0x1F, 0x07, 0xF0,
  0x7C, 0x3E, 0x0F, 0xE0, 0xF8, 0x7C, 0x3F, 0xC3, 0xF0, 0xF8, 0x7F, 0x87,
  0xC1, 0xF1, 0xFF, 0x1F, 0x83, 0xE3, 0xFE, 0x3E, 0x0F, 0xC7, 0xFC, 0x7C,
  0x1F, 0x9F, 0xF9, 0xF8, 0x3F, 0x3D, 0xF3, 0xE0, 0x7E, 0x7B, 0xE7, 0xC0,
  0xF9, 0xF7, 0xDF, 0x81, 0xF3, 0xCF, 0x3E, 0x03, 0xEF, 0x9E, 0xFC, 0x07,
  0xDE, 0x3D, 0xF0, 0x0F, 0xBC, 0x7B, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F,
  0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF,
  0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x7C, 0x1E,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xEF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0x78,
  0x3E, 0x0F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7E, 0x7E,
  0x3E, 0x3F, 0x1F, 0x0F, 0x01, 0xE0, 0x00, 0xFE, 0x7C, 0x3F, 0xEF, 0x87,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF1, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xF1,
  0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0x7C, 0x1F, 0xCF, 0x81, 0xF1,
  0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF9,
  0xE0, 0x3F, 0x7E, 0x07, 0xDF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xF3, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xDF, 0xE0, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x84, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFE, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x1F, 0x01, 0xFC,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x7F, 0x07,
  0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0xCF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0x80, 0x3F, 0x3C, 0x00, 0x00,
  0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFE, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x81, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xF7, 0xC0, 0x7F, 0xBE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xF3, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x08, 0x07, 0xE0, 0x78, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF9, 0xE0, 0x3F, 0x7F, 0x07, 0xDF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F,
  0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x3E, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F,
  0x9F, 0x81, 0xFB, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x7E,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0xFB, 0xF8, 0xFE, 0x0F, 0xFF, 0xDF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0x3F, 0x1F, 0x87,
  0xE3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07, 0xC3, 0xF1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xE3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC7, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x07,
  0xC7, 0xC1, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0xFC,
  0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F, 0x87, 0xE1,
  0xF0, 0x00, 0x07, 0x00, 0xF3, 0xF0, 0x3E, 0xFF, 0x07, 0xBF, 0xE0, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF9, 0xFC, 0xFC, 0xFC,
  0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x3F, 0x7C, 0x1F,
  0xBF, 0x1F, 0x9F, 0xDF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x00, 0x01, 0xC0, 0x1F, 0x3F, 0x80, 0xFB, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xC1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x9F, 0x83, 0xFF, 0xF8, 0x1F, 0x7F, 0xC0, 0xFB,
  0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x7C,
  0x1F, 0xEF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0x3F, 0x8F, 0xC3, 0xF1,
  0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF,
  0xC1, 0xF9, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F,
  0x07, 0xE3, 0xF1, 0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x9F, 0x0F, 0xBE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0x04, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x81, 0xF8, 0xF7, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0x7F, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x90, 0xFF, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x00, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F,
  0xC3, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFB, 0xC0, 0xFF, 0x78, 0x0F, 0xCF, 0x00, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x3F, 0x87, 0xEF, 0x87,
  0xE0, 0xF9, 0xF0, 0xFC, 0x3E, 0x3E, 0x3F, 0x87, 0xC7, 0xC7, 0xF0, 0xF8,
  0xF9, 0xFE, 0x3E, 0x1F, 0x3F, 0xC7, 0xC3, 0xC7, 0xF9, 0xF0, 0x79, 0xEF,
  0x3E, 0x0F, 0x3D, 0xE7, 0xC3, 0xEF, 0xBD, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F,
  0xBC, 0xF7, 0x81, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0,
  0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x09, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x2F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x00, 0xBF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 15, 11, 17, 4, -31 },
  { 69, 22, 31, 21, 0, -31 },
  { 155, 19, 36, 18, 0, -33 },
  { 241, 27, 31, 30, 2, -31 },
  { 346, 22, 31, 22, 0, -31 },
  { 432, 8, 11, 10, 4, -31 },
  { 443, 14, 38, 12, 1, -31 },
  { 510, 14, 38, 12, -3, -31 },
  { 577, 16, 18, 18, 3, -33 },
  { 613, 17, 21, 20, 2, -26 },
  { 658, 9, 12, 10, -2, -6 },
  { 672, 12, 5, 12, 0, -14 },
  { 680, 7, 7, 10, 0, -7 },
  { 687, 22, 31, 16, -2, -31 },
  { 773, 18, 31, 18, 1, -31 },
  { 843, 14, 31, 19, 4, -31 },
  { 898, 21, 31, 18, -2, -31 },
  { 980, 20, 31, 18, -1, -31 },
  { 1058, 20, 31, 19, -1, -31 },
  { 1136, 19, 31, 18, 0, -31 },
  { 1210, 19, 31, 18, 1, -31 },
  { 1284, 20, 31, 18, 1, -31 },
  { 1362, 19, 31, 18, 0, -31 },
  { 1436, 19, 31, 18, 0, -31 },
  { 1510, 10, 24, 10, 0, -24 },
  { 1540, 12, 30, 10, -2, -24 },
  { 1585, 17, 21, 20, 2, -26 },
  { 1630, 17, 13, 20, 2, -22 },
  { 1658, 17, 21, 20, 2, -26 },
  { 1703, 15, 31, 14, 1, -31 },
  { 1762, 27, 34, 28, 1, -31 },
  { 1877, 21, 31, 20, -3, -31 },
  { 1959, 21, 31, 20, 0, -31 },
  { 2041, 21, 31, 19, 1, -31 },
  { 2123, 22, 31, 22, 0, -31 },
  { 2209, 19, 31, 17, 0, -31 },
  { 2283, 19, 31, 16, 0, -31 },
  { 2357, 22, 31, 23, 2, -31 },
  { 2443, 24, 31, 23, 0, -31 },
  { 2536, 19, 31, 14, -2, -31 },
  { 2610, 19, 40, 11, -7, -31 },
  { 2705, 24, 31, 20, 0, -31 },
  { 2798, 14, 31, 17, 0, -31 },
  { 2853, 31, 31, 30, 0, -31 },
  { 2974, 26, 31, 24, 0, -31 },
  { 3075, 22, 31, 23, 1, -31 },
  { 3161, 21, 31, 20, 0, -31 },
  { 3243, 22, 38, 23, 1, -31 },
  { 3348, 20, 31, 20, 0, -31 },
  { 3426, 21, 31, 18, -1, -31 },
  { 3508, 17, 31, 17, 3, -31 },
  { 3574, 23, 31, 22, 1, -31 },
  { 3664, 20, 31, 20, 4, -31 },
  { 3742, 31, 31, 30, 3, -31 },
  { 3863, 25, 31, 19, -3, -31 },
  { 3960, 18, 31, 18, 4, -31 },
  { 4030, 22, 31, 17, -2, -31 },
  { 4116, 17, 38, 12, -2, -31 },
  { 4197, 9, 31, 16, 4, -31 },
  { 4232, 17, 38, 12, -3, -31 },
  { 4313, 19, 19, 19, 0, -31 },
  { 4359, 14, 3, 14, -4, 4 },
  { 4365, 8, 7, 13, 6, -33 },
  { 4372, 19, 24, 20, 1, -24 },
  { 4429, 19, 33, 20, 0, -33 },
  { 4508, 16, 24, 16, 1, -24 },
  { 4556, 21, 33, 20, 1, -33 },
  { 4643, 17, 24, 18, 1, -24 },
  { 4694, 22, 43, 12, -5, -33 },
  { 4813, 21, 34, 20, -1, -24 },
  { 4903, 19, 33, 20, 0, -33 },
  { 4982, 12, 33, 10, 0, -33 },
  { 5032, 17, 43, 10, -5, -33 },
  { 5124, 20, 33, 18, 0, -33 },
  { 5207, 12, 33, 10, 0, -33 },
  { 5257, 28, 24, 29, 0, -24 },
  { 5341, 19, 24, 20, 0, -24 },
  { 5398, 17, 24, 19, 1, -24 },
  { 5449, 21, 34, 20, -2, -24 },
  { 5539, 19, 34, 20, 1, -24 },
  { 5620, 16, 24, 14, 0, -24 },
  { 5668, 16, 24, 15, 0, -24 },
  { 5716, 13, 28, 13, 1, -28 },
  { 5762, 19, 23, 19, 1, -23 },
  { 5817, 16, 23, 17, 3, -23 },
  { 5863, 27, 23, 26, 2, -23 },
  { 5941, 21, 23, 17, -2, -23 },
  { 6002, 23, 33, 17, -3, -23 },
  { 6097, 18, 23, 15, -2, -23 },
  { 6149, 18, 38, 15, 0, -31 },
  { 6235, 5, 43, 16, 5, -33 },
  { 6262, 17, 38, 15, -3, -31 },
  { 6343, 17, 7, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC43PT7B_H_
