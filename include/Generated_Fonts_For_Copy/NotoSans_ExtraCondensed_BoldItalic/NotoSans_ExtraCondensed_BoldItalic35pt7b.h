#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x3C, 0xFB, 0xE7,
  0x9F, 0x3C, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0xF1, 0xC0,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x38, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x71,
  0xC0, 0x1C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x83, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0x4C, 0x1E, 0x44, 0x1E, 0x40, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0x7C, 0x01, 0x7C, 0x43,
  0x7C, 0x43, 0x78, 0x7A, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x07,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0xE0, 0x7E, 0x07,
  0x03, 0xFC, 0x3C, 0x1E, 0x70, 0xE0, 0x71, 0xC7, 0x81, 0xCF, 0x1C, 0x0F,
  0x3C, 0xF0, 0x38, 0xE3, 0x80, 0xE3, 0x9E, 0x03, 0x8E, 0x70, 0x0E, 0x7B,
  0x8F, 0x39, 0xCE, 0x7E, 0xFF, 0x73, 0xFF, 0xFB, 0xDE, 0xF7, 0xCE, 0x73,
  0xC0, 0x79, 0xCF, 0x01, 0xCE, 0x3C, 0x0F, 0x38, 0xE0, 0x38, 0xE3, 0x81,
  0xE3, 0x8E, 0x07, 0x0E, 0x78, 0x3C, 0x39, 0xC0, 0xE0, 0xFF, 0x07, 0x03,
  0xF8, 0x3C, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE7, 0xC7, 0xF9, 0xE3,
  0xDE, 0x79, 0xF7, 0xFE, 0x78, 0xFF, 0x3E, 0x3F, 0xCF, 0x0F, 0xE3, 0xC1,
  0xF0, 0xF0, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x1F,
  0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9C, 0xF0, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x8F,
  0x07, 0x71, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0x01, 0xFC, 0x1F, 0xF1,
  0xF7, 0x83, 0x1E, 0x08, 0xE0, 0x04, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x70,
  0xF0, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x7C,
  0x3D, 0xF1, 0xF7, 0x87, 0xDE, 0x1F, 0xF8, 0x7B, 0xE1, 0xEF, 0x0F, 0xBC,
  0x3E, 0xF0, 0xFB, 0xC3, 0xCF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFE, 0x1F,
  0xE3, 0xFC, 0xFF, 0xC7, 0xBC, 0x27, 0xC2, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x07, 0x1F, 0x06, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x81, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xBC, 0x03, 0xFC, 0x07, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1C,
  0x78, 0x38, 0xF8, 0x38, 0xF0, 0x70, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x10, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x81, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xFB, 0xE1, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0x9F, 0x9F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0xF9, 0xE1,
  0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x9F, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xBF,
  0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x0F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3E, 0xF8, 0x7C, 0xF8,
  0x78, 0x78, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0x78, 0xFD, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x78,
  0x7C, 0xF0, 0xF9, 0xF3, 0xF3, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xBE,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF0,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0xE3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0x9F, 0x01, 0xF0, 0x1C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xC1, 0xE3, 0x87, 0x1F, 0xE7, 0x38, 0xFF, 0x1C, 0xE7, 0x9C,
  0x67, 0x1C, 0x73, 0x9C, 0xF1, 0xCE, 0x73, 0x8E, 0x3B, 0x8E, 0x38, 0xEE,
  0x38, 0xE3, 0xB9, 0xE7, 0x9C, 0xE7, 0x1C, 0x73, 0x9C, 0x73, 0x8E, 0x7F,
  0xFE, 0x38, 0xFB, 0xF0, 0xE1, 0xC7, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x0C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xEF, 0x01, 0xEF, 0x03, 0xEF, 0x03, 0xCF,
  0x03, 0xCF, 0x07, 0x8F, 0x07, 0x8F, 0x0F, 0x8F, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F,
  0x8F, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xF8, 0xF8,
  0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0xC7, 0x87,
  0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xF8, 0x20, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0x9F, 0x83, 0xE3, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF8, 0x7C, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xC1, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0xFE, 0x7C, 0x7F, 0x1E, 0x1F,
  0xCF, 0x87, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE3,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0xF0, 0x78,
  0x1E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1E, 0x3E, 0x03, 0xCF, 0x80,
  0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x07,
  0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x1E, 0xE0, 0xFF, 0x0F, 0x70,
  0xFF, 0x07, 0xB8, 0x77, 0x83, 0xDC, 0x7B, 0xC1, 0xEE, 0x3D, 0xE1, 0xF7,
  0x3D, 0xF0, 0xF3, 0x9E, 0xF0, 0x79, 0xDE, 0x78, 0x3C, 0xFF, 0x3C, 0x1E,
  0x7F, 0x3E, 0x1E, 0x3F, 0x9F, 0x0F, 0x1F, 0x8F, 0x07, 0x8F, 0xC7, 0x83,
  0xC7, 0xC3, 0xC3, 0xE3, 0xE3, 0xE1, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0,
  0x00, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xF8, 0x3C, 0x1F, 0xC1, 0xE0,
  0xFE, 0x0F, 0x07, 0xF0, 0xF8, 0x3F, 0x87, 0x81, 0xFC, 0x3C, 0x1E, 0xF1,
  0xE0, 0xF7, 0x8F, 0x07, 0xBC, 0xF8, 0x3D, 0xE7, 0x81, 0xEF, 0x3C, 0x1E,
  0x39, 0xE0, 0xF1, 0xEF, 0x07, 0x8F, 0xF0, 0x3C, 0x7F, 0x81, 0xE3, 0xFC,
  0x1E, 0x1F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF0, 0x3C, 0x1F, 0x83, 0xE0,
  0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x83, 0xE3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xC7, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF0, 0x78, 0x7C, 0x3C, 0x3E, 0x1E,
  0x1E, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xDF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3E,
  0x0F, 0x1F, 0x07, 0x8F, 0x83, 0xC3, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0,
  0x7C, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC,
  0x60, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x08, 0x0F, 0x86, 0x0F, 0x83, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xC3, 0xC1, 0xF0,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF0,
  0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0xC0,
  0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x1E, 0x07, 0xDE, 0x07, 0x81,
  0xE7, 0x83, 0xE0, 0xF9, 0xE0, 0xF8, 0x3C, 0x78, 0x3E, 0x1F, 0x1E, 0x1F,
  0x87, 0x87, 0x87, 0xE1, 0xE1, 0xE3, 0xF8, 0xF8, 0x78, 0xFE, 0x3C, 0x1E,
  0x3F, 0x9F, 0x07, 0x9F, 0xE7, 0x81, 0xE7, 0xF9, 0xE0, 0x79, 0xDE, 0xF8,
  0x1E, 0xF7, 0xBC, 0x07, 0xB9, 0xEF, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x1F, 0xC7, 0x78, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E,
  0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x3C, 0x3E, 0x03, 0xE3, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x7C,
  0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0xF0, 0x7B, 0xE1,
  0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0,
  0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x07, 0x9C, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1,
  0xE0, 0xE7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0xF8,
  0xF1, 0xF1, 0xE3, 0xC3, 0xC0, 0x0F, 0xDE, 0x3F, 0xBC, 0x7F, 0xF9, 0xFF,
  0xF3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3,
  0xE1, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1F, 0x3C, 0x7C, 0x7D, 0xF8, 0xFF,
  0xF1, 0xFD, 0xE1, 0xF3, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7C, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xBE, 0x1F, 0x1E, 0x1E, 0x1F, 0x3E, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x78, 0xFE, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xE7, 0xC0, 0x07,
  0xF0, 0x7F, 0xC7, 0xFC, 0x7E, 0xC3, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE1, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x07,
  0xDE, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xCF, 0xC3, 0xC7, 0xC3, 0xE1, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F,
  0x78, 0x1F, 0x38, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x7C, 0xF3, 0xC3,
  0xBC, 0x3D, 0xE1, 0xFF, 0x3E, 0xFF, 0xF7, 0xFE, 0x3F, 0x81, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x0C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF7, 0x81, 0xFB, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF1, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xDF, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC2, 0x03, 0xC1, 0xE7, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x7C, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x1F, 0x3C, 0x3E,
  0x78, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x7C,
  0x3C, 0xF8, 0xF9, 0xE1, 0xF3, 0xC3, 0xC0, 0x01, 0x01, 0xF0, 0x7C, 0x1E,
  0x07, 0x80, 0x80, 0x00, 0x00, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x0F, 0x8F, 0x8F, 0x07, 0x8F, 0x83, 0xCF, 0x81, 0xE7, 0x80, 0xF7,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xDF, 0x03, 0xCF, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x7C, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x00, 0x0E, 0x7C, 0xFC, 0x3D, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFD, 0xFF, 0xF1, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF8, 0xF1, 0xF1, 0xF3, 0xE3,
  0xC3, 0xC7, 0x87, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x3E, 0x7C, 0x7C,
  0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0xC0, 0x0E, 0x7C,
  0x3D, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x87, 0x9F,
  0x1F, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0x87, 0xCF, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE1, 0xF3, 0xC3, 0xC0, 0x00, 0x80,
  0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0xF1, 0xF7, 0xC3, 0xDE, 0x0F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F,
  0xBC, 0x7C, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x9F, 0x01,
  0xEF, 0xE0, 0x7F, 0xF8, 0x1F, 0xBE, 0x07, 0xC7, 0x81, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0x7F, 0x03, 0xDF, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xDE,
  0x1F, 0xFC, 0x7F, 0xF9, 0xF7, 0xF3, 0xC7, 0xCF, 0x87, 0x9E, 0x1F, 0x3C,
  0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1F,
  0x3C, 0x7C, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xF7, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x0E, 0x78, 0xF7, 0xC7, 0xFC, 0x3F, 0xE1, 0xFD, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xF0, 0xFF, 0xC7,
  0xFC, 0x7C, 0x63, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF2, 0x0F, 0x9F, 0xF8, 0xFF, 0xC7,
  0xFC, 0x3F, 0xC0, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1F, 0xDF, 0xF7, 0xFC,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xE8, 0xFE, 0x3F, 0x87, 0xE0, 0x1E, 0x1E, 0x7C, 0x3C,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x1F, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C,
  0x7D, 0xF8, 0xFF, 0xF1, 0xFD, 0xC1, 0xF3, 0x80, 0xF0, 0x7F, 0xC1, 0xEF,
  0x0F, 0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3,
  0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x7F, 0x87, 0xC7, 0xFC,
  0x7E, 0x3D, 0xE3, 0xF1, 0xEF, 0x1F, 0x9E, 0x79, 0xFC, 0xF3, 0xCF, 0xE7,
  0x9E, 0xFF, 0x78, 0xF7, 0x7B, 0xC7, 0xBB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFC,
  0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC1, 0xE3,
  0xE0, 0x78, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1F,
  0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x02, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x81, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xFE, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x3F,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x3E, 0x03,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xD0, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 13, 9, 14, 3, -25 },
  { 48, 18, 25, 17, 0, -25 },
  { 105, 16, 29, 15, 0, -27 },
  { 163, 22, 25, 25, 2, -25 },
  { 232, 18, 25, 18, 0, -25 },
  { 289, 6, 9, 9, 3, -25 },
  { 296, 12, 31, 9, 0, -25 },
  { 343, 12, 31, 10, -3, -25 },
  { 390, 13, 15, 14, 3, -27 },
  { 415, 15, 17, 16, 1, -21 },
  { 447, 8, 10, 8, -2, -5 },
  { 457, 10, 5, 10, 0, -12 },
  { 464, 5, 5, 8, 0, -5 },
  { 468, 18, 25, 13, -2, -25 },
  { 525, 14, 25, 15, 1, -25 },
  { 569, 12, 25, 15, 3, -25 },
  { 607, 16, 25, 15, -1, -25 },
  { 657, 16, 25, 15, 0, -25 },
  { 707, 16, 25, 15, 0, -25 },
  { 757, 16, 25, 15, 0, -25 },
  { 807, 15, 25, 15, 1, -25 },
  { 854, 16, 25, 15, 1, -25 },
  { 904, 16, 25, 15, 0, -25 },
  { 954, 15, 25, 15, 0, -25 },
  { 1001, 8, 19, 8, 0, -19 },
  { 1020, 10, 24, 8, -2, -19 },
  { 1050, 15, 17, 16, 1, -21 },
  { 1082, 15, 11, 16, 1, -18 },
  { 1103, 15, 17, 16, 1, -21 },
  { 1135, 12, 25, 12, 1, -25 },
  { 1173, 22, 28, 23, 1, -25 },
  { 1250, 16, 25, 16, -2, -25 },
  { 1300, 17, 25, 17, 0, -25 },
  { 1354, 17, 25, 15, 1, -25 },
  { 1408, 18, 25, 18, 0, -25 },
  { 1465, 16, 25, 14, 0, -25 },
  { 1515, 16, 25, 13, 0, -25 },
  { 1565, 18, 25, 18, 1, -25 },
  { 1622, 20, 25, 19, 0, -25 },
  { 1685, 16, 25, 11, -2, -25 },
  { 1735, 15, 32, 9, -5, -25 },
  { 1795, 19, 25, 16, 0, -25 },
  { 1855, 11, 25, 14, 0, -25 },
  { 1890, 25, 25, 24, 0, -25 },
  { 1969, 21, 25, 20, 0, -25 },
  { 2035, 18, 25, 19, 1, -25 },
  { 2092, 17, 25, 16, 0, -25 },
  { 2146, 18, 31, 19, 1, -25 },
  { 2216, 17, 25, 16, 0, -25 },
  { 2270, 17, 25, 14, -1, -25 },
  { 2324, 15, 25, 14, 2, -25 },
  { 2371, 18, 25, 18, 1, -25 },
  { 2428, 16, 25, 16, 3, -25 },
  { 2478, 26, 25, 25, 2, -25 },
  { 2560, 20, 25, 15, -2, -25 },
  { 2623, 15, 25, 15, 3, -25 },
  { 2670, 17, 25, 14, -1, -25 },
  { 2724, 14, 31, 10, -1, -25 },
  { 2779, 8, 25, 13, 3, -25 },
  { 2804, 14, 31, 10, -3, -25 },
  { 2859, 15, 15, 15, 0, -25 },
  { 2888, 12, 2, 11, -3, 3 },
  { 2891, 7, 6, 10, 5, -27 },
  { 2897, 15, 19, 16, 1, -19 },
  { 2933, 16, 27, 16, 0, -27 },
  { 2987, 13, 19, 13, 1, -19 },
  { 3018, 17, 27, 16, 1, -27 },
  { 3076, 13, 19, 15, 1, -19 },
  { 3107, 18, 35, 10, -4, -27 },
  { 3186, 17, 27, 16, -1, -19 },
  { 3244, 15, 27, 16, 0, -27 },
  { 3295, 10, 27, 8, 0, -27 },
  { 3329, 14, 35, 8, -4, -27 },
  { 3391, 17, 27, 15, 0, -27 },
  { 3449, 10, 27, 8, 0, -27 },
  { 3483, 23, 19, 23, 0, -19 },
  { 3538, 15, 19, 16, 0, -19 },
  { 3574, 14, 20, 16, 1, -20 },
  { 3609, 18, 27, 16, -2, -19 },
  { 3670, 15, 27, 16, 1, -19 },
  { 3721, 13, 19, 11, 0, -19 },
  { 3752, 13, 19, 13, 0, -19 },
  { 3783, 10, 23, 10, 1, -23 },
  { 3812, 15, 19, 16, 1, -19 },
  { 3848, 14, 19, 14, 2, -19 },
  { 3882, 21, 19, 21, 2, -19 },
  { 3932, 18, 19, 14, -2, -19 },
  { 3975, 19, 27, 14, -3, -19 },
  { 4040, 14, 19, 12, -1, -19 },
  { 4074, 14, 31, 12, 0, -25 },
  { 4129, 4, 35, 13, 4, -27 },
  { 4147, 13, 31, 12, -2, -25 },
  { 4198, 15, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC35PT7B_H_
