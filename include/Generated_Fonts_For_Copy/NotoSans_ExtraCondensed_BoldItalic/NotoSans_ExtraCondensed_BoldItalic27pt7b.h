#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0xF7, 0xFB, 0xF9, 0xDC,
  0xEE, 0x77, 0x33, 0x38, 0x03, 0x98, 0x0C, 0xE0, 0x73, 0x01, 0xCC, 0x06,
  0x70, 0xFF, 0xF3, 0xFF, 0x83, 0x38, 0x0C, 0xE0, 0x73, 0x01, 0x9C, 0x3F,
  0xFC, 0xFF, 0xF0, 0xC6, 0x03, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x0E,
  0x60, 0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x0F, 0xF1, 0xFE, 0x1D,
  0x23, 0xD0, 0x3F, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x5C, 0x05,
  0xE8, 0x5C, 0xE7, 0xCF, 0xFC, 0xFF, 0x83, 0xE0, 0x08, 0x00, 0x80, 0x18,
  0x00, 0x04, 0x00, 0x0F, 0x07, 0x0F, 0xC3, 0x06, 0x63, 0x87, 0x31, 0x83,
  0x39, 0xC1, 0x9C, 0xC1, 0xCE, 0xE0, 0xE6, 0x67, 0x77, 0x77, 0xDF, 0x77,
  0xEF, 0xB3, 0x33, 0x3B, 0x98, 0x19, 0x8C, 0x1C, 0xCE, 0x0C, 0x67, 0x0E,
  0x33, 0x06, 0x1B, 0x87, 0x0F, 0x87, 0x07, 0x80, 0x00, 0x80, 0x1F, 0x80,
  0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x7B, 0x81, 0xEE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3C, 0x01, 0xF3, 0xCF, 0xEE, 0x77, 0xBB, 0xCF, 0xCE, 0x3F, 0x38, 0x78,
  0xE3, 0xE3, 0xFF, 0x8F, 0xFF, 0x1F, 0xBC, 0x7F, 0xFE, 0xEE, 0xC0, 0x03,
  0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81,
  0xC0, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0x83,
  0x81, 0xC1, 0xC1, 0xE0, 0x0C, 0x03, 0x84, 0xE1, 0xB9, 0xFF, 0xDF, 0xF1,
  0xFC, 0xF8, 0x7F, 0x1D, 0xE2, 0x30, 0x08, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0xE7, 0x9C, 0x73, 0xCE, 0x30, 0x7E, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x02, 0x01, 0xF8, 0x7F, 0x0F,
  0xF3, 0x9E, 0xF3, 0xDE, 0x7B, 0x8F, 0xF1, 0xDE, 0x3B, 0x87, 0x71, 0xEE,
  0x3D, 0xC7, 0x38, 0xE7, 0x3C, 0xE7, 0x1F, 0xE3, 0xF8, 0x3E, 0x00, 0x0F,
  0x1F, 0x3F, 0x7E, 0xFE, 0xEE, 0x5E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x00, 0x80, 0x3F, 0x83, 0xFC, 0x3F,
  0xF0, 0xC7, 0x84, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFE, 0x3F,
  0xF1, 0xFF, 0x80, 0x01, 0x00, 0xFE, 0x1F, 0xF1, 0xFF, 0x10, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x87, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0D, 0xE1, 0xDC, 0x19, 0xC3, 0x9C,
  0x73, 0xC6, 0x38, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC8, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0xD0, 0x3E, 0x0F, 0xE1,
  0xF6, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x20, 0x77, 0x8F, 0xFC, 0xFB, 0xCF,
  0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0x38, 0xE7, 0x8F, 0xF0, 0xFF, 0x07,
  0xE0, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0x00, 0xFE, 0x1F, 0xF1, 0xEF,
  0x1C, 0x73, 0xC7, 0x3C, 0xF1, 0xDE, 0x1F, 0xC0, 0xF8, 0x1F, 0x83, 0xFC,
  0x7B, 0xCF, 0x1C, 0xF1, 0xCE, 0x1C, 0xF1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0,
  0x01, 0x00, 0xFE, 0x1F, 0xE1, 0xFE, 0x3C, 0xF3, 0x8F, 0x38, 0xF3, 0x8F,
  0x78, 0xE7, 0x9E, 0x3F, 0xE3, 0xFE, 0x3D, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0x1C, 0x73, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x0E, 0x0F, 0x1E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0,
  0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x3C, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x78, 0x3F, 0x3F, 0x9F, 0xC3, 0xE0, 0x70,
  0x08, 0x00, 0x04, 0x1F, 0x9F, 0xE6, 0xF4, 0x38, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x00, 0x00, 0x60, 0x78, 0x38, 0x1C,
  0x00, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x0E, 0x07, 0x1C, 0x03, 0x38,
  0x03, 0x31, 0xFB, 0x73, 0xF3, 0x67, 0x33, 0x66, 0x73, 0xEE, 0x73, 0xCE,
  0x63, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xEC, 0xCF, 0xFC, 0xC7, 0x38, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x60, 0x7F, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38,
  0x79, 0xC3, 0x8E, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0xF0, 0xE7, 0x07, 0x78,
  0x7B, 0xC3, 0xFC, 0x1E, 0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xC7,
  0x8E, 0x3C, 0x71, 0xC7, 0xBE, 0x3F, 0xC1, 0xFE, 0x0E, 0x78, 0xF1, 0xC7,
  0x8F, 0x38, 0x79, 0xC3, 0x8E, 0x3C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x00,
  0x80, 0x3F, 0xC3, 0xFC, 0x3F, 0xE3, 0xE2, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x87, 0x9E, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x38,
  0xF0, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x1F, 0x1C, 0xF8,
  0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x1F, 0xE1, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3F,
  0xC3, 0xFC, 0x3F, 0x87, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1E,
  0x08, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC7, 0xEF, 0x1F, 0x3C,
  0xFC, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF8, 0xE1, 0xFF, 0x87,
  0xFE, 0x0F, 0xF0, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0x78, 0xF0, 0xE1, 0xE1,
  0xC3, 0x87, 0x87, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xF1, 0xE1,
  0xC3, 0xC3, 0x80, 0x0F, 0xF0, 0xFE, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x0B, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x00, 0x0E, 0x1E,
  0x1C, 0x78, 0x79, 0xE0, 0xF3, 0x81, 0xCF, 0x03, 0xBC, 0x07, 0x70, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x78,
  0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0x87, 0x80, 0x0F, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xC0, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0x81, 0xF0, 0xF8,
  0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F,
  0x8F, 0xC3, 0xF9, 0xDC, 0x3B, 0x9F, 0xC3, 0xB9, 0xBC, 0x3B, 0xBB, 0x83,
  0xBB, 0xB8, 0x7B, 0xF3, 0x87, 0x3F, 0x78, 0x73, 0xE7, 0x87, 0x3E, 0x70,
  0xF3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x8F, 0x00, 0x0F, 0x07, 0x0F, 0x0F,
  0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x8E, 0x1F, 0x8E, 0x1F, 0x9E, 0x3B, 0x9C,
  0x3B, 0x9C, 0x39, 0xDC, 0x39, 0xDC, 0x39, 0xFC, 0x79, 0xF8, 0x71, 0xF8,
  0x71, 0xF8, 0x70, 0xF8, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xF0, 0x00, 0xC0,
  0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3C, 0x78, 0xF0, 0xE7, 0x83, 0xDE, 0x0F,
  0x78, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F,
  0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xC7, 0xFE, 0x3C, 0x71, 0xE3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x3C, 0xF1,
  0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3C,
  0x78, 0xF0, 0xE7, 0x83, 0xDE, 0x0E, 0x78, 0x3B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0xC7,
  0x9E, 0x3D, 0xF1, 0xFF, 0x0F, 0xF0, 0x77, 0x07, 0xB8, 0x39, 0xE1, 0xCF,
  0x0E, 0x38, 0xF1, 0xC7, 0x8F, 0x38, 0x78, 0x00, 0xC0, 0x1F, 0xC3, 0xFE,
  0x1F, 0xE1, 0xF1, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x63, 0xC3, 0xFE,
  0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x70, 0xF3, 0xC3,
  0x8F, 0x0E, 0x3C, 0x78, 0xE1, 0xE7, 0x87, 0x1E, 0x1C, 0x78, 0xF1, 0xC3,
  0xC7, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xFF,
  0xC1, 0xFE, 0x03, 0xF0, 0x00, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xC7,
  0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC7, 0x87, 0x78, 0xF1, 0xEF, 0x3E, 0x39,
  0xC7, 0xC7, 0x38, 0xF9, 0xE7, 0x3F, 0x38, 0xE7, 0xEF, 0x1C, 0xDD, 0xC3,
  0xBB, 0xB8, 0x77, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x0F,
  0x07, 0x9E, 0x07, 0x9C, 0x07, 0xBC, 0x03, 0xB8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF7, 0x1E, 0x71, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0xF0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0,
  0x07, 0xE0, 0xF8, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xF8, 0x3F, 0x00, 0xE7, 0x39, 0xCE, 0x71,
  0xCE, 0x73, 0x9C, 0xE7, 0x3C, 0xE7, 0x39, 0xCE, 0x07, 0xE0, 0xF8, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC1, 0xF8, 0x3F, 0x00, 0x01, 0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xC1,
  0xDC, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0xE0, 0x70, 0x7F, 0xFF, 0xE0,
  0xF7, 0x9C, 0x73, 0x80, 0x07, 0x38, 0xFF, 0x87, 0xFC, 0x79, 0xE3, 0x8F,
  0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x71, 0xE3, 0x8F, 0x3C, 0x79, 0xE7, 0x87,
  0xFC, 0x3E, 0xE0, 0xE7, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1D, 0xE1, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x38,
  0xF7, 0x8F, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0xFF, 0xCF, 0xF8, 0xEF,
  0x00, 0x0F, 0x87, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x88, 0xFE, 0x3F, 0x87, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x77, 0x87, 0xFC, 0x1F, 0xF0,
  0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78,
  0xF1, 0xC3, 0xC7, 0x07, 0xFC, 0x1F, 0xF0, 0x3D, 0xC0, 0x0F, 0x07, 0xF3,
  0xFD, 0xE7, 0x71, 0xFC, 0xFF, 0xFB, 0xFC, 0xFC, 0x38, 0x0E, 0x03, 0x80,
  0xF3, 0x3F, 0xC7, 0xE0, 0x00, 0x30, 0x03, 0xF0, 0x1F, 0x80, 0x7A, 0x01,
  0xC0, 0x0F, 0x00, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0x9C, 0x1F, 0xE0, 0xFF, 0x87, 0x9E, 0x1C,
  0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E,
  0x78, 0x3F, 0xE0, 0xFB, 0x83, 0xFE, 0x00, 0x70, 0x01, 0xC2, 0x0F, 0x0E,
  0x78, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1D, 0xE1, 0xFE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x38,
  0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCF, 0x3C, 0xE3,
  0xC0, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x3C, 0x78, 0xE1, 0xC3,
  0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x00, 0x00, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x71, 0xE3, 0x9E, 0x3C, 0xE1, 0xCE, 0x0E, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x73, 0x83, 0x9C, 0x3C,
  0xE1, 0xC7, 0x8E, 0x3C, 0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0xF0, 0xE0, 0x1D, 0xE7, 0x06, 0xFB, 0xE3, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C,
  0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x39, 0xE3, 0x8E, 0x71, 0xE7, 0x9C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0xCF, 0x38, 0xE3, 0xCE, 0x38, 0xE0,
  0x19, 0xC1, 0xBE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x8E,
  0x78, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCE, 0x3C, 0xE3, 0xC0, 0x0F,
  0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE,
  0x3F, 0x9E, 0xFF, 0xBF, 0xC7, 0xE0, 0x07, 0x78, 0x1B, 0xE0, 0xFF, 0xC3,
  0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE1,
  0xC7, 0x87, 0x1C, 0x3F, 0xF0, 0xEF, 0x83, 0xBC, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x38, 0x7F, 0x87, 0xFC,
  0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x3C,
  0x71, 0xE3, 0x87, 0xFC, 0x3E, 0xE0, 0xFF, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x1D, 0xC7, 0xF3, 0xF8, 0xFE, 0x3C,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E,
  0x00, 0x0F, 0x87, 0xF3, 0xF8, 0xE2, 0x78, 0x0F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xC0, 0x72, 0x1C, 0xFF, 0x3F, 0x8F, 0xC0, 0x0C, 0x1C, 0x1C, 0x3F,
  0x7F, 0xFE, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xF8,
  0xF8, 0x78, 0x38, 0xE7, 0x1D, 0xE3, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0x77,
  0x8E, 0xE3, 0xDC, 0x73, 0x8E, 0x73, 0xCF, 0xF9, 0xFF, 0x3E, 0xC0, 0xE1,
  0xF8, 0xFE, 0x3B, 0x9E, 0xE7, 0x39, 0xCE, 0xE3, 0xB8, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x71, 0xE3, 0xB9, 0xF3, 0x9C, 0xF9,
  0xCE, 0x7D, 0xE7, 0x7C, 0xE3, 0xBE, 0x71, 0xDB, 0x70, 0xFD, 0xB8, 0x6C,
  0xDC, 0x36, 0x7C, 0x3F, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xC7, 0x80, 0x1C, 0x78, 0xF3, 0x87, 0xBC, 0x1D, 0xC0, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x07, 0xBC, 0x39,
  0xE3, 0xC7, 0x00, 0x0E, 0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x70,
  0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x0B, 0xC0,
  0x3E, 0x00, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x81, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0xF9, 0xFE, 0x3F,
  0xC0, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC1, 0xF0, 0x38, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x3F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x80,
  0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x00, 0x38, 0x3F, 0xC7, 0xFF, 0xE7, 0xF8, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 14, 19, 13, 0, -19 },
  { 62, 12, 23, 11, 0, -21 },
  { 97, 17, 20, 19, 1, -20 },
  { 140, 14, 20, 14, 0, -20 },
  { 175, 4, 7, 7, 3, -19 },
  { 179, 9, 23, 7, 0, -19 },
  { 205, 9, 24, 7, -2, -20 },
  { 232, 10, 12, 11, 2, -21 },
  { 247, 11, 13, 13, 1, -16 },
  { 265, 6, 8, 6, -1, -4 },
  { 271, 7, 3, 8, 0, -9 },
  { 274, 4, 4, 6, 0, -4 },
  { 276, 13, 19, 10, -1, -19 },
  { 307, 11, 20, 11, 1, -20 },
  { 335, 8, 19, 12, 3, -19 },
  { 354, 13, 20, 11, -1, -20 },
  { 387, 12, 20, 11, 0, -20 },
  { 417, 12, 19, 12, 0, -19 },
  { 446, 12, 19, 11, 0, -19 },
  { 475, 12, 20, 11, 1, -20 },
  { 505, 12, 19, 11, 1, -19 },
  { 534, 12, 20, 11, 0, -20 },
  { 564, 12, 20, 11, 0, -20 },
  { 594, 6, 15, 7, 0, -15 },
  { 606, 8, 19, 7, -1, -15 },
  { 625, 11, 13, 13, 1, -16 },
  { 643, 11, 9, 13, 1, -14 },
  { 656, 11, 13, 13, 1, -16 },
  { 674, 9, 20, 9, 1, -20 },
  { 697, 16, 22, 18, 1, -20 },
  { 741, 13, 19, 13, -2, -19 },
  { 772, 13, 19, 13, 0, -19 },
  { 803, 13, 20, 12, 1, -20 },
  { 836, 14, 19, 14, 0, -19 },
  { 870, 12, 19, 11, 0, -19 },
  { 899, 12, 19, 10, 0, -19 },
  { 928, 14, 20, 14, 1, -20 },
  { 963, 15, 19, 14, 0, -19 },
  { 999, 12, 19, 9, -1, -19 },
  { 1028, 12, 25, 7, -4, -19 },
  { 1066, 15, 19, 12, 0, -19 },
  { 1102, 9, 19, 10, 0, -19 },
  { 1124, 20, 19, 19, 0, -19 },
  { 1172, 16, 19, 15, 0, -19 },
  { 1210, 14, 20, 15, 1, -20 },
  { 1245, 13, 19, 12, 0, -19 },
  { 1276, 14, 25, 15, 1, -20 },
  { 1320, 13, 19, 13, 0, -19 },
  { 1351, 13, 20, 11, -1, -20 },
  { 1384, 11, 19, 11, 2, -19 },
  { 1411, 14, 19, 14, 1, -19 },
  { 1445, 13, 19, 13, 2, -19 },
  { 1476, 19, 19, 19, 2, -19 },
  { 1522, 16, 19, 12, -2, -19 },
  { 1560, 12, 19, 11, 2, -19 },
  { 1589, 13, 19, 11, -1, -19 },
  { 1620, 11, 23, 8, -1, -19 },
  { 1652, 5, 19, 10, 3, -19 },
  { 1664, 11, 23, 8, -2, -19 },
  { 1696, 12, 11, 12, 0, -19 },
  { 1713, 10, 2, 9, -3, 2 },
  { 1716, 5, 5, 8, 4, -21 },
  { 1720, 13, 15, 12, 0, -15 },
  { 1745, 12, 21, 12, 0, -21 },
  { 1777, 10, 15, 10, 1, -15 },
  { 1796, 14, 21, 12, 0, -21 },
  { 1833, 10, 15, 11, 1, -15 },
  { 1852, 14, 27, 8, -3, -21 },
  { 1900, 14, 21, 12, -1, -15 },
  { 1937, 12, 21, 12, 0, -21 },
  { 1969, 7, 21, 6, 0, -21 },
  { 1988, 10, 27, 6, -3, -21 },
  { 2022, 13, 21, 11, 0, -21 },
  { 2057, 8, 21, 6, 0, -21 },
  { 2078, 18, 15, 18, 0, -15 },
  { 2112, 12, 15, 12, 0, -15 },
  { 2135, 10, 15, 12, 1, -15 },
  { 2154, 14, 21, 12, -2, -15 },
  { 2191, 13, 21, 12, 0, -15 },
  { 2226, 10, 15, 9, 0, -15 },
  { 2245, 10, 15, 10, 0, -15 },
  { 2264, 8, 18, 8, 1, -18 },
  { 2282, 11, 15, 12, 1, -15 },
  { 2303, 10, 15, 11, 2, -15 },
  { 2322, 17, 15, 17, 1, -15 },
  { 2354, 13, 15, 11, -1, -15 },
  { 2379, 14, 21, 11, -2, -15 },
  { 2416, 11, 15, 9, -1, -15 },
  { 2437, 11, 23, 9, 0, -19 },
  { 2469, 3, 27, 10, 3, -21 },
  { 2480, 11, 23, 9, -2, -19 },
  { 2512, 11, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC27PT7B_H_
