#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x00, 0x7C, 0xFB, 0xE7, 0xDF, 0x3E, 0xF1, 0xE7, 0x8F,
  0x7C, 0xFB, 0xE7, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x00, 0x00, 0x78, 0xE0,
  0x07, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C,
  0x01, 0xE3, 0x80, 0x1C, 0x78, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0x79, 0xE0, 0x07, 0x1E, 0x00, 0xF1,
  0xC0, 0x0F, 0x1C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1C,
  0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07,
  0x8E, 0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xB7, 0x03, 0xC8, 0x00, 0xF2, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x02, 0xF8, 0x01, 0xBE, 0x10, 0x6F, 0x84, 0x1B, 0xE1, 0xC5,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x3C, 0x0F, 0xC0,
  0x78, 0x1F, 0xE0, 0x70, 0x3D, 0xE0, 0xF0, 0x38, 0xE1, 0xE0, 0x78, 0xE1,
  0xE0, 0x71, 0xE3, 0xC0, 0x71, 0xE3, 0xC0, 0xF1, 0xE7, 0x80, 0xF1, 0xE7,
  0x80, 0xF1, 0xCF, 0x00, 0xF3, 0xCE, 0x3E, 0xF3, 0xDE, 0x7F, 0xF7, 0x9C,
  0xFF, 0xFF, 0x3D, 0xEF, 0x7F, 0x39, 0xE7, 0x3C, 0x79, 0xC7, 0x00, 0xF3,
  0xC7, 0x00, 0xF3, 0x87, 0x01, 0xE3, 0x8F, 0x01, 0xE7, 0x8F, 0x03, 0xC7,
  0x8F, 0x03, 0x87, 0x8E, 0x07, 0x87, 0x9E, 0x07, 0x07, 0x9C, 0x0F, 0x03,
  0xFC, 0x0E, 0x03, 0xF8, 0x1E, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF1, 0xF1, 0xFF, 0x1E, 0x3E,
  0xFB, 0xE7, 0xCF, 0xBC, 0x7C, 0xFF, 0xCF, 0x87, 0xF8, 0xF8, 0x7F, 0x8F,
  0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xEF, 0x83, 0xF8, 0xFC, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0xBE, 0xF3,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x02, 0x1E,
  0x07, 0x3C, 0x0F, 0xFB, 0xBF, 0xFF, 0x7F, 0xFE, 0x0F, 0xFE, 0x1F, 0x80,
  0x7F, 0x81, 0xFF, 0x07, 0xDF, 0x07, 0x9F, 0x06, 0x3C, 0x08, 0x20, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x7F,
  0xEF, 0xF9, 0xFF, 0x3F, 0xEF, 0xFC, 0x39, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xBF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F,
  0xE3, 0xFE, 0x7F, 0xEF, 0xBE, 0xF3, 0xC6, 0x7C, 0x27, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0x07, 0xCF, 0xC1, 0xC1,
  0xF0, 0x20, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0x8F, 0xC0, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x88, 0x07, 0xE3, 0x83, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xEF, 0x80, 0x7B, 0xC0, 0x1D, 0xF0, 0x0E, 0x7C, 0x07, 0x9F, 0x01, 0xC7,
  0x80, 0xE3, 0xE0, 0x78, 0xF8, 0x1C, 0x3E, 0x0F, 0x0F, 0x87, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xC8, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xD8, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE2, 0x03, 0xF1, 0xC3, 0xF0, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7E, 0x10, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x0F, 0xBF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFD, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F,
  0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1, 0xFB, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7C, 0x3E,
  0x3F, 0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF8, 0xFC, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3,
  0xF3, 0xE3, 0xF1, 0xF9, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xDF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE1,
  0x07, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0x07, 0xC3, 0xE3, 0xF1, 0xF8, 0x78, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC0,
  0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0x18,
  0x7C, 0x41, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x0E, 0x0F, 0x87, 0x1E, 0x3F, 0xE7, 0x1C, 0x7F, 0xC7, 0x3C,
  0x71, 0xC7, 0x38, 0xF3, 0xC7, 0x79, 0xE3, 0xC7, 0x71, 0xE3, 0x8F, 0x71,
  0xC3, 0x8E, 0x73, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xE3, 0xC7, 0x1E, 0xE3,
  0x8F, 0x1C, 0xE3, 0xCF, 0x3C, 0xE3, 0xDF, 0x78, 0xE3, 0xFF, 0xF0, 0xE1,
  0xF3, 0xE0, 0xE0, 0x40, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x07, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0x9F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3,
  0xE3, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x38,
  0x1F, 0x81, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF1, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x7E, 0x0F, 0xC3,
  0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF1, 0xF8,
  0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x3F,
  0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x1F, 0x87,
  0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x9E, 0x07, 0xF0, 0x10, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE3, 0xFE, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C,
  0x3F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xE3, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x81,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x9F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x0F, 0x07, 0xE0, 0x7C,
  0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0xC0, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0x78, 0x7F, 0xC1, 0xF7,
  0x8F, 0xFC, 0x1F, 0x78, 0xF7, 0xC1, 0xF7, 0x8F, 0x7C, 0x1E, 0x79, 0xE7,
  0x81, 0xE7, 0x9E, 0xF8, 0x3E, 0x7B, 0xCF, 0x83, 0xE7, 0xBC, 0xF8, 0x3E,
  0x7F, 0xCF, 0x03, 0xC7, 0xF9, 0xF0, 0x7C, 0x7F, 0x9F, 0x07, 0xC7, 0xF1,
  0xF0, 0x7C, 0x7F, 0x1F, 0x07, 0x87, 0xE1, 0xE0, 0x78, 0x7E, 0x3E, 0x0F,
  0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0xF8, 0x3F, 0x81, 0xE0, 0x7F, 0x03,
  0xC0, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xFC, 0x3E, 0x0F, 0xF8, 0x78,
  0x1E, 0xF0, 0xF0, 0x3D, 0xE3, 0xE0, 0xFB, 0xC7, 0xC1, 0xF7, 0x8F, 0x83,
  0xEF, 0x9E, 0x07, 0x9F, 0x7C, 0x0F, 0x1E, 0xF8, 0x3E, 0x3D, 0xF0, 0x7C,
  0x7B, 0xC0, 0xF8, 0xF7, 0x81, 0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x83,
  0xFC, 0x1F, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC1, 0xF0, 0x3F,
  0x83, 0xE0, 0x7F, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0xFC, 0x3F, 0x1F, 0x83,
  0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F,
  0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC,
  0x3E, 0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE7,
  0xE0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xF0,
  0x1F, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x7C, 0x1F, 0x87, 0xE7, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x07, 0xCF, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3F, 0x1F, 0x1F, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0xF9,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xC1, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x18,
  0x1F, 0x83, 0xEF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x7E, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0xCF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x81, 0xF3, 0xC0, 0xF9,
  0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x0F, 0x1F,
  0x07, 0x8F, 0x83, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x01,
  0xFF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x7C, 0xF8,
  0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x7F, 0x0F, 0x8F, 0x87, 0xF0,
  0xF8, 0xF8, 0x7F, 0x0F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F, 0x0F,
  0x8F, 0xF3, 0xE0, 0xF9, 0xEF, 0x3E, 0x0F, 0x9E, 0xF3, 0xC0, 0xFB, 0xCF,
  0x7C, 0x0F, 0xBC, 0xF7, 0xC0, 0xFB, 0xCF, 0xF8, 0x0F, 0xF8, 0xEF, 0x80,
  0xF7, 0x8E, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0x78, 0x01,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF0, 0xF0,
  0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x1F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xE3,
  0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFE, 0xF9, 0xF9, 0xF3, 0xE3, 0xC3, 0xC0, 0x01, 0x80,
  0x03, 0xF3, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF9, 0xF9, 0xF8, 0xF8,
  0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E,
  0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0xF7, 0x81, 0xF3, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x8C, 0x07, 0xDF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E,
  0x7C, 0x3E, 0x3F, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x7F, 0x07, 0x9F,
  0x00, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFC, 0x23,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x23, 0xF1, 0x8F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0x8F, 0x80, 0xFD, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7C,
  0x7E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF7,
  0x80, 0x7C, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1,
  0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x1F, 0x7C, 0x7C, 0xF7, 0xFB, 0xFF,
  0xE7, 0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x23, 0xFB, 0xC3, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x3C,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x9F, 0x83, 0xE1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07,
  0xCF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0x03, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x8C, 0x07, 0xDF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3,
  0xE0, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x21, 0xF0,
  0xF8, 0x3E, 0x3E, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF,
  0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x0C, 0x04, 0x07, 0xBF,
  0x9F, 0x83, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFC,
  0x7E, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1E, 0x1F, 0x0F, 0x9F,
  0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xC7, 0xC3, 0xC3, 0xE3, 0xC1, 0xE1, 0xF1,
  0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3C, 0x7C, 0x3C, 0x3E,
  0x3C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F, 0x87, 0x8F, 0x87, 0xC3,
  0xC7, 0xC3, 0xC3, 0xE0, 0x00, 0x08, 0x07, 0x9F, 0x83, 0xDF, 0xC1, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F,
  0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3E, 0x3E, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00,
  0x03, 0x00, 0x79, 0xF8, 0x0F, 0x7F, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x7E, 0x1F, 0x0F, 0x83, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7D, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0x80, 0x03, 0xF3, 0xC3, 0xFD, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1,
  0xF1, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x1E, 0x78, 0x3D,
  0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xF3, 0x87, 0xC1,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x81, 0xF1, 0x87, 0xE3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE1, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xEF, 0x07, 0xE7, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x79, 0xF0, 0x79,
  0xF0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1E, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE,
  0x3C, 0xF8, 0xFE, 0x7C, 0xF9, 0xFE, 0x7C, 0xF9, 0xFE, 0x78, 0xF9, 0xDC,
  0xF8, 0xFB, 0xDC, 0xF0, 0xFB, 0xDC, 0xF0, 0xFF, 0x9D, 0xF0, 0xF7, 0xBD,
  0xE0, 0xF7, 0x3D, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x3C, 0xF8, 0x03, 0xEF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE3,
  0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xBF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xBF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x07, 0xF2, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 28, 10, 0, -28 },
  { 40, 13, 10, 15, 4, -28 },
  { 57, 20, 28, 19, 0, -28 },
  { 127, 18, 32, 17, 0, -30 },
  { 199, 24, 28, 27, 2, -28 },
  { 283, 20, 28, 20, 0, -28 },
  { 353, 6, 10, 10, 4, -28 },
  { 361, 13, 34, 11, 1, -28 },
  { 417, 13, 34, 11, -3, -28 },
  { 473, 15, 16, 16, 3, -30 },
  { 503, 15, 19, 18, 2, -23 },
  { 539, 9, 10, 9, -2, -5 },
  { 551, 11, 5, 11, 0, -13 },
  { 558, 6, 6, 9, 0, -6 },
  { 563, 20, 28, 15, -2, -28 },
  { 633, 16, 28, 17, 1, -28 },
  { 689, 12, 28, 17, 4, -28 },
  { 731, 18, 28, 17, -1, -28 },
  { 794, 18, 28, 17, -1, -28 },
  { 857, 18, 28, 17, -1, -28 },
  { 920, 17, 28, 17, 0, -28 },
  { 980, 17, 28, 17, 1, -28 },
  { 1040, 18, 28, 17, 1, -28 },
  { 1103, 17, 28, 17, 0, -28 },
  { 1163, 17, 28, 17, 0, -28 },
  { 1223, 9, 22, 9, 0, -22 },
  { 1248, 11, 27, 9, -2, -22 },
  { 1286, 16, 18, 18, 1, -23 },
  { 1322, 17, 12, 18, 1, -20 },
  { 1348, 16, 18, 18, 2, -23 },
  { 1384, 14, 28, 13, 1, -28 },
  { 1433, 24, 31, 25, 1, -28 },
  { 1526, 18, 28, 18, -2, -28 },
  { 1589, 19, 28, 19, 0, -28 },
  { 1656, 19, 28, 17, 1, -28 },
  { 1723, 20, 28, 20, 0, -28 },
  { 1793, 17, 28, 16, 0, -28 },
  { 1853, 17, 28, 15, 0, -28 },
  { 1913, 21, 28, 21, 1, -28 },
  { 1987, 22, 28, 21, 0, -28 },
  { 2064, 17, 28, 12, -2, -28 },
  { 2124, 17, 36, 10, -6, -28 },
  { 2201, 22, 28, 18, 0, -28 },
  { 2278, 13, 28, 15, 0, -28 },
  { 2324, 28, 28, 27, 0, -28 },
  { 2422, 23, 28, 22, 0, -28 },
  { 2503, 20, 28, 21, 1, -28 },
  { 2573, 19, 28, 18, 0, -28 },
  { 2640, 20, 35, 21, 1, -28 },
  { 2728, 18, 28, 18, 0, -28 },
  { 2791, 19, 28, 16, -1, -28 },
  { 2858, 15, 28, 15, 3, -28 },
  { 2911, 21, 28, 20, 1, -28 },
  { 2985, 17, 28, 18, 4, -28 },
  { 3045, 28, 28, 27, 3, -28 },
  { 3143, 22, 28, 17, -2, -28 },
  { 3220, 17, 28, 17, 3, -28 },
  { 3280, 20, 28, 15, -2, -28 },
  { 3350, 16, 34, 11, -2, -28 },
  { 3418, 8, 28, 15, 4, -28 },
  { 3446, 16, 34, 11, -3, -28 },
  { 3514, 17, 17, 17, 0, -28 },
  { 3551, 13, 3, 13, -4, 3 },
  { 3556, 7, 6, 12, 6, -30 },
  { 3562, 17, 22, 18, 1, -22 },
  { 3609, 17, 30, 18, 0, -30 },
  { 3673, 14, 22, 14, 1, -22 },
  { 3712, 19, 30, 18, 1, -30 },
  { 3784, 15, 22, 16, 1, -22 },
  { 3826, 19, 39, 11, -4, -30 },
  { 3919, 19, 31, 18, -1, -22 },
  { 3993, 17, 30, 18, 0, -30 },
  { 4057, 11, 30, 9, 0, -30 },
  { 4099, 16, 39, 9, -5, -30 },
  { 4177, 19, 30, 17, 0, -30 },
  { 4249, 11, 30, 9, 0, -30 },
  { 4291, 25, 22, 26, 0, -22 },
  { 4360, 17, 22, 18, 0, -22 },
  { 4407, 16, 22, 17, 1, -22 },
  { 4451, 19, 31, 18, -2, -22 },
  { 4525, 17, 31, 18, 1, -22 },
  { 4591, 15, 22, 13, 0, -22 },
  { 4633, 15, 22, 14, 0, -22 },
  { 4675, 12, 26, 11, 1, -26 },
  { 4714, 17, 21, 18, 1, -21 },
  { 4759, 16, 21, 16, 2, -21 },
  { 4801, 24, 21, 24, 2, -21 },
  { 4864, 20, 21, 16, -2, -21 },
  { 4917, 21, 30, 16, -3, -21 },
  { 4996, 16, 21, 13, -2, -21 },
  { 5038, 16, 34, 13, 0, -28 },
  { 5106, 4, 39, 15, 5, -30 },
  { 5126, 15, 34, 13, -2, -28 },
  { 5190, 17, 7, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC39PT7B_H_
