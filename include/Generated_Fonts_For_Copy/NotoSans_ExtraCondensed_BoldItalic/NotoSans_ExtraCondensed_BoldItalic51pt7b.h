#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x01, 0x00, 0x00, 0x3F,
  0x1F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x87, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F,
  0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xD9, 0xE0, 0x3F, 0x30,
  0x80, 0x7E, 0x60, 0x00, 0xFD, 0xC0, 0x01, 0xFB, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x6F, 0xE0, 0x00, 0xDF, 0xC0, 0x01, 0xBF, 0x84, 0x06,
  0x7F, 0x0C, 0x0C, 0xFC, 0x1E, 0x1B, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x07, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xC0, 0x1F, 0x7C, 0x07, 0xC0, 0x3E,
  0x7C, 0x0F, 0x80, 0x3C, 0x3C, 0x0F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0x7C,
  0x7C, 0x1F, 0x00, 0x78, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3C, 0x00, 0xF8,
  0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0xF8, 0x00, 0xF0, 0xF8, 0xF8, 0x00, 0xF0,
  0xF9, 0xF0, 0x00, 0xF0, 0xF9, 0xF1, 0xF8, 0xF1, 0xF3, 0xE3, 0xFC, 0xF1,
  0xF3, 0xE7, 0xFE, 0xFB, 0xE7, 0xCF, 0xFE, 0xFF, 0xE7, 0xCF, 0x9E, 0xFF,
  0xCF, 0x9F, 0x1E, 0x7F, 0x8F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1E, 0x00,
  0x1E, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x3E, 0x00,
  0x7C, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3C, 0x01,
  0xF0, 0x7C, 0x7C, 0x01, 0xF0, 0x7C, 0x7C, 0x03, 0xE0, 0x7C, 0x78, 0x03,
  0xE0, 0x7C, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x07, 0x80, 0x3F, 0xF0, 0x0F,
  0x80, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFC, 0x1F, 0xFC, 0x7F,
  0x0F, 0xFF, 0x1F, 0x87, 0xEF, 0xE7, 0xE3, 0xFB, 0xFB, 0xF0, 0xFC, 0x7E,
  0xFC, 0x7E, 0x1F, 0xFE, 0x1F, 0x87, 0xFF, 0x8F, 0xE0, 0xFF, 0xC3, 0xF0,
  0x3F, 0xF0, 0xFC, 0x0F, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0x83,
  0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE7, 0xF8, 0x1F, 0xF0, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x9F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F,
  0x8F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x02,
  0x0F, 0x80, 0xF1, 0xF0, 0x1F, 0xBC, 0x3B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xFB, 0xF0, 0x7F, 0x3F, 0x07, 0xC7, 0xF0, 0x70, 0x7C, 0x06,
  0x0E, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7F, 0xF8, 0x0C, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC1,
  0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xFE, 0xFC,
  0x7C, 0xFC, 0x79, 0xFC, 0x31, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF8,
  0x7F, 0x00, 0xF0, 0x7F, 0x00, 0xC0, 0x7F, 0x00, 0x80, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xE0, 0xFF, 0x00, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x0F,
  0xF0, 0xC0, 0x1F, 0xE0, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3D,
  0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x79, 0xF8, 0x00, 0xFB, 0xF8, 0x01, 0xF3,
  0xF0, 0x01, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0x87,
  0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x20,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x08, 0x01, 0xFC, 0x18, 0x07, 0xF8, 0x3F, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0xC0, 0x07, 0xEF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0x7F,
  0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF0,
  0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xBF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC,
  0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F,
  0xC7, 0xE0, 0xFF, 0x1F, 0x83, 0xF8, 0x7F, 0x1F, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0x01, 0xF9,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x30, 0x7F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0xFC, 0x20, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC1, 0xFF, 0x1F, 0x0F, 0x83, 0xFF, 0x8F, 0x0F, 0x07, 0xFF, 0x0F,
  0x1F, 0x0F, 0xFF, 0x0F, 0x1E, 0x1F, 0x1F, 0x0F, 0x3E, 0x1E, 0x1F, 0x1F,
  0x3E, 0x3E, 0x1E, 0x1F, 0x3C, 0x3C, 0x1E, 0x1E, 0x3C, 0x7C, 0x3E, 0x1E,
  0x7C, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0x3C, 0x1E, 0x78, 0x78, 0x3C, 0x3C,
  0x78, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x78,
  0xF8, 0xF8, 0xF8, 0x78, 0xF0, 0xF9, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xF0,
  0xF0, 0x7F, 0xBF, 0xE0, 0xF8, 0x7F, 0x3F, 0xC0, 0xF8, 0x3E, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x78, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xBF, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x3F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x38, 0x07, 0xF8, 0x08,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xF0, 0x1F, 0xE0, 0x0C, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xFF, 0x1F, 0xC1, 0xFF, 0xC7, 0xF0, 0x7F, 0xE3, 0xF8, 0x3F, 0xF8,
  0xFE, 0x0F, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x43, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x81, 0xF7, 0xE0, 0x3F, 0x7E, 0x0F, 0xBF, 0x01, 0xFB, 0xF0, 0xFF, 0xF8,
  0x0F, 0xDF, 0x87, 0xDF, 0xC0, 0x7E, 0xFC, 0x7E, 0xFC, 0x03, 0xF7, 0xE3,
  0xE7, 0xE0, 0x3F, 0x3F, 0x3F, 0x3F, 0x01, 0xF9, 0xF9, 0xF3, 0xF8, 0x0F,
  0xCF, 0xDF, 0x9F, 0x80, 0x7E, 0x7E, 0xF8, 0xFC, 0x03, 0xF3, 0xF7, 0xC7,
  0xE0, 0x3F, 0x1F, 0xFE, 0x3F, 0x01, 0xF8, 0xFF, 0xE3, 0xF8, 0x0F, 0xC3,
  0xFF, 0x1F, 0x80, 0x7E, 0x1F, 0xF0, 0xFC, 0x07, 0xF0, 0xFF, 0x87, 0xE0,
  0x3F, 0x07, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x7E,
  0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0x80,
  0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x7F,
  0xF8, 0x3F, 0x01, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x87, 0xF0, 0x1F, 0x3E,
  0x1F, 0x80, 0xFC, 0xF8, 0x7E, 0x03, 0xF3, 0xF1, 0xF8, 0x0F, 0xCF, 0xC7,
  0xE0, 0x3F, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0xFC, 0x07, 0xE1, 0xF3, 0xF0,
  0x1F, 0x87, 0xCF, 0xC0, 0x7E, 0x1F, 0xBF, 0x01, 0xF8, 0x7E, 0xF8, 0x07,
  0xE1, 0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xF0,
  0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x0F,
  0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x7E, 0x01, 0xFE,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xCF, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xF1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8,
  0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x9F,
  0x80, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0x7C, 0x03, 0xFC, 0x0C, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x60, 0x0F, 0xE0, 0x78, 0x1F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x01,
  0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE0, 0x1F, 0x9F, 0xC0,
  0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0, 0x7E,
  0x3F, 0x81, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF,
  0x81, 0xF8, 0x7E, 0x07, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0xE0, 0xFC, 0x1F,
  0x83, 0xFF, 0x0F, 0xE0, 0xFC, 0x1F, 0xF8, 0x7E, 0x07, 0xE0, 0xFF, 0xC3,
  0xF0, 0x3F, 0x0F, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0xF1, 0xF8, 0x0F, 0xC7,
  0xFF, 0x0F, 0xC0, 0x7E, 0x3E, 0xF8, 0xFE, 0x03, 0xF1, 0xF7, 0xC7, 0xE0,
  0x1F, 0x9F, 0x3E, 0x7F, 0x00, 0xFC, 0xF9, 0xF3, 0xF0, 0x07, 0xEF, 0xCF,
  0x9F, 0x80, 0x3F, 0x7C, 0x7D, 0xFC, 0x01, 0xFB, 0xE3, 0xEF, 0xC0, 0x0F,
  0xFF, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF3,
  0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFB, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x87, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xDF, 0x80, 0xFF, 0x3E, 0x01, 0xFC, 0x7C, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x7E, 0x7F, 0x80, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xF9, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07,
  0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xE0, 0xFF, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0x3F, 0xE0, 0x3E, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xE7,
  0x07, 0xF0, 0x20, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x08, 0x3F, 0xC7, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x3F, 0xEF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE7, 0xFC,
  0x0F, 0xE1, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x7F, 0x0F, 0xE7, 0xE3, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x37, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x3F, 0xCF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xCF, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x40, 0x1F, 0xC0, 0x3C, 0x1F, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0xFC, 0x07, 0xEF, 0xF8, 0x1F, 0xBF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFB, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x7E, 0x03, 0xE7, 0xFC, 0xFF, 0x81,
  0xF7, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xCF, 0xF9, 0xFC, 0x3F, 0x87, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0,
  0x7E, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x8F, 0xE0, 0xFC,
  0x1F, 0xC7, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x03,
  0xC3, 0xF0, 0x1F, 0x3F, 0xE0, 0x7C, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0xEF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x07,
  0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7F,
  0x0F, 0xE3, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x3F, 0xC0, 0x0F, 0x9F, 0xF8, 0x03, 0xEF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xEF, 0xFC, 0x01, 0xFB, 0xFE,
  0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x82, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x03, 0xFC,
  0xFC, 0x0F, 0xFD, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF,
  0x87, 0xF0, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x7E,
  0x01, 0xFC, 0xFC, 0x00, 0x43, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x07, 0xE3, 0xE0, 0xFD, 0xFC, 0x1F, 0x3F, 0x03, 0xEF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x87, 0x07,
  0xF0, 0x20, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0x00,
  0xFE, 0x3C, 0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF4, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC4,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x20, 0x00,
  0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83,
  0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE3, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xBE, 0x07,
  0xFC, 0xF8, 0x0F, 0xE3, 0xE0, 0x04, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xDF, 0x80,
  0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F,
  0xC1, 0xFB, 0xF0, 0x7F, 0x83, 0xF7, 0xE0, 0xFF, 0x07, 0xEF, 0xC3, 0xFE,
  0x1F, 0x9F, 0x87, 0xFC, 0x3F, 0x3F, 0x0F, 0xF8, 0xFC, 0x7E, 0x3F, 0xF1,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xF9, 0xF7, 0xCF, 0xC3, 0xF3, 0xEF, 0x9F,
  0x87, 0xE7, 0xDE, 0x3E, 0x0F, 0xDF, 0x7C, 0xFC, 0x1F, 0xBE, 0xF9, 0xF8,
  0x3F, 0x7D, 0xF7, 0xE0, 0x7F, 0xF3, 0xEF, 0xC0, 0xFB, 0xE7, 0xDF, 0x01,
  0xF7, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xE3, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x01, 0xFF, 0xD0, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 37, 13, 0, -36 },
  { 71, 18, 13, 20, 5, -36 },
  { 101, 26, 36, 24, 0, -36 },
  { 218, 23, 42, 22, 0, -39 },
  { 339, 32, 37, 36, 3, -37 },
  { 487, 26, 38, 26, 0, -37 },
  { 611, 9, 13, 12, 5, -36 },
  { 626, 17, 45, 14, 1, -37 },
  { 722, 17, 45, 14, -4, -37 },
  { 818, 19, 21, 21, 4, -39 },
  { 868, 21, 24, 24, 2, -30 },
  { 931, 12, 14, 12, -3, -7 },
  { 952, 13, 6, 15, 1, -17 },
  { 962, 8, 9, 12, 0, -8 },
  { 971, 26, 37, 19, -3, -37 },
  { 1092, 21, 38, 22, 1, -37 },
  { 1192, 16, 36, 22, 5, -36 },
  { 1264, 24, 37, 22, -2, -37 },
  { 1375, 24, 38, 22, -1, -37 },
  { 1489, 24, 37, 22, -1, -37 },
  { 1600, 23, 37, 22, 0, -36 },
  { 1707, 23, 38, 22, 1, -37 },
  { 1817, 24, 36, 22, 1, -36 },
  { 1925, 23, 38, 22, 0, -37 },
  { 2035, 22, 38, 22, 0, -37 },
  { 2140, 12, 29, 12, 0, -28 },
  { 2184, 15, 35, 12, -3, -28 },
  { 2250, 21, 24, 24, 2, -30 },
  { 2313, 21, 16, 24, 2, -26 },
  { 2355, 21, 24, 24, 2, -30 },
  { 2418, 18, 38, 17, 1, -37 },
  { 2504, 32, 41, 33, 1, -37 },
  { 2668, 24, 37, 24, -3, -37 },
  { 2779, 25, 36, 24, 0, -36 },
  { 2892, 24, 38, 22, 2, -37 },
  { 3006, 26, 36, 26, 0, -36 },
  { 3123, 23, 36, 20, 0, -36 },
  { 3227, 23, 36, 20, 0, -36 },
  { 3331, 26, 38, 27, 2, -37 },
  { 3455, 29, 36, 27, 0, -36 },
  { 3586, 22, 36, 16, -2, -36 },
  { 3685, 22, 47, 13, -8, -36 },
  { 3815, 28, 36, 24, 0, -36 },
  { 3941, 17, 36, 20, 0, -36 },
  { 4018, 37, 36, 36, 0, -36 },
  { 4185, 30, 36, 29, 0, -36 },
  { 4320, 25, 38, 28, 2, -37 },
  { 4439, 25, 36, 23, 0, -36 },
  { 4552, 25, 46, 28, 2, -37 },
  { 4696, 24, 36, 24, 0, -36 },
  { 4804, 24, 38, 21, -1, -37 },
  { 4918, 20, 36, 20, 4, -36 },
  { 5008, 26, 37, 26, 2, -36 },
  { 5129, 23, 36, 24, 5, -36 },
  { 5233, 37, 36, 36, 3, -36 },
  { 5400, 29, 36, 22, -3, -36 },
  { 5531, 21, 36, 22, 5, -36 },
  { 5626, 25, 36, 20, -2, -36 },
  { 5739, 20, 45, 14, -2, -37 },
  { 5852, 11, 37, 19, 5, -37 },
  { 5903, 21, 45, 14, -4, -37 },
  { 6022, 22, 21, 22, 0, -36 },
  { 6080, 17, 4, 17, -5, 4 },
  { 6089, 10, 8, 15, 7, -39 },
  { 6099, 23, 29, 24, 1, -28 },
  { 6183, 23, 40, 23, 0, -39 },
  { 6298, 19, 29, 19, 1, -28 },
  { 6367, 25, 40, 24, 1, -39 },
  { 6492, 20, 29, 22, 1, -28 },
  { 6565, 26, 51, 14, -6, -39 },
  { 6731, 25, 40, 24, -1, -28 },
  { 6856, 22, 39, 23, 0, -39 },
  { 6964, 14, 39, 12, 0, -39 },
  { 7033, 20, 51, 12, -6, -39 },
  { 7161, 24, 39, 22, 0, -39 },
  { 7278, 14, 39, 12, 0, -39 },
  { 7347, 33, 28, 34, 0, -28 },
  { 7463, 22, 28, 23, 0, -28 },
  { 7540, 21, 29, 23, 1, -28 },
  { 7617, 26, 40, 23, -3, -28 },
  { 7747, 23, 40, 23, 1, -28 },
  { 7862, 19, 28, 16, 0, -28 },
  { 7929, 19, 29, 18, 0, -28 },
  { 7998, 15, 35, 15, 2, -34 },
  { 8064, 22, 29, 23, 1, -28 },
  { 8144, 20, 28, 20, 3, -28 },
  { 8214, 31, 28, 31, 3, -28 },
  { 8323, 26, 28, 21, -3, -28 },
  { 8414, 27, 40, 21, -4, -28 },
  { 8549, 21, 28, 17, -2, -28 },
  { 8623, 20, 44, 17, 1, -36 },
  { 8733, 6, 51, 19, 6, -39 },
  { 8772, 20, 44, 17, -3, -36 },
  { 8882, 21, 8, 24, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC51PT7B_H_
