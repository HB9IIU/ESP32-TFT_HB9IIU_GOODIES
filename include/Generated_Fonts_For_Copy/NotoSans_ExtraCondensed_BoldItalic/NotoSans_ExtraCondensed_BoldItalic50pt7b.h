#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xDF, 0xCF,
  0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03,
  0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C,
  0x00, 0x7C, 0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x03, 0xC3, 0xC0, 0x03, 0xE1,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0x99, 0xC0, 0x3F,
  0x30, 0x80, 0x7C, 0xC0, 0x01, 0xFD, 0x80, 0x03, 0xFB, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x6F, 0xE0, 0x01, 0x9F, 0x82, 0x03, 0x3F, 0x06,
  0x06, 0x7E, 0x0F, 0x0D, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x1F,
  0x00, 0xFF, 0xE0, 0x3C, 0x03, 0xE7, 0xC0, 0xF8, 0x07, 0xCF, 0x81, 0xE0,
  0x1F, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x0F, 0x00, 0x78, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0xF8, 0x03, 0xE1, 0xE1, 0xF0, 0x07, 0xC3, 0xC7, 0xC0, 0x0F,
  0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x3E, 0x00, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0xF9, 0xF1, 0xFC, 0xF1, 0xF3, 0xC7, 0xFD, 0xF7, 0xCF, 0x9F, 0xFB, 0xFF,
  0x9E, 0x7E, 0xFF, 0xFE, 0x7C, 0xF9, 0xF7, 0xF9, 0xF3, 0xE3, 0xE7, 0xE3,
  0xE7, 0xC7, 0xC0, 0x0F, 0x8F, 0x0F, 0x80, 0x1F, 0x3E, 0x1F, 0x00, 0x7C,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x78, 0x03, 0xE1, 0xE1, 0xF0, 0x07, 0x83,
  0xC3, 0xE0, 0x1F, 0x07, 0x87, 0xC0, 0x3C, 0x0F, 0x1F, 0x00, 0xF8, 0x1E,
  0x3E, 0x01, 0xE0, 0x3C, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x7F, 0xE1, 0xF8, 0x3F,
  0xFC, 0x7E, 0x1F, 0xFF, 0x3F, 0x0F, 0xEF, 0xCF, 0xC3, 0xF3, 0xFB, 0xF1,
  0xF8, 0x7F, 0xF8, 0x7E, 0x1F, 0xFE, 0x3F, 0x07, 0xFF, 0x0F, 0xC0, 0xFF,
  0xC3, 0xF0, 0x3F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x0F, 0xE1,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0x9F, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x20, 0xFC, 0x03, 0x1F,
  0x80, 0xFB, 0xE0, 0x9F, 0xFC, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x1F, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFB, 0xF0, 0x3E, 0x3F, 0x03, 0x87, 0xE0, 0x30, 0xF0, 0x04, 0x0C,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x80, 0x08, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F,
  0x0F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3,
  0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0x07,
  0xF3, 0xF8, 0x3F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F,
  0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xFB, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC, 0xFE,
  0xFC, 0xFC, 0xFC, 0x79, 0xF8, 0x31, 0xF8, 0x21, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01,
  0xF0, 0x7F, 0x00, 0xE0, 0x7F, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x30,
  0x3F, 0x80, 0x40, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x18, 0x03, 0xFC, 0x3E, 0x1F, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xE0,
  0x01, 0xEF, 0xC0, 0x07, 0xBF, 0x80, 0x1F, 0x7E, 0x00, 0x3C, 0xFC, 0x00,
  0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0x8F, 0xC0, 0x1E, 0x1F, 0x80, 0x7C,
  0x3F, 0x00, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x20, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0x1F, 0xC3, 0x00, 0xFF, 0x0F, 0x8F,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x60, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x03, 0xFB, 0xFC, 0x0F,
  0xDF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFE, 0xFE, 0x1F, 0xE3,
  0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0xDF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE, 0x3F, 0x07, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x1F, 0x83, 0xF8, 0x7F,
  0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x87,
  0xF8, 0x7F, 0x3F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7E, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x0C, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x07, 0xC0, 0x10, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC3, 0xC7, 0xF0, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x3E, 0x0F, 0xFC, 0x78, 0x78, 0x3F,
  0xF8, 0xF1, 0xF0, 0xFF, 0xF1, 0xE3, 0xC3, 0xE3, 0xE3, 0xC7, 0x87, 0x87,
  0x87, 0x9F, 0x1F, 0x0F, 0x0F, 0x3C, 0x3C, 0x3E, 0x1E, 0x78, 0xF8, 0x7C,
  0x7D, 0xF1, 0xE0, 0xF0, 0xF3, 0xC3, 0xC1, 0xE1, 0xE7, 0x8F, 0x87, 0xC3,
  0xCF, 0x1F, 0x0F, 0x87, 0xBE, 0x3E, 0x1E, 0x1E, 0x7C, 0x78, 0x7C, 0x3C,
  0xF8, 0xF0, 0xF8, 0xF1, 0xE1, 0xF3, 0xF1, 0xE3, 0xC3, 0xFF, 0xFF, 0x87,
  0x87, 0xFD, 0xFE, 0x0F, 0x07, 0xF3, 0xF8, 0x1E, 0x07, 0xC3, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x01, 0xF8, 0x03, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFE, 0x03, 0xF1, 0xFC,
  0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83,
  0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x06, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x20,
  0x3F, 0xF7, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE3, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x60, 0x3F, 0xE0, 0x08, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xFE, 0x1F, 0xC3, 0xFF, 0x8F, 0xE0, 0xFF, 0xE3, 0xF8, 0x3F,
  0xF8, 0xFE, 0x0F, 0xFC, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x67, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01,
  0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E,
  0xFC, 0x0F, 0xDF, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x7D, 0xF8, 0x0F, 0xDF,
  0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0xF9, 0xF8, 0x0F, 0xDF, 0x0F, 0xBF, 0x81,
  0xF9, 0xF1, 0xF3, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F, 0x01, 0xF9, 0xF3, 0xF3,
  0xF0, 0x1F, 0x9F, 0x3E, 0x3F, 0x01, 0xF1, 0xF7, 0xE7, 0xE0, 0x3F, 0x1F,
  0x7C, 0x7E, 0x03, 0xF1, 0xFF, 0xC7, 0xE0, 0x3F, 0x1F, 0xF8, 0x7E, 0x03,
  0xF1, 0xFF, 0x8F, 0xE0, 0x7E, 0x1F, 0xF0, 0xFC, 0x07, 0xE1, 0xFF, 0x0F,
  0xC0, 0x7E, 0x1F, 0xE0, 0xFC, 0x07, 0xE1, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F,
  0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC0, 0xF8, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xE0,
  0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x0F,
  0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0xFC, 0x03, 0xFF,
  0x03, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xC1,
  0xF8, 0x07, 0xFF, 0x87, 0xE0, 0x1F, 0x7E, 0x1F, 0x80, 0xFD, 0xF8, 0x7E,
  0x03, 0xF3, 0xE3, 0xF0, 0x0F, 0xCF, 0x8F, 0xC0, 0x3F, 0x3E, 0x3F, 0x00,
  0xFC, 0xFC, 0xFC, 0x07, 0xE3, 0xF3, 0xF0, 0x1F, 0x8F, 0xCF, 0x80, 0x7E,
  0x1F, 0x7E, 0x01, 0xF8, 0x7D, 0xF8, 0x07, 0xC1, 0xFF, 0xE0, 0x3F, 0x07,
  0xFF, 0x80, 0xFC, 0x1F, 0xFC, 0x03, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0, 0xFF,
  0xC0, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xE0,
  0x1F, 0x80, 0xFF, 0x80, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1,
  0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC7, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0x9F, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFC, 0x3C, 0x07, 0xF8, 0x08, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x60, 0x0F, 0xE0, 0x70, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F,
  0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x03,
  0xF7, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x80, 0x7E, 0x7E, 0x01, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0x7E,
  0x03, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x81, 0xFC, 0x7E, 0x07, 0xF8, 0x1F,
  0x87, 0xE0, 0x7F, 0x83, 0xF8, 0x7E, 0x0F, 0xF8, 0x3F, 0x07, 0xE0, 0xFF,
  0x83, 0xF0, 0x7E, 0x1F, 0xF8, 0x7F, 0x07, 0xE1, 0xFF, 0x87, 0xE0, 0x7E,
  0x1F, 0xF8, 0x7E, 0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0x7E, 0x3E, 0xF8, 0xFC,
  0x07, 0xE7, 0xEF, 0x9F, 0xC0, 0x7E, 0x7C, 0xF9, 0xF8, 0x07, 0xE7, 0xCF,
  0x9F, 0x80, 0x7E, 0xFC, 0xFB, 0xF0, 0x07, 0xEF, 0x8F, 0xBF, 0x00, 0x7F,
  0xF8, 0xFB, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0x81, 0xFC,
  0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xE3,
  0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xC7, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x00, 0x70, 0x02, 0x03, 0xF8, 0xF8,
  0x0F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xF1, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFC,
  0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x7E, 0x01,
  0xFC, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x1C,
  0x01, 0xF9, 0xFC, 0x07, 0xEF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F,
  0x03, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF9, 0xFF, 0x03,
  0xE3, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x60, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x08, 0x3F, 0xC7,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x1C,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0xEF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFD, 0xF0, 0x03, 0xFC, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8,
  0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x03, 0x07, 0xFB, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFC, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0xBF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0, 0x0F, 0xEF,
  0xE0, 0x01, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0xC0, 0x3F, 0x80, 0xF8, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x1C, 0x01, 0xF9, 0xFC, 0x07, 0xEF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x00, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F,
  0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x38, 0x03, 0xE7, 0xF8, 0x7F, 0x01, 0xF7, 0xFE, 0xFF, 0xC0,
  0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC7, 0xF8, 0xFC, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x1F,
  0xC0, 0x7C, 0xFF, 0x81, 0xF7, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x1F, 0xC7, 0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF0,
  0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x7F, 0x00, 0x3E, 0x7F, 0xC0, 0x1F,
  0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFE, 0x03,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xDF, 0xF8, 0x07, 0xEF,
  0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF8, 0x20, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF9, 0xF0,
  0x3F, 0xEF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC,
  0x7F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x3F,
  0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x04,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0xF8,
  0xF8, 0x1F, 0x3F, 0x03, 0xEF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xC4, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xDF, 0x07, 0xF0, 0x60, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xE1, 0x01, 0xFC, 0x38, 0x7F, 0x87, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x60, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF,
  0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x87, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x20, 0x00,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x7C, 0x03,
  0xF9, 0xF0, 0x01, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xCF, 0x80, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x1F,
  0xBF, 0x0F, 0xF0, 0x7E, 0xFC, 0x3F, 0xC3, 0xF3, 0xF0, 0xFF, 0x0F, 0xCF,
  0xC7, 0xFC, 0x3F, 0x3F, 0x1F, 0xF1, 0xF8, 0xFC, 0xFF, 0xC7, 0xE3, 0xF3,
  0xFF, 0x1F, 0x0F, 0xCF, 0x7C, 0xFC, 0x3F, 0x7D, 0xF3, 0xF0, 0xFD, 0xF7,
  0xDF, 0x83, 0xEF, 0x9F, 0x7E, 0x0F, 0xBE, 0x7D, 0xF0, 0x3E, 0xF9, 0xFF,
  0xC0, 0xFB, 0xC7, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB,
  0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0xC0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0D, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0x0B, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xD0, 0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 37, 13, 0, -36 },
  { 66, 17, 13, 20, 5, -36 },
  { 94, 25, 36, 24, 0, -36 },
  { 207, 23, 41, 21, 0, -38 },
  { 325, 31, 36, 35, 3, -36 },
  { 465, 26, 37, 26, 0, -36 },
  { 586, 8, 13, 12, 5, -36 },
  { 599, 16, 44, 14, 1, -36 },
  { 687, 17, 44, 14, -4, -36 },
  { 781, 19, 20, 21, 4, -38 },
  { 829, 20, 24, 23, 2, -30 },
  { 889, 11, 14, 12, -3, -7 },
  { 909, 13, 7, 14, 1, -17 },
  { 921, 8, 9, 12, 0, -8 },
  { 930, 26, 36, 19, -3, -36 },
  { 1047, 21, 37, 21, 1, -36 },
  { 1145, 16, 36, 22, 5, -36 },
  { 1217, 24, 36, 21, -2, -36 },
  { 1325, 23, 37, 21, -1, -36 },
  { 1432, 23, 36, 22, -1, -36 },
  { 1536, 22, 37, 21, 0, -36 },
  { 1638, 22, 37, 21, 1, -36 },
  { 1740, 23, 36, 21, 1, -36 },
  { 1844, 22, 37, 21, 0, -36 },
  { 1946, 22, 37, 21, 0, -36 },
  { 2048, 12, 29, 12, 0, -28 },
  { 2092, 15, 35, 12, -3, -28 },
  { 2158, 20, 24, 23, 2, -30 },
  { 2218, 20, 15, 23, 2, -25 },
  { 2256, 21, 24, 23, 2, -30 },
  { 2319, 18, 37, 17, 1, -36 },
  { 2403, 31, 40, 32, 1, -36 },
  { 2558, 23, 36, 24, -3, -36 },
  { 2662, 24, 36, 24, 0, -36 },
  { 2770, 23, 37, 22, 2, -36 },
  { 2877, 25, 36, 26, 0, -36 },
  { 2990, 22, 36, 20, 0, -36 },
  { 3089, 22, 36, 19, 0, -36 },
  { 3188, 26, 37, 26, 2, -36 },
  { 3309, 28, 36, 27, 0, -36 },
  { 3435, 22, 36, 16, -2, -36 },
  { 3534, 22, 47, 12, -8, -36 },
  { 3664, 28, 36, 23, 0, -36 },
  { 3790, 16, 36, 19, 0, -36 },
  { 3862, 36, 36, 35, 0, -36 },
  { 4024, 30, 36, 28, 0, -36 },
  { 4159, 25, 37, 27, 2, -36 },
  { 4275, 25, 36, 23, 0, -36 },
  { 4388, 25, 45, 27, 2, -36 },
  { 4529, 24, 36, 23, 0, -36 },
  { 4637, 24, 37, 21, -1, -36 },
  { 4748, 21, 36, 20, 3, -36 },
  { 4843, 26, 37, 26, 2, -36 },
  { 4964, 24, 36, 23, 4, -36 },
  { 5072, 36, 36, 35, 3, -36 },
  { 5234, 29, 36, 22, -3, -36 },
  { 5365, 22, 36, 21, 4, -36 },
  { 5464, 25, 36, 19, -2, -36 },
  { 5577, 20, 44, 14, -2, -36 },
  { 5687, 10, 36, 19, 5, -36 },
  { 5732, 20, 44, 14, -4, -36 },
  { 5842, 22, 22, 22, 0, -36 },
  { 5903, 17, 4, 16, -5, 4 },
  { 5912, 10, 8, 15, 7, -38 },
  { 5922, 23, 29, 23, 1, -28 },
  { 6006, 22, 39, 23, 0, -38 },
  { 6114, 19, 29, 18, 1, -28 },
  { 6183, 25, 39, 23, 1, -38 },
  { 6305, 20, 29, 21, 1, -28 },
  { 6378, 26, 50, 14, -6, -38 },
  { 6541, 24, 40, 23, -1, -28 },
  { 6661, 22, 38, 23, 0, -38 },
  { 6766, 14, 38, 11, 0, -38 },
  { 6833, 20, 50, 11, -6, -38 },
  { 6958, 24, 38, 21, 0, -38 },
  { 7072, 14, 38, 11, 0, -38 },
  { 7139, 33, 28, 34, 0, -28 },
  { 7255, 22, 28, 23, 0, -28 },
  { 7332, 20, 29, 22, 1, -28 },
  { 7405, 25, 40, 23, -3, -28 },
  { 7530, 22, 40, 23, 1, -28 },
  { 7640, 19, 28, 16, 0, -28 },
  { 7707, 19, 29, 18, 0, -28 },
  { 7776, 14, 34, 15, 2, -33 },
  { 7836, 22, 28, 23, 1, -27 },
  { 7913, 20, 27, 20, 3, -27 },
  { 7981, 30, 27, 31, 3, -27 },
  { 8083, 24, 27, 20, -2, -27 },
  { 8164, 27, 39, 20, -4, -27 },
  { 8296, 21, 27, 17, -2, -27 },
  { 8367, 19, 44, 17, 1, -36 },
  { 8472, 6, 49, 19, 6, -38 },
  { 8509, 19, 44, 17, -3, -36 },
  { 8614, 21, 9, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC50PT7B_H_
