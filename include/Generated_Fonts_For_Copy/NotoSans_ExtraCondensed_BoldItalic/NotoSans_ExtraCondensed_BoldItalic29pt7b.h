#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x7B, 0xDC,
  0xF7, 0x3B, 0xCE, 0xE7, 0xB9, 0xCE, 0x73, 0x9C, 0x01, 0x8C, 0x07, 0x38,
  0x0E, 0x70, 0x18, 0xC0, 0x33, 0x80, 0xE7, 0x0F, 0xFF, 0x9F, 0xFE, 0x3F,
  0xFC, 0x1C, 0xC0, 0x33, 0x80, 0xE7, 0x07, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC,
  0x1C, 0xE0, 0x31, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x18, 0x0E, 0x70, 0x00,
  0x00, 0x40, 0x06, 0x00, 0xF8, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x74, 0x43,
  0xA0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0xDC, 0x45, 0xE7, 0xBF, 0x3F, 0xF1, 0xFF, 0x03, 0xE0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x1E, 0x07, 0x0F, 0x83, 0x87, 0xF0, 0xC1, 0x9C, 0x70,
  0xE7, 0x38, 0x39, 0xCE, 0x0C, 0x77, 0x03, 0x19, 0xC0, 0xCE, 0xE7, 0x33,
  0xBB, 0xEF, 0xDD, 0xFB, 0xE6, 0x67, 0x73, 0xB9, 0xC0, 0xCE, 0x70, 0x73,
  0x18, 0x39, 0xCE, 0x0E, 0x73, 0x87, 0x1C, 0xE1, 0xC7, 0x70, 0xE0, 0xF8,
  0x38, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x73, 0xC0, 0xE7,
  0x81, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x79,
  0xFC, 0xE7, 0xBF, 0xCE, 0x7F, 0xBC, 0xFE, 0x78, 0xF8, 0xF1, 0xF1, 0xE3,
  0xE3, 0xFF, 0xC3, 0xFF, 0xC7, 0xE7, 0x80, 0x7B, 0x9D, 0xEF, 0x73, 0x9C,
  0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x00, 0x07, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x00, 0x07, 0x00, 0xE1, 0x1C, 0x3B, 0x3F, 0xFE, 0xFF, 0xC7,
  0xF9, 0xF8, 0x7B, 0x8F, 0x78, 0xCE, 0x01, 0x00, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x1E, 0x3C, 0xF1, 0xE3, 0x8F, 0x1C, 0x78,
  0x7F, 0x7F, 0x7F, 0xFE, 0x77, 0xFD, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0xFE, 0x1F, 0xE1, 0xFE, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x8E, 0x70,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x3C, 0xE7,
  0x8E, 0x78, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x03, 0x83, 0xC7, 0xE7, 0xE7,
  0xF7, 0xFB, 0xBC, 0x9E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0xFF,
  0x83, 0xDF, 0x0C, 0x3C, 0x20, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xE0, 0x7F, 0x87,
  0xFE, 0x1D, 0xF0, 0x87, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE4,
  0x3E, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xDC, 0x0C, 0xE0, 0xEF, 0x0E,
  0x78, 0x63, 0x87, 0x1C, 0x70, 0xE3, 0xFF, 0xDF, 0xFC, 0xFF, 0xE0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8,
  0x23, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE6, 0x3E, 0x3F,
  0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xF1, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x7F, 0xC7, 0xFC, 0xFF, 0xEF, 0x9E, 0xF1,
  0xEF, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0xCF, 0x7C, 0xFF, 0x87, 0xF0, 0x7E,
  0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0xE3,
  0xDE, 0x1F, 0xE0, 0x7E, 0x03, 0xE0, 0x7F, 0x87, 0xDE, 0x3C, 0xF3, 0xC3,
  0x9E, 0x1C, 0xF1, 0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x7F, 0x87, 0xFC, 0x3D, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E,
  0x38, 0xF1, 0xC7, 0x8F, 0xFC, 0x7F, 0xE3, 0xEE, 0x06, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x3F, 0xE1, 0xFE, 0x0F, 0xC0, 0x00, 0x0E, 0x3C,
  0xF8, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x3C, 0x78,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x00, 0x00,
  0x30, 0x0F, 0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x08, 0x00, 0x1F, 0x1F, 0xE3, 0xFC, 0xCF,
  0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x80, 0x78, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x08, 0x73,
  0x9F, 0xDD, 0xCF, 0xE7, 0x73, 0x99, 0xD9, 0xCE, 0x6E, 0x63, 0x9B, 0x98,
  0xC6, 0xCE, 0x73, 0xB3, 0x9C, 0xCC, 0xE7, 0x33, 0x3F, 0xF8, 0xC7, 0xBE,
  0x30, 0xC6, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x20, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xDC, 0x07,
  0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F,
  0x3C, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE,
  0x0F, 0xF0, 0x3C, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0x9F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC,
  0x38, 0xF1, 0xE1, 0xC7, 0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xEC, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE2, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE1, 0xE3, 0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x78, 0x7C,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x78,
  0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFC, 0xE1, 0xE0, 0x47, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF1, 0xFB, 0xE7, 0xE7, 0x8F, 0xCF, 0x1F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x38, 0xF0, 0xF1, 0xF1, 0xE1, 0xFF, 0xC3, 0xFF, 0x81, 0xFC, 0x00, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C,
  0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x09,
  0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x0F, 0x0F, 0x1E, 0x0E, 0x1E,
  0x0E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x39, 0xC0, 0x79, 0xC0,
  0x79, 0xE0, 0x79, 0xE0, 0x71, 0xE0, 0xF1, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x8F, 0xE1,
  0xFC, 0x77, 0x0F, 0xE7, 0xF8, 0x77, 0x3B, 0xC3, 0xB9, 0xDE, 0x1D, 0xFC,
  0xE1, 0xE7, 0xE7, 0x0F, 0x3E, 0x78, 0x71, 0xF3, 0xC3, 0x8F, 0x1C, 0x3C,
  0x78, 0xE1, 0xE3, 0xCF, 0x0E, 0x1C, 0x78, 0x00, 0x0F, 0x03, 0x87, 0xC1,
  0xC3, 0xE1, 0xE1, 0xF0, 0xF1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x3C, 0x3F,
  0x9E, 0x1D, 0xCE, 0x1E, 0xE7, 0x0F, 0x73, 0x87, 0x3B, 0xC3, 0x9F, 0xE1,
  0xCF, 0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x3C, 0x3E,
  0x1E, 0x1F, 0x0E, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB,
  0xE1, 0xE3, 0xC7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x7B,
  0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0xF1, 0xF3, 0xE1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x1E, 0x3C, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x1C,
  0x3C, 0xF1, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFC, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xE1, 0xE3, 0xC7, 0x83, 0xCF, 0x07, 0xBC,
  0x0F, 0x78, 0x3E, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xF3, 0xE1, 0xFF, 0x83, 0xFE, 0x03,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x0E, 0x1C, 0x78, 0xF3, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xEF, 0x07,
  0x9C, 0x1E, 0x70, 0x79, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF0,
  0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0x08, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x41, 0xE1, 0xCF, 0x87, 0xFC, 0x3F, 0xF0, 0x7F,
  0x00, 0x7F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E,
  0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xF7, 0xC3, 0xFF, 0x03, 0xFE, 0x03, 0xF0,
  0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xEE, 0x1E, 0x70, 0xF3, 0x87,
  0x1C, 0x78, 0xE3, 0x87, 0x3C, 0x39, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x70, 0x70, 0x7B, 0x83, 0x83, 0x9C, 0x3C, 0x3D, 0xE1, 0xE1, 0xEF, 0x1F,
  0x0E, 0x78, 0xF8, 0xF3, 0xC7, 0xC7, 0x1E, 0x7E, 0x78, 0xF3, 0xF3, 0xC7,
  0x9F, 0x9C, 0x3D, 0xDD, 0xE1, 0xEE, 0xEE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F,
  0x83, 0xB9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x87, 0x83, 0xC7,
  0x81, 0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1D, 0xE0, 0x1E, 0xF0, 0x1E, 0x38, 0x0F, 0x1C,
  0x0F, 0x0F, 0x0F, 0x07, 0x80, 0xE0, 0xFE, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3,
  0xCF, 0x78, 0xF7, 0x87, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x87, 0xE0, 0xFC,
  0x1F, 0x80, 0xE3, 0x8E, 0x3C, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x78,
  0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x3C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x7E, 0x07, 0xF0, 0x3B, 0x83, 0x9C, 0x3C, 0xF1, 0xC3, 0x9E, 0x1C,
  0xE0, 0xEE, 0x07, 0x80, 0xFF, 0xC0, 0xF9, 0xE3, 0x8F, 0x0F, 0x78, 0xFB,
  0x8F, 0xFC, 0xFB, 0xE7, 0x8F, 0x38, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7,
  0x0F, 0x38, 0x71, 0xC7, 0x8F, 0x3C, 0x7F, 0xE3, 0xFF, 0x0F, 0x70, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0x83, 0xBE,
  0x1F, 0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xCF,
  0x1E, 0x78, 0xF3, 0xC7, 0x3E, 0x79, 0xFF, 0x8E, 0xFC, 0x77, 0xC0, 0x0F,
  0xC7, 0xF3, 0xFD, 0xF2, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xF1, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0xF7, 0x87, 0xFC, 0x3F, 0xF1, 0xE7,
  0xC7, 0x8F, 0x1C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x78, 0xE1,
  0xC3, 0x8F, 0x0E, 0x3C, 0x3F, 0xF0, 0xFF, 0xC1, 0xEE, 0x00, 0x07, 0x83,
  0xF8, 0xFF, 0xBC, 0x77, 0x8E, 0xE3, 0xFD, 0xF7, 0xFC, 0xFF, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x09, 0xFF, 0x3F, 0xE3, 0xF8, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0xC0, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x02, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x03,
  0xDE, 0x0F, 0xB8, 0x3F, 0xF0, 0xFB, 0xE1, 0xE3, 0xC3, 0x87, 0x0F, 0x0E,
  0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE1, 0xC3, 0xC7, 0x83, 0xDF, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x86, 0x1E,
  0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xC3, 0xBE, 0x1F, 0xF9, 0xF3, 0xCF,
  0x1E, 0x78, 0xE3, 0x87, 0x1C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xE3, 0x87,
  0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xE0, 0x07, 0x0F, 0x0F, 0x0E, 0x00,
  0x00, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x0B, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE3, 0xC7, 0x1E, 0x1C, 0xF0, 0xF3, 0x83, 0xDE, 0x0E, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7B, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF0,
  0xF1, 0xC3, 0x87, 0x80, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0x1D, 0xE3, 0xC3, 0xFE, 0xFC, 0x7F, 0xFF, 0x9F, 0x7C, 0xF3,
  0xC7, 0x9E, 0x78, 0xE3, 0xCE, 0x3C, 0x71, 0xC7, 0x8E, 0x78, 0xE3, 0xCF,
  0x1C, 0x79, 0xC3, 0x8F, 0x38, 0xF1, 0xC7, 0x1E, 0x39, 0xE3, 0x8F, 0x3C,
  0x71, 0xE7, 0x1E, 0x38, 0x1C, 0xE0, 0xEF, 0x87, 0xFE, 0x7C, 0xF3, 0xC7,
  0x9E, 0x38, 0xE1, 0xC7, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0xE1, 0xC7,
  0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0xBE, 0xF7,
  0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xEF, 0x3D,
  0xFF, 0x1F, 0xC1, 0xF0, 0x07, 0x3C, 0x0E, 0xF8, 0x1F, 0xF8, 0x7C, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC3, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xC1, 0xE7, 0x87, 0xFE, 0x0F, 0xFC, 0x1D, 0xF0, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x78, 0xFF, 0x8F, 0xFC, 0xF3, 0xE7, 0x8F, 0x38, 0x73, 0xC3, 0x9E,
  0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0x71, 0xC7, 0x8E, 0x3C, 0x7F, 0xE3, 0xFF,
  0x0F, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x00, 0x1C, 0xE3, 0xB8, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x0F, 0xC3, 0xFC, 0xFF, 0x1E, 0x23, 0x80, 0x78, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xC8, 0x79, 0xFE, 0x3F, 0xC7, 0xF0, 0x0E, 0x1C,
  0x1C, 0x3F, 0x7F, 0xFF, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xE0, 0xFC, 0xFC, 0x7C, 0x3C, 0x73, 0x87, 0x38, 0xF7, 0x8F, 0x78,
  0xE7, 0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0xEF, 0x1C, 0xE3, 0xCE, 0x3C, 0xE7,
  0xCF, 0xF8, 0xFF, 0x87, 0xB8, 0xE1, 0xFC, 0x3F, 0x8F, 0x71, 0xEE, 0x39,
  0xCF, 0x39, 0xC7, 0x78, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x07, 0x80, 0xE3, 0xE3, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0xF8, 0xEE,
  0x7C, 0xF7, 0x7E, 0x73, 0xBF, 0x79, 0xDF, 0xB8, 0xFD, 0xDC, 0x7E, 0xFE,
  0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3,
  0xC0, 0x1E, 0x3C, 0x79, 0xE0, 0xE7, 0x83, 0xBC, 0x0E, 0xE0, 0x3F, 0x80,
  0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x0F, 0xF0, 0x39, 0xC1,
  0xE7, 0x07, 0x1E, 0x3C, 0x78, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x71,
  0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0xF8, 0xFF, 0x8F,
  0xF8, 0x00, 0x30, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0x78, 0x07, 0x80, 0xFC, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x3E, 0x03,
  0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xF0, 0x1E, 0x07, 0xC1, 0xF8,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0x07, 0xE0,
  0xF8, 0x10, 0x00, 0x10, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 10, 8, 11, 3, -21 },
  { 32, 15, 21, 14, 0, -21 },
  { 72, 13, 24, 12, 0, -22 },
  { 111, 18, 21, 20, 2, -21 },
  { 159, 15, 21, 15, 0, -21 },
  { 199, 5, 8, 7, 3, -21 },
  { 204, 10, 26, 8, 0, -21 },
  { 237, 9, 26, 8, -2, -21 },
  { 267, 11, 12, 12, 2, -22 },
  { 284, 12, 14, 13, 1, -17 },
  { 305, 7, 8, 7, -2, -4 },
  { 312, 8, 4, 8, 0, -10 },
  { 316, 5, 4, 7, 0, -4 },
  { 319, 15, 21, 11, -2, -21 },
  { 359, 12, 21, 12, 1, -21 },
  { 391, 9, 21, 13, 3, -21 },
  { 415, 14, 21, 12, -1, -21 },
  { 452, 13, 21, 12, 0, -21 },
  { 487, 13, 21, 13, 0, -21 },
  { 522, 13, 21, 12, 0, -21 },
  { 557, 12, 21, 12, 1, -21 },
  { 589, 13, 21, 12, 1, -21 },
  { 624, 13, 21, 12, 0, -21 },
  { 659, 13, 21, 12, 0, -21 },
  { 694, 7, 16, 7, 0, -16 },
  { 708, 9, 20, 7, -2, -16 },
  { 731, 12, 14, 13, 1, -17 },
  { 752, 12, 9, 13, 1, -15 },
  { 766, 12, 14, 13, 1, -17 },
  { 787, 10, 21, 10, 1, -21 },
  { 814, 18, 23, 19, 1, -21 },
  { 866, 14, 21, 14, -2, -21 },
  { 903, 14, 21, 14, 0, -21 },
  { 940, 14, 21, 13, 1, -21 },
  { 977, 15, 21, 15, 0, -21 },
  { 1017, 13, 21, 12, 0, -21 },
  { 1052, 13, 21, 11, 0, -21 },
  { 1087, 15, 21, 15, 1, -21 },
  { 1127, 16, 21, 15, 0, -21 },
  { 1169, 12, 21, 9, -1, -21 },
  { 1201, 12, 27, 7, -4, -21 },
  { 1242, 16, 21, 13, 0, -21 },
  { 1284, 9, 21, 11, 0, -21 },
  { 1308, 21, 21, 20, 0, -21 },
  { 1364, 17, 21, 16, 0, -21 },
  { 1409, 15, 21, 16, 1, -21 },
  { 1449, 14, 21, 13, 0, -21 },
  { 1486, 15, 26, 16, 1, -21 },
  { 1535, 14, 21, 13, 0, -21 },
  { 1572, 14, 21, 12, -1, -21 },
  { 1609, 12, 21, 11, 2, -21 },
  { 1641, 15, 21, 15, 1, -21 },
  { 1681, 13, 21, 13, 3, -21 },
  { 1716, 21, 21, 20, 2, -21 },
  { 1772, 17, 21, 13, -2, -21 },
  { 1817, 12, 21, 12, 3, -21 },
  { 1849, 14, 21, 11, -1, -21 },
  { 1886, 11, 26, 8, -1, -21 },
  { 1922, 6, 21, 11, 3, -21 },
  { 1938, 11, 26, 8, -2, -21 },
  { 1974, 13, 13, 13, 0, -21 },
  { 1996, 10, 1, 9, -3, 3 },
  { 1998, 6, 4, 9, 4, -22 },
  { 2001, 13, 16, 13, 1, -16 },
  { 2027, 13, 22, 13, 0, -22 },
  { 2063, 10, 16, 11, 1, -16 },
  { 2083, 14, 22, 13, 1, -22 },
  { 2122, 11, 16, 12, 1, -16 },
  { 2144, 14, 29, 8, -3, -22 },
  { 2195, 15, 23, 13, -1, -16 },
  { 2239, 13, 22, 13, 0, -22 },
  { 2275, 8, 22, 7, 0, -22 },
  { 2297, 12, 29, 7, -4, -22 },
  { 2341, 14, 22, 12, 0, -22 },
  { 2380, 8, 22, 7, 0, -22 },
  { 2402, 19, 16, 19, 0, -16 },
  { 2440, 13, 16, 13, 0, -16 },
  { 2466, 11, 16, 13, 1, -16 },
  { 2488, 15, 23, 13, -2, -16 },
  { 2532, 13, 23, 13, 1, -16 },
  { 2570, 11, 16, 9, 0, -16 },
  { 2592, 11, 16, 10, 0, -16 },
  { 2614, 8, 19, 8, 1, -19 },
  { 2633, 12, 16, 13, 1, -16 },
  { 2657, 11, 16, 12, 2, -16 },
  { 2679, 17, 16, 18, 2, -16 },
  { 2713, 14, 16, 12, -1, -16 },
  { 2741, 15, 23, 12, -2, -16 },
  { 2785, 12, 16, 10, -1, -16 },
  { 2809, 12, 26, 10, 0, -21 },
  { 2848, 3, 29, 11, 4, -22 },
  { 2859, 11, 26, 10, -2, -21 },
  { 2895, 12, 5, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC29PT7B_H_
