#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x3F, 0x8F, 0xE7,
  0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0xFE, 0x3F, 0x9F,
  0xC7, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E,
  0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0x63, 0x80, 0x7F, 0x30, 0xC0, 0x3F, 0x98, 0x00, 0x1F, 0xDC, 0x00, 0x0F,
  0xEC, 0x00, 0x07, 0xF6, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0x7F, 0x00, 0x01, 0xBF, 0x80, 0x01, 0xDF, 0xC1, 0x00, 0xCF,
  0xE0, 0xC0, 0x67, 0xF0, 0x78, 0x37, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x3F, 0xF8,
  0x07, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0xFC, 0x03, 0xE3,
  0xF0, 0x3E, 0x00, 0xF8, 0x7C, 0x1F, 0x80, 0x7E, 0x3F, 0x07, 0xC0, 0x1F,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x7C, 0x00,
  0xF8, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xE3, 0xE0,
  0x03, 0xE1, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0xFC, 0x3E, 0x3E, 0x3F, 0x3E,
  0x3F, 0xEF, 0x8F, 0x9F, 0x9F, 0xFB, 0xE7, 0xE7, 0xC7, 0xFF, 0xFF, 0xF3,
  0xF3, 0xFF, 0xFF, 0xF8, 0xF9, 0xF1, 0xF7, 0xFC, 0x7C, 0x7C, 0x7C, 0xFE,
  0x1F, 0x3E, 0x1F, 0x0E, 0x0F, 0x8F, 0x87, 0xC0, 0x03, 0xE3, 0xE1, 0xF0,
  0x01, 0xF1, 0xF8, 0x7C, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x07,
  0xC0, 0x1F, 0x87, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0xF8, 0x03, 0xF0, 0x7C,
  0x3E, 0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x01,
  0xF3, 0xF0, 0x0F, 0x80, 0x7C, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xF0,
  0x07, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0xCF,
  0xE1, 0xFD, 0xFC, 0xFE, 0x3F, 0x9F, 0xCF, 0xC3, 0xF1, 0xFF, 0xFC, 0x7F,
  0x0F, 0xFF, 0x87, 0xE0, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x7F,
  0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0x81, 0xFF, 0x87, 0xF8,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x02,
  0x07, 0xC0, 0x1C, 0x3E, 0x00, 0xF9, 0xF0, 0x4F, 0xFF, 0xBE, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFC, 0xFC,
  0x07, 0xC7, 0xF0, 0x1E, 0x1F, 0x80, 0x60, 0xF0, 0x02, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0x3F, 0x9F, 0xFF, 0xFF, 0xF7,
  0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFC, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF,
  0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF1,
  0xF9, 0xF8, 0x3C, 0xFE, 0x06, 0x3F, 0x81, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xE0, 0xFF, 0x00, 0xF0, 0x3F, 0xC0, 0x18, 0x07, 0xF0,
  0x04, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0x81, 0xFF, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x80, 0x07, 0xF8,
  0x38, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xDF, 0xC0, 0x03, 0xEF, 0xE0, 0x03, 0xE7, 0xE0, 0x01,
  0xF3, 0xF0, 0x01, 0xF3, 0xF8, 0x01, 0xF1, 0xFC, 0x00, 0xF8, 0xFE, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x7F, 0x00, 0x7C, 0x3F, 0x80, 0x7C, 0x1F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xF0, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xBC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x71, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC1, 0x00, 0x3F, 0xE0, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x86, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0x00, 0x1F, 0xCF, 0xE0, 0x1F, 0xBF,
  0xF0, 0x3F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF7, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F,
  0xC7, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F,
  0xC1, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x7F,
  0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x40, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0x8F, 0xF0, 0xC0, 0x7F, 0x08, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x01, 0xFF, 0x0F, 0x07, 0xC1, 0xFF, 0xE3, 0xC3, 0xE0,
  0xFF, 0xF0, 0xF0, 0xF8, 0x7F, 0xFC, 0x3C, 0x7C, 0x3F, 0x1F, 0x0F, 0x1F,
  0x0F, 0x87, 0xC3, 0xC7, 0x87, 0xC1, 0xE0, 0xF3, 0xE1, 0xF0, 0xF8, 0x7C,
  0xF8, 0xF8, 0x3E, 0x1F, 0x3C, 0x3E, 0x0F, 0x87, 0xDF, 0x0F, 0x83, 0xC1,
  0xE7, 0xC3, 0xC1, 0xF0, 0x79, 0xF1, 0xF0, 0x7C, 0x3E, 0x78, 0x7C, 0x1F,
  0x0F, 0x1E, 0x1F, 0x0F, 0xC3, 0xCF, 0x87, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0,
  0xF8, 0x78, 0xF8, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0xFF, 0xDF, 0x0F, 0x87,
  0xFF, 0xFF, 0x83, 0xE0, 0xFF, 0x3F, 0xC0, 0xF8, 0x3F, 0x8F, 0xE0, 0x3E,
  0x01, 0x80, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0,
  0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3,
  0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF,
  0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0x8F, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0,
  0x7F, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xF8, 0x18, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x1F,
  0xF0, 0x70, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFC, 0x7F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x3F,
  0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x40, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1C, 0x07, 0xFC, 0x00, 0x40, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x83, 0xFF, 0xC7, 0xF8, 0x3F, 0xF8, 0x7F, 0x03, 0xFF,
  0x8F, 0xF0, 0x3F, 0xF8, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xF8, 0xFF,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F,
  0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x07,
  0xEF, 0xC1, 0xFB, 0xF8, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x0F, 0xEF, 0xC3,
  0xF3, 0xF0, 0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x0F, 0xEF, 0xC3, 0xE7, 0xF0,
  0x0F, 0xCF, 0xC7, 0xE7, 0xF0, 0x0F, 0xCF, 0xC7, 0xE7, 0xE0, 0x1F, 0xCF,
  0xCF, 0xCF, 0xE0, 0x1F, 0xCF, 0xCF, 0xCF, 0xE0, 0x1F, 0x8F, 0xDF, 0x8F,
  0xE0, 0x1F, 0x8F, 0xDF, 0x8F, 0xE0, 0x1F, 0x8F, 0xDF, 0x0F, 0xC0, 0x3F,
  0x8F, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xFE,
  0x1F, 0xC0, 0x3F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x7E, 0x07,
  0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF0,
  0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F,
  0x80, 0x7F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xE0, 0x1F, 0xBF, 0x07,
  0xF0, 0x0F, 0xCF, 0xC3, 0xF0, 0x07, 0xE7, 0xE1, 0xF8, 0x07, 0xF3, 0xF1,
  0xFC, 0x03, 0xF9, 0xF8, 0xFE, 0x01, 0xFC, 0xFC, 0x7E, 0x00, 0xFC, 0x7F,
  0x3F, 0x00, 0x7E, 0x1F, 0x9F, 0x80, 0x7F, 0x0F, 0xDF, 0xC0, 0x3F, 0x87,
  0xEF, 0xE0, 0x1F, 0x83, 0xF7, 0xE0, 0x0F, 0xC1, 0xFB, 0xF0, 0x07, 0xE0,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x1F, 0xFE, 0x01, 0xF8,
  0x0F, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0x80, 0x3F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8,
  0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8,
  0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFC, 0x3C, 0x03, 0xFC, 0x02, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0x00, 0x1F, 0xE0, 0x70,
  0x0F, 0xF0, 0x1F, 0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0,
  0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0x01,
  0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xF0, 0x0F, 0xE7, 0xE0,
  0x1F, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0x80,
  0xFE, 0x3F, 0x01, 0xFF, 0x03, 0xF8, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0xFC,
  0x0F, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0xF0,
  0x7F, 0x07, 0xE0, 0xFF, 0xE1, 0xFC, 0x0F, 0xC1, 0xFF, 0xC3, 0xF8, 0x3F,
  0x87, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x7C,
  0x3F, 0x81, 0xFC, 0x7E, 0xF8, 0xFE, 0x03, 0xF8, 0xF9, 0xF1, 0xFC, 0x07,
  0xF3, 0xF3, 0xE3, 0xF8, 0x0F, 0xE7, 0xE7, 0xCF, 0xE0, 0x1F, 0xCF, 0x8F,
  0x9F, 0xC0, 0x3F, 0xBF, 0x1F, 0x3F, 0x00, 0x7F, 0x7E, 0x3E, 0xFE, 0x00,
  0xFF, 0xF8, 0x7D, 0xFC, 0x01, 0xFB, 0xF1, 0xFB, 0xF0, 0x03, 0xF7, 0xC3,
  0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07,
  0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8,
  0x01, 0xF9, 0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x7F, 0xCF, 0xE0, 0x7F, 0xF7, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFE, 0xFC, 0x07, 0xFF,
  0x7E, 0x01, 0xFF, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x04, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x20, 0x03,
  0xF9, 0xF8, 0x03, 0xF7, 0xFC, 0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0xFF, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F,
  0xCF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xC0, 0xFD,
  0xFF, 0x80, 0xF8, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFE, 0x08, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x20, 0xFF,
  0x07, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xF3, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0x00, 0x3F,
  0xE7, 0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0xFE,
  0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x20, 0x7F, 0x03, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8,
  0x40, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x01, 0xFF, 0x3F, 0x00,
  0x7F, 0xF7, 0xE0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC7,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x08, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x08, 0x01, 0xFE, 0x01, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x20, 0x03, 0xF9, 0xFC, 0x03, 0xF7, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7E, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x8F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x3E, 0x3F, 0x83, 0xFC, 0x03, 0xE7, 0xFC, 0x7F, 0xE0, 0x7E, 0xFF,
  0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x83, 0xF8, 0x7F,
  0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x03, 0xE1, 0xFC, 0x03, 0xE7,
  0xFE, 0x03, 0xEF, 0xFE, 0x07, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x7F, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0x87, 0xF0,
  0x01, 0xF3, 0xFF, 0x00, 0x7E, 0x7F, 0xE0, 0x0F, 0xDF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xBF, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFC, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x7F, 0xEF, 0xC0, 0x7F, 0xF7, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x08,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x3E, 0x3F, 0x03, 0xE7, 0xF0,
  0x7E, 0x7F, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x08, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x10, 0x0F,
  0xF0, 0xC0, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xFF,
  0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x20,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x04, 0x00,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xC0,
  0x7F, 0xE7, 0xC0, 0x3F, 0xC7, 0xC0, 0x02, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xFC, 0x07,
  0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0x81, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x83, 0xFB, 0xF8, 0x3F, 0xE0,
  0xFC, 0xFE, 0x1F, 0xF8, 0x7F, 0x3F, 0x87, 0xFC, 0x1F, 0x8F, 0xE1, 0xFF,
  0x07, 0xE3, 0xF8, 0xFF, 0xC3, 0xF8, 0xFE, 0x3F, 0xF0, 0xFC, 0x3F, 0x8F,
  0xFC, 0x7F, 0x0F, 0xE7, 0xFF, 0x1F, 0x83, 0xF9, 0xF7, 0xC7, 0xE0, 0xFC,
  0xFD, 0xF3, 0xF8, 0x3F, 0x3E, 0x7C, 0xFC, 0x0F, 0xCF, 0x9F, 0x3F, 0x03,
  0xF7, 0xE7, 0xDF, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0x7C, 0x7D, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xFC,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x02, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE, 0x80, 0x07,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 16, 40, 14, 0, -39 },
  { 81, 19, 14, 22, 5, -39 },
  { 115, 28, 39, 26, 0, -39 },
  { 252, 25, 45, 23, 0, -42 },
  { 393, 34, 41, 39, 3, -40 },
  { 568, 28, 41, 28, 0, -40 },
  { 712, 10, 14, 13, 5, -39 },
  { 730, 18, 48, 15, 1, -39 },
  { 838, 18, 49, 15, -4, -40 },
  { 949, 21, 23, 23, 4, -42 },
  { 1010, 23, 27, 26, 2, -33 },
  { 1088, 12, 14, 13, -3, -7 },
  { 1109, 14, 7, 16, 1, -18 },
  { 1122, 9, 9, 13, 0, -8 },
  { 1133, 28, 40, 20, -3, -40 },
  { 1273, 23, 41, 23, 1, -40 },
  { 1391, 18, 39, 24, 5, -39 },
  { 1479, 26, 40, 23, -2, -40 },
  { 1609, 26, 41, 23, -1, -40 },
  { 1743, 25, 39, 24, -1, -39 },
  { 1865, 25, 40, 23, 0, -39 },
  { 1990, 24, 41, 23, 1, -40 },
  { 2113, 26, 39, 23, 1, -39 },
  { 2240, 25, 41, 23, 0, -40 },
  { 2369, 24, 41, 23, 0, -40 },
  { 2492, 13, 31, 13, 0, -30 },
  { 2543, 16, 37, 13, -3, -30 },
  { 2617, 23, 26, 26, 2, -33 },
  { 2692, 23, 17, 26, 2, -28 },
  { 2741, 23, 26, 26, 2, -33 },
  { 2816, 20, 41, 18, 1, -40 },
  { 2919, 34, 44, 36, 1, -40 },
  { 3106, 25, 39, 26, -3, -39 },
  { 3228, 27, 39, 26, 0, -39 },
  { 3360, 26, 41, 24, 2, -40 },
  { 3494, 28, 39, 28, 0, -39 },
  { 3631, 25, 39, 22, 0, -39 },
  { 3753, 25, 39, 21, 0, -39 },
  { 3875, 28, 41, 29, 2, -40 },
  { 4019, 31, 39, 29, 0, -39 },
  { 4171, 24, 39, 17, -2, -39 },
  { 4288, 24, 51, 14, -8, -39 },
  { 4441, 30, 39, 25, 0, -39 },
  { 4588, 18, 39, 21, 0, -39 },
  { 4676, 40, 39, 38, 0, -39 },
  { 4871, 33, 39, 31, 0, -39 },
  { 5032, 28, 41, 30, 2, -40 },
  { 5176, 27, 39, 25, 0, -39 },
  { 5308, 28, 49, 30, 2, -40 },
  { 5480, 26, 39, 25, 0, -39 },
  { 5607, 26, 41, 23, -1, -40 },
  { 5741, 22, 39, 22, 4, -39 },
  { 5849, 28, 40, 28, 2, -39 },
  { 5989, 25, 39, 26, 5, -39 },
  { 6111, 39, 39, 39, 4, -39 },
  { 6302, 31, 39, 24, -3, -39 },
  { 6454, 23, 39, 23, 5, -39 },
  { 6567, 27, 39, 21, -2, -39 },
  { 6699, 22, 48, 16, -2, -39 },
  { 6831, 12, 40, 21, 5, -40 },
  { 6891, 22, 48, 16, -4, -39 },
  { 7023, 24, 23, 24, 0, -39 },
  { 7092, 18, 3, 18, -5, 5 },
  { 7099, 10, 9, 16, 8, -42 },
  { 7111, 25, 32, 25, 1, -31 },
  { 7211, 24, 43, 25, 0, -42 },
  { 7340, 21, 32, 20, 1, -31 },
  { 7424, 27, 43, 25, 1, -42 },
  { 7570, 22, 31, 23, 1, -30 },
  { 7656, 28, 55, 15, -6, -42 },
  { 7849, 27, 44, 25, -1, -31 },
  { 7998, 24, 42, 25, 0, -42 },
  { 8124, 15, 42, 13, 0, -42 },
  { 8203, 22, 55, 13, -7, -42 },
  { 8355, 26, 42, 23, 0, -42 },
  { 8492, 16, 42, 12, 0, -42 },
  { 8576, 36, 31, 37, 0, -31 },
  { 8716, 24, 31, 25, 0, -31 },
  { 8809, 22, 32, 25, 1, -31 },
  { 8897, 27, 44, 25, -3, -31 },
  { 9046, 25, 44, 25, 1, -31 },
  { 9184, 20, 31, 18, 0, -31 },
  { 9262, 21, 32, 20, 0, -31 },
  { 9346, 16, 37, 16, 2, -36 },
  { 9420, 24, 31, 25, 1, -30 },
  { 9513, 22, 30, 22, 3, -30 },
  { 9596, 34, 30, 34, 3, -30 },
  { 9724, 28, 30, 22, -3, -30 },
  { 9829, 29, 43, 22, -4, -30 },
  { 9985, 22, 30, 19, -2, -30 },
  { 10068, 22, 48, 19, 1, -39 },
  { 10200, 6, 54, 21, 7, -42 },
  { 10241, 21, 48, 19, -3, -39 },
  { 10367, 23, 9, 26, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC55PT7B_H_
