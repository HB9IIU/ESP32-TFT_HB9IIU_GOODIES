#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x19, 0xCC, 0x60, 0x11, 0xCC, 0x00, 0xEF, 0x7D,
  0xB6, 0xD8, 0x0D, 0x84, 0x82, 0xC3, 0x67, 0xF8, 0x90, 0xD8, 0x6C, 0xFF,
  0x36, 0x1B, 0x09, 0x0D, 0x80, 0x04, 0x04, 0x1F, 0x3F, 0x3A, 0x38, 0x38,
  0x1C, 0x0E, 0x16, 0x96, 0xFE, 0xFC, 0x20, 0x20, 0x38, 0xCF, 0x31, 0x66,
  0x6D, 0x8D, 0xB1, 0xAD, 0xFD, 0x7F, 0x69, 0x0B, 0x63, 0x6C, 0x4D, 0x99,
  0xE6, 0x38, 0x0E, 0x0F, 0x8C, 0xC6, 0x63, 0xE0, 0xE0, 0xE6, 0xFB, 0xEF,
  0x67, 0xB3, 0x9F, 0xE7, 0xF0, 0xFB, 0x6C, 0x0C, 0x61, 0x8C, 0x31, 0x86,
  0x18, 0x63, 0x8C, 0x30, 0xC3, 0x06, 0x18, 0x18, 0x61, 0xC7, 0x1C, 0x71,
  0x86, 0x18, 0x63, 0x8C, 0x31, 0x86, 0x30, 0x18, 0x31, 0xEF, 0xF3, 0x8F,
  0x9B, 0x04, 0x30, 0x60, 0xC1, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0x76, 0x6C,
  0x7F, 0xC0, 0x5F, 0x00, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x00, 0x0E, 0x1F, 0x33, 0x33, 0x77,
  0x67, 0x66, 0x66, 0xE6, 0xEE, 0xEC, 0x7C, 0x78, 0x1C, 0xE7, 0xB6, 0xB8,
  0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x60, 0x0F, 0x0F, 0xC4, 0xE0, 0x70, 0x38,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0xCF, 0xE0, 0x1E, 0x3F, 0x27,
  0x03, 0x06, 0x3E, 0x3C, 0x0E, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x03, 0x07,
  0x0E, 0x0E, 0x16, 0x36, 0x2E, 0x6C, 0xFE, 0xFE, 0x0C, 0x1C, 0x18, 0x1F,
  0x3F, 0x30, 0x30, 0x30, 0x7C, 0x7E, 0x0E, 0x06, 0x0E, 0x8C, 0xFC, 0xF8,
  0x07, 0x1F, 0x18, 0x30, 0x30, 0x6E, 0x7E, 0x66, 0xE6, 0xE6, 0xEE, 0x7C,
  0x78, 0x3F, 0x9F, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x0E, 0x00, 0x1E, 0x3F, 0x33, 0x33, 0x37, 0x3E, 0x3C, 0x7C,
  0xE6, 0xC6, 0xC6, 0xFC, 0x78, 0x1E, 0x3F, 0x37, 0x77, 0x67, 0x67, 0x7E,
  0x7E, 0x06, 0x0C, 0x1C, 0xF8, 0xF0, 0x33, 0x30, 0x00, 0x04, 0xEC, 0x18,
  0xC6, 0x00, 0x00, 0x00, 0x73, 0x19, 0x80, 0x02, 0x0C, 0x7F, 0xCC, 0x1E,
  0x0F, 0x87, 0x02, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC1, 0xE0,
  0xE7, 0xBC, 0x60, 0x80, 0x3C, 0xFD, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x60,
  0x01, 0x83, 0x0E, 0x00, 0x07, 0xC0, 0xEE, 0x18, 0x23, 0x33, 0x27, 0xB6,
  0xDB, 0x49, 0x25, 0x92, 0xDB, 0x6D, 0xB4, 0xCD, 0x84, 0x00, 0x61, 0x03,
  0xF0, 0x07, 0x07, 0x0F, 0x0F, 0x1F, 0x1B, 0x1B, 0x33, 0x3F, 0x7F, 0x63,
  0x63, 0xE3, 0x1E, 0x1F, 0x8C, 0xE6, 0x73, 0x31, 0xF9, 0xF8, 0xCC, 0x67,
  0x33, 0xB9, 0x9F, 0xCF, 0xC0, 0x1F, 0x3F, 0x72, 0x70, 0xE0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC4, 0xF8, 0x78, 0x1E, 0x1F, 0x8E, 0xE6, 0x33, 0x19,
  0x8D, 0xCE, 0xE7, 0x63, 0x33, 0xBB, 0x9F, 0xCF, 0x80, 0x1F, 0x3F, 0x38,
  0x30, 0x30, 0x3E, 0x7C, 0x70, 0x60, 0x60, 0xE0, 0xFC, 0xF8, 0x1F, 0x3F,
  0x38, 0x30, 0x30, 0x30, 0x7E, 0x7C, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x0F,
  0x1F, 0xDE, 0x4E, 0x0E, 0x07, 0x03, 0x3D, 0x9E, 0xC7, 0x63, 0x39, 0x9F,
  0xC7, 0xE0, 0x18, 0xCE, 0x73, 0x9C, 0xC6, 0x31, 0x8F, 0xE7, 0xF9, 0xCE,
  0x63, 0x18, 0xCE, 0x33, 0x9C, 0xC7, 0x00, 0x1F, 0x1E, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x7C, 0xF8, 0x03, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0xB8, 0xF0,
  0xE0, 0x19, 0xCE, 0x63, 0x30, 0xDC, 0x36, 0x0F, 0x07, 0xC1, 0xF0, 0x6C,
  0x1B, 0x8E, 0xE3, 0x98, 0xC6, 0x00, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x18,
  0x61, 0x8E, 0x3F, 0xFC, 0x1C, 0x39, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF,
  0x1E, 0x59, 0xB6, 0xCD, 0xBE, 0x6F, 0x63, 0x7B, 0x3B, 0x99, 0x9D, 0xCC,
  0xCC, 0x00, 0x18, 0xE7, 0x18, 0xF3, 0x1E, 0x63, 0xCC, 0x7B, 0x9B, 0x63,
  0x6C, 0x67, 0x8C, 0xF3, 0x9C, 0x63, 0x8C, 0x70, 0x1E, 0x1F, 0x9C, 0xEC,
  0x7E, 0x3F, 0x1F, 0x0D, 0x86, 0xC7, 0x63, 0xB3, 0x9F, 0x87, 0x80, 0x1F,
  0x1F, 0xCE, 0xE6, 0x33, 0x39, 0x9D, 0xFC, 0xFC, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x3F, 0x1F, 0x0D, 0x86, 0xC7,
  0x63, 0xB3, 0x9F, 0x87, 0x80, 0xC0, 0x70, 0x38, 0x1E, 0x1F, 0x8C, 0xC6,
  0x73, 0x31, 0xB9, 0xF8, 0xF8, 0x6C, 0x36, 0x3B, 0x9C, 0xCC, 0x60, 0x1F,
  0x3F, 0x3A, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x8C, 0xFC, 0xF8,
  0x7F, 0x7E, 0xB8, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0x33, 0xB9, 0xDC, 0xCC, 0x66, 0x37, 0x3B, 0x9D, 0x8C, 0xC6, 0x63,
  0x33, 0x9F, 0x87, 0x80, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xDC, 0xD8, 0xD8,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x63, 0x1B, 0x39, 0xD9, 0xCC, 0xCE, 0x6E,
  0xF6, 0x77, 0xB3, 0xEF, 0x9F, 0x78, 0xDB, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7,
  0x0E, 0x30, 0x00, 0x18, 0xC6, 0x61, 0xD8, 0x7C, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x0D, 0x87, 0x61, 0x98, 0xE7, 0x00, 0xC7, 0x9F, 0x36, 0xCD,
  0x9E, 0x3C, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x00, 0x1F, 0x8F, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0F, 0xCF, 0xE0, 0x0E,
  0x3C, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x1C,
  0x78, 0xCC, 0xCC, 0xCE, 0x66, 0x66, 0x66, 0x70, 0x1E, 0x3C, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x3C, 0x78, 0x0C, 0x0C,
  0x1E, 0x1E, 0x36, 0x66, 0x62, 0xC3, 0xFC, 0xDD, 0x80, 0x1F, 0x3F, 0x77,
  0x67, 0x67, 0xE6, 0xE6, 0xEE, 0xFE, 0x7C, 0x18, 0x18, 0x38, 0x30, 0x36,
  0x3F, 0x73, 0x63, 0x63, 0x67, 0x66, 0xE6, 0xFC, 0xFC, 0x1E, 0x7D, 0xC3,
  0x06, 0x1C, 0x38, 0x72, 0x78, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x71, 0xF1,
  0xF9, 0xDC, 0xCE, 0x67, 0x73, 0x39, 0x9D, 0xCF, 0xE3, 0xA0, 0x1E, 0x7D,
  0xDB, 0x37, 0xFF, 0x38, 0x70, 0x7C, 0xF8, 0x03, 0x83, 0xC1, 0x81, 0xC0,
  0xF0, 0xF8, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0xF0, 0x70, 0x00, 0x1F, 0x3F, 0x77, 0x67, 0x67, 0xE6, 0xE6, 0xEE,
  0xFE, 0x7C, 0x0C, 0x0C, 0xFC, 0xF8, 0x18, 0x18, 0x38, 0x30, 0x36, 0x3F,
  0x77, 0x77, 0x66, 0x66, 0x66, 0xE6, 0xCE, 0xCC, 0x19, 0xCC, 0x03, 0x19,
  0xCE, 0x63, 0x19, 0xCC, 0x60, 0x06, 0x1C, 0x30, 0x00, 0xC1, 0x87, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0xF1, 0xC0, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x39, 0xB9, 0xF8, 0xD8, 0x78, 0x3E, 0x1B, 0x1D, 0x8C, 0xC6,
  0x70, 0x18, 0xCE, 0x63, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x60, 0x3E, 0xE3,
  0xFF, 0x77, 0x76, 0x77, 0x66, 0x66, 0x66, 0x66, 0x6E, 0xEE, 0xCC, 0xCC,
  0xCC, 0x36, 0x3F, 0x77, 0x77, 0x66, 0x66, 0x66, 0xE6, 0xCE, 0xCC, 0x1E,
  0x3E, 0x77, 0x67, 0x67, 0xE6, 0xE6, 0xEE, 0x7C, 0x78, 0x1B, 0x0F, 0xCE,
  0x66, 0x33, 0x19, 0x9C, 0xCC, 0xE6, 0x7E, 0x37, 0x18, 0x0C, 0x0E, 0x06,
  0x00, 0x1F, 0x3F, 0x77, 0x67, 0x67, 0x66, 0xE6, 0xE6, 0xFE, 0x7C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x36, 0x79, 0xF3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x80,
  0x3E, 0xF9, 0x93, 0x87, 0x87, 0x07, 0x4E, 0xF9, 0xE0, 0x31, 0x1F, 0xF6,
  0x73, 0x18, 0xC6, 0x39, 0xC0, 0x33, 0x33, 0x73, 0x67, 0x66, 0x66, 0x66,
  0xEE, 0xFC, 0x7C, 0xC7, 0x9F, 0x36, 0xED, 0x9B, 0x3C, 0x78, 0xE1, 0xC0,
  0xCE, 0x79, 0xDB, 0x7B, 0x6F, 0x6D, 0x79, 0xEF, 0x3D, 0x47, 0x38, 0xE7,
  0x1C, 0xC0, 0x3B, 0x8D, 0x87, 0xC3, 0xC1, 0xC0, 0xE0, 0xF0, 0x7C, 0x66,
  0x73, 0x00, 0x31, 0x99, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78, 0x18,
  0x0C, 0x0E, 0x06, 0x0F, 0x07, 0x00, 0x3F, 0x3E, 0x06, 0x0C, 0x1C, 0x18,
  0x30, 0x70, 0x7C, 0xFC, 0x06, 0x1C, 0x70, 0xC1, 0x83, 0x0E, 0x38, 0xE0,
  0xE0, 0xC3, 0x86, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x38, 0x30, 0x61, 0xC3, 0x87, 0x07, 0x1E, 0x70, 0xC1, 0x83, 0x0E, 0x38,
  0x60, 0xE3, 0xFE, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 8, 15, 8, 0, -14 },
  { 44, 11, 13, 13, 1, -13 },
  { 62, 9, 13, 9, 0, -13 },
  { 77, 3, 5, 4, 2, -13 },
  { 79, 6, 16, 5, 0, -13 },
  { 91, 6, 16, 5, -1, -13 },
  { 103, 7, 8, 7, 1, -14 },
  { 110, 7, 9, 8, 1, -11 },
  { 118, 4, 4, 4, -1, -2 },
  { 120, 5, 2, 5, 0, -6 },
  { 122, 3, 3, 4, 0, -3 },
  { 124, 9, 13, 7, -1, -13 },
  { 139, 8, 13, 8, 0, -13 },
  { 152, 6, 13, 8, 2, -13 },
  { 162, 9, 13, 8, -1, -13 },
  { 177, 8, 13, 8, 0, -13 },
  { 190, 8, 13, 8, 0, -13 },
  { 203, 8, 13, 8, 0, -13 },
  { 216, 8, 13, 8, 0, -13 },
  { 229, 9, 13, 8, 0, -13 },
  { 244, 8, 13, 8, 0, -13 },
  { 257, 8, 13, 8, 0, -13 },
  { 270, 4, 10, 4, 0, -10 },
  { 275, 5, 12, 4, -1, -10 },
  { 283, 7, 9, 8, 1, -11 },
  { 291, 7, 5, 8, 1, -9 },
  { 296, 7, 9, 8, 1, -11 },
  { 304, 7, 13, 6, 0, -13 },
  { 316, 12, 14, 12, 0, -13 },
  { 337, 8, 13, 8, -1, -13 },
  { 350, 9, 13, 9, 0, -13 },
  { 365, 8, 13, 8, 1, -13 },
  { 378, 9, 13, 9, 0, -13 },
  { 393, 8, 13, 7, 0, -13 },
  { 406, 8, 13, 7, 0, -13 },
  { 419, 9, 13, 9, 1, -13 },
  { 434, 10, 13, 10, 0, -13 },
  { 451, 8, 13, 6, -1, -13 },
  { 464, 8, 17, 4, -3, -13 },
  { 481, 10, 13, 8, 0, -13 },
  { 498, 6, 13, 7, 0, -13 },
  { 508, 13, 13, 13, 0, -13 },
  { 530, 11, 13, 10, 0, -13 },
  { 548, 9, 13, 10, 1, -13 },
  { 563, 9, 13, 8, 0, -13 },
  { 578, 9, 16, 10, 1, -13 },
  { 596, 9, 13, 8, 0, -13 },
  { 611, 8, 13, 7, 0, -13 },
  { 624, 8, 13, 7, 1, -13 },
  { 637, 9, 13, 9, 1, -13 },
  { 652, 8, 13, 8, 2, -13 },
  { 665, 13, 13, 13, 1, -13 },
  { 687, 10, 13, 8, -1, -13 },
  { 704, 7, 13, 8, 2, -13 },
  { 716, 9, 13, 7, -1, -13 },
  { 731, 7, 16, 5, -1, -13 },
  { 745, 4, 13, 7, 2, -13 },
  { 752, 7, 16, 5, -1, -13 },
  { 766, 8, 8, 8, 0, -13 },
  { 774, 6, 1, 6, -2, 2 },
  { 775, 3, 3, 5, 3, -14 },
  { 777, 8, 10, 8, 0, -10 },
  { 787, 8, 14, 8, 0, -14 },
  { 801, 7, 10, 7, 0, -10 },
  { 810, 9, 14, 8, 0, -14 },
  { 826, 7, 10, 8, 0, -10 },
  { 835, 9, 18, 5, -2, -14 },
  { 856, 8, 14, 8, 0, -10 },
  { 870, 8, 14, 8, 0, -14 },
  { 884, 5, 14, 4, 0, -14 },
  { 893, 7, 18, 4, -2, -14 },
  { 909, 9, 14, 8, 0, -14 },
  { 925, 5, 14, 4, 0, -14 },
  { 934, 12, 10, 12, 0, -10 },
  { 949, 8, 10, 8, 0, -10 },
  { 959, 8, 10, 8, 0, -10 },
  { 969, 9, 14, 8, -1, -10 },
  { 985, 8, 14, 8, 0, -10 },
  { 999, 7, 10, 6, 0, -10 },
  { 1008, 7, 10, 6, 0, -10 },
  { 1017, 5, 12, 5, 1, -12 },
  { 1025, 8, 10, 8, 0, -10 },
  { 1035, 7, 10, 7, 1, -10 },
  { 1044, 11, 10, 11, 1, -10 },
  { 1058, 9, 10, 7, -1, -10 },
  { 1070, 9, 14, 7, -1, -10 },
  { 1086, 8, 10, 6, -1, -10 },
  { 1096, 7, 16, 6, 0, -13 },
  { 1110, 2, 18, 7, 2, -14 },
  { 1115, 7, 16, 6, -1, -13 },
  { 1129, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC18PT7B_H_
