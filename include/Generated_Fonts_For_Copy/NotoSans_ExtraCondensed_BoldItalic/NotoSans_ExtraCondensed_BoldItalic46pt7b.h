#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3F, 0x3E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x7C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x7C, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x67, 0x03, 0xF2, 0x10, 0x1F,
  0xB0, 0x00, 0xFD, 0x80, 0x07, 0xEC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0D, 0xF8, 0x00, 0x4F, 0xC2,
  0x06, 0x7E, 0x18, 0x33, 0xF0, 0xF1, 0xBF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x3F, 0xC0, 0x3C, 0x03, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1E,
  0x01, 0xE7, 0x81, 0xE0, 0x1E, 0x3E, 0x1F, 0x00, 0xF1, 0xF0, 0xF0, 0x0F,
  0x8F, 0x0F, 0x80, 0x78, 0x78, 0x78, 0x03, 0xC3, 0xC7, 0xC0, 0x1E, 0x1E,
  0x3C, 0x00, 0xF1, 0xF3, 0xE0, 0x0F, 0x8F, 0x1E, 0x00, 0x7C, 0x79, 0xF1,
  0xF3, 0xE7, 0xCF, 0x1F, 0xDF, 0x3C, 0xF1, 0xFF, 0x7F, 0xE7, 0x9F, 0xFB,
  0xFE, 0x79, 0xF3, 0xDF, 0xE7, 0xCF, 0x1E, 0x7E, 0x3C, 0xF8, 0xF0, 0x03,
  0xE7, 0x87, 0x80, 0x1E, 0x3C, 0x3C, 0x01, 0xF1, 0xE1, 0xE0, 0x0F, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0xF0, 0x07, 0x87, 0x87, 0x80, 0x7C, 0x3C, 0x7C,
  0x03, 0xC1, 0xE3, 0xC0, 0x3C, 0x0F, 0x1E, 0x03, 0xE0, 0x7F, 0xE0, 0x1E,
  0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0x0F, 0xFC, 0x7E, 0x1F, 0xFE, 0x7E, 0x3F, 0x7E, 0x7C, 0x3E, 0x7E,
  0xFC, 0x7E, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x1F,
  0xF0, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF3, 0xF0, 0x1F, 0xE3,
  0xF8, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x3C, 0x07, 0x1E, 0x03, 0xCF,
  0x0B, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xF7, 0xC3, 0xFB, 0xF0, 0x78, 0xFC, 0x18, 0x7C,
  0x04, 0x38, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xEF, 0xFF, 0x00, 0x3C, 0xFD,
  0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0x81, 0xFB, 0xF0,
  0x3F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1,
  0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0x7E, 0xF9, 0xF9, 0xF1, 0xE7, 0xE1, 0x8F, 0xC1, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xC7, 0xF0, 0x1C, 0x0F, 0xC0, 0x20, 0x3F, 0x00,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0x0F,
  0xF0, 0x10, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x08, 0x01, 0xFC, 0x38, 0x0F,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x01, 0xEF, 0xC0, 0x1F,
  0x7E, 0x00, 0xF3, 0xF0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x8F, 0xC0,
  0x78, 0x7E, 0x03, 0xC3, 0xE0, 0x3C, 0x1F, 0x03, 0xC1, 0xF8, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x20,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFB, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x73, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x20, 0x0F, 0xC1, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x3E, 0x03, 0xFF, 0xF0, 0x3E, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x87, 0xF1, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE,
  0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0x7F, 0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F,
  0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xF3, 0xF0,
  0x7F, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x3F, 0x10, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0xE0, 0x70,
  0x78, 0x3F, 0xE3, 0xC3, 0xC3, 0xFF, 0x1E, 0x3C, 0x3F, 0xF8, 0xF1, 0xE3,
  0xE7, 0xC7, 0x9E, 0x1E, 0x3C, 0x38, 0xF1, 0xE1, 0xE1, 0xCF, 0x0F, 0x0F,
  0x1E, 0x78, 0xF0, 0xF8, 0xF3, 0xC7, 0x87, 0x87, 0x9E, 0x3C, 0x3C, 0x38,
  0xE1, 0xE1, 0xE3, 0xCF, 0x1E, 0x1F, 0x1E, 0x78, 0xF0, 0xF0, 0xE3, 0xC7,
  0x87, 0x8F, 0x1E, 0x3E, 0x7C, 0x70, 0xF1, 0xFF, 0xFF, 0x87, 0x87, 0xF7,
  0xF8, 0x3C, 0x3F, 0x1F, 0x81, 0xE0, 0x70, 0x70, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x3F,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF8, 0x3F, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xF8, 0xFE, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFC, 0x70,
  0x3F, 0x80, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x1C, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0x80, 0xFE,
  0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0xFE,
  0x1F, 0xE1, 0xF8, 0x7F, 0x83, 0xF7, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x07, 0x83, 0xFC, 0x02,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x0F, 0xFC, 0xFE, 0x1F, 0xF9, 0xF8, 0x3F, 0xF3, 0xF0, 0x7F, 0xC7, 0xE0,
  0xFF, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF8, 0x7E,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF3, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1,
  0xF7, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0xFB, 0xF0, 0x3E, 0xF8,
  0x7D, 0xF0, 0x1F, 0x7C, 0x3E, 0xF8, 0x1F, 0xBE, 0x3E, 0xFC, 0x0F, 0xDF,
  0x1F, 0x7E, 0x07, 0xCF, 0x9F, 0x3F, 0x03, 0xE7, 0xCF, 0x9F, 0x01, 0xF3,
  0xEF, 0x8F, 0x81, 0xF9, 0xF7, 0xCF, 0xC0, 0xFC, 0xFF, 0xC7, 0xE0, 0x7C,
  0x7F, 0xE3, 0xF0, 0x3E, 0x3F, 0xE1, 0xF0, 0x3F, 0x1F, 0xF1, 0xF8, 0x1F,
  0x8F, 0xF8, 0xFC, 0x0F, 0xC7, 0xF8, 0x7E, 0x07, 0xC3, 0xFC, 0x3E, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x80, 0x7C,
  0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8,
  0x0F, 0x80, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x7E, 0x07, 0xFE, 0x0F, 0xC0,
  0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x3E, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xE1,
  0xF8, 0x1F, 0x3E, 0x3E, 0x03, 0xE7, 0xC7, 0xC0, 0x7C, 0xF8, 0xF8, 0x1F,
  0x9F, 0x3F, 0x03, 0xF3, 0xE7, 0xE0, 0x7C, 0x7E, 0xF8, 0x0F, 0x87, 0xDF,
  0x01, 0xF0, 0xFB, 0xE0, 0x7E, 0x1F, 0xFC, 0x0F, 0xC3, 0xFF, 0x81, 0xF0,
  0x7F, 0xE0, 0x3E, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0xF0,
  0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x3F, 0x01,
  0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F,
  0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x03,
  0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F,
  0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x1F, 0xC3,
  0xF0, 0x3F, 0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E,
  0x7F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x7F, 0x07, 0xE3, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x3F,
  0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00,
  0xFE, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x8F, 0xF0, 0x3E, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xF7, 0xC0, 0x7F, 0x03, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0x00, 0x7F, 0x06,
  0x01, 0xF8, 0x1E, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0,
  0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x0F,
  0xDF, 0x80, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x03,
  0xE3, 0xF0, 0x3F, 0x03, 0xF1, 0xF0, 0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0xC0,
  0xF8, 0x7C, 0x1F, 0xE0, 0xFC, 0x3E, 0x0F, 0xF0, 0x7E, 0x1F, 0x07, 0xF8,
  0x7E, 0x0F, 0x87, 0xFC, 0x3F, 0x07, 0xC3, 0xDE, 0x1F, 0x03, 0xE3, 0xFF,
  0x1F, 0x81, 0xF1, 0xFF, 0x8F, 0xC0, 0xF8, 0xF7, 0xCF, 0xC0, 0x7C, 0xFB,
  0xE7, 0xE0, 0x3E, 0x7D, 0xF3, 0xE0, 0x1F, 0x7C, 0xFB, 0xF0, 0x0F, 0xBE,
  0x7D, 0xF8, 0x0F, 0xDF, 0x3E, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0xFE, 0x7E,
  0x7E, 0x3F, 0x1F, 0x1F, 0x00, 0x40, 0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7C,
  0x1F, 0xFB, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x3F, 0x87, 0xF0,
  0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x01, 0xF9, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x30, 0x07, 0xEF, 0xC0, 0x7D, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xF1, 0xF8, 0x7F, 0xBF, 0x8F, 0xFF, 0xF0, 0xFB, 0xFE, 0x0F,
  0xBF, 0xC0, 0xF1, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7E, 0x08, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE1, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x83, 0xF0, 0x0F, 0xE7, 0xC0, 0x3F, 0xEF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x87, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xBE, 0x00, 0xFC, 0x78, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F,
  0x7E, 0x0F, 0x9F, 0x87, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x08, 0xFE, 0x0C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x9F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC, 0xFC, 0x07, 0xFD,
  0xF0, 0x0F, 0xFB, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF8, 0xFE,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xEF, 0xC0, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x20, 0x0F, 0xC0, 0x70, 0x3F, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x10, 0x07, 0xCF, 0xC0, 0x7D, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x8F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x1F,
  0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03,
  0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xDF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7E,
  0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F,
  0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x40, 0x1E, 0x3F, 0x0F, 0xC0,
  0x7B, 0xFE, 0x7F, 0x83, 0xEF, 0xFB, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF7, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x83,
  0xF0, 0xFC, 0x7E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x0F, 0x87, 0xC1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0xFC, 0x1F, 0x07, 0xE3, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xF0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E, 0x0F, 0xC7,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE0, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF0,
  0x7E, 0x1F, 0x8F, 0xC1, 0xF0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0x00, 0x78, 0xFC, 0x07,
  0x9F, 0xE0, 0x7B, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x3E,
  0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3E, 0x0F,
  0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0, 0x00,
  0x38, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xE3, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8,
  0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC7,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xE3, 0xF0, 0x03, 0xCF,
  0xF0, 0x0F, 0xBF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xBF, 0xC0, 0x3E, 0x7F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x08, 0x0F, 0xCF, 0x80, 0xFF, 0x7C, 0x0F,
  0xFB, 0xE0, 0xFF, 0xFF, 0x0F, 0xEF, 0xF8, 0x7E, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0,
  0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x01, 0xF9, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x03, 0xE7, 0xC1, 0xE7, 0xE1,
  0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x30, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFE, 0x78, 0x7E, 0x08, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x8C, 0x1F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xF3, 0xFF, 0xCF, 0xFE, 0x7F,
  0xF9, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xFB, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E,
  0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07,
  0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0,
  0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFB, 0xE0, 0x3F, 0x3E, 0x00, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xFB,
  0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8,
  0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xFC,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x1F, 0xC1, 0xFB, 0xE0, 0xFE, 0x1F, 0x9F, 0x07, 0xF0,
  0xFC, 0xF8, 0x7F, 0x87, 0xC7, 0xC3, 0xFC, 0x7E, 0x3E, 0x3F, 0xE3, 0xE1,
  0xF1, 0xFF, 0x1F, 0x0F, 0x8F, 0xF1, 0xF8, 0x7C, 0xFF, 0x8F, 0x83, 0xE7,
  0xBC, 0xFC, 0x1F, 0x3D, 0xE7, 0xC0, 0xFB, 0xEF, 0x3E, 0x07, 0xDE, 0x7B,
  0xF0, 0x3F, 0xF3, 0xDF, 0x01, 0xFF, 0x1E, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x07, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xA0, 0x1F, 0xE4, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 33, 12, 0, -33 },
  { 55, 16, 12, 18, 4, -33 },
  { 79, 23, 33, 22, 0, -33 },
  { 174, 21, 38, 20, 0, -35 },
  { 274, 29, 33, 32, 2, -33 },
  { 394, 24, 33, 24, 0, -33 },
  { 493, 8, 12, 11, 4, -33 },
  { 505, 15, 40, 12, 1, -33 },
  { 580, 16, 40, 13, -4, -33 },
  { 660, 17, 19, 19, 4, -35 },
  { 701, 19, 22, 21, 2, -27 },
  { 754, 10, 12, 11, -2, -6 },
  { 769, 13, 5, 13, 0, -15 },
  { 778, 7, 7, 11, 0, -7 },
  { 785, 23, 33, 17, -2, -33 },
  { 880, 19, 33, 20, 1, -33 },
  { 959, 15, 33, 20, 4, -33 },
  { 1021, 22, 33, 20, -2, -33 },
  { 1112, 22, 33, 20, -1, -33 },
  { 1203, 21, 33, 20, -1, -33 },
  { 1290, 21, 33, 20, 0, -33 },
  { 1377, 20, 33, 20, 1, -33 },
  { 1460, 21, 33, 20, 1, -33 },
  { 1547, 21, 33, 20, 0, -33 },
  { 1634, 20, 33, 20, 0, -33 },
  { 1717, 11, 25, 11, 0, -25 },
  { 1752, 14, 31, 11, -3, -25 },
  { 1807, 19, 21, 21, 2, -27 },
  { 1857, 19, 14, 21, 2, -23 },
  { 1891, 19, 21, 21, 2, -27 },
  { 1941, 16, 33, 15, 1, -33 },
  { 2007, 29, 37, 30, 1, -33 },
  { 2142, 22, 33, 22, -3, -33 },
  { 2233, 22, 33, 22, 0, -33 },
  { 2324, 21, 33, 20, 2, -33 },
  { 2411, 23, 33, 24, 0, -33 },
  { 2506, 21, 33, 18, 0, -33 },
  { 2593, 21, 33, 18, 0, -33 },
  { 2680, 23, 33, 24, 2, -33 },
  { 2775, 26, 33, 24, 0, -33 },
  { 2883, 20, 33, 15, -2, -33 },
  { 2966, 20, 43, 11, -7, -33 },
  { 3074, 25, 33, 21, 0, -33 },
  { 3178, 15, 33, 18, 0, -33 },
  { 3240, 33, 33, 32, 0, -33 },
  { 3377, 27, 33, 26, 0, -33 },
  { 3489, 23, 33, 25, 2, -33 },
  { 3584, 23, 33, 21, 0, -33 },
  { 3679, 23, 41, 25, 2, -33 },
  { 3797, 22, 33, 21, 0, -33 },
  { 3888, 22, 33, 19, -1, -33 },
  { 3979, 19, 33, 18, 3, -33 },
  { 4058, 23, 33, 24, 2, -33 },
  { 4153, 21, 33, 21, 4, -33 },
  { 4240, 33, 33, 32, 3, -33 },
  { 4377, 27, 33, 20, -3, -33 },
  { 4489, 20, 33, 20, 4, -33 },
  { 4572, 23, 33, 18, -2, -33 },
  { 4667, 18, 40, 13, -2, -33 },
  { 4757, 9, 33, 17, 5, -33 },
  { 4795, 18, 40, 13, -3, -33 },
  { 4885, 20, 20, 20, 0, -33 },
  { 4935, 15, 3, 15, -4, 4 },
  { 4941, 8, 7, 14, 7, -35 },
  { 4948, 21, 26, 21, 1, -26 },
  { 5017, 20, 35, 21, 0, -35 },
  { 5105, 17, 26, 17, 1, -26 },
  { 5161, 23, 35, 21, 1, -35 },
  { 5262, 18, 25, 19, 1, -25 },
  { 5319, 23, 46, 13, -5, -35 },
  { 5452, 23, 37, 21, -1, -26 },
  { 5559, 20, 35, 21, 0, -35 },
  { 5647, 13, 35, 11, 0, -35 },
  { 5704, 19, 46, 11, -6, -35 },
  { 5814, 22, 35, 20, 0, -35 },
  { 5911, 13, 35, 10, 0, -35 },
  { 5968, 30, 26, 31, 0, -26 },
  { 6066, 20, 26, 21, 0, -26 },
  { 6131, 19, 27, 21, 1, -26 },
  { 6196, 23, 37, 21, -3, -26 },
  { 6303, 21, 37, 21, 1, -26 },
  { 6401, 17, 26, 15, 0, -26 },
  { 6457, 17, 26, 17, 0, -26 },
  { 6513, 14, 30, 13, 1, -30 },
  { 6566, 20, 25, 21, 1, -25 },
  { 6629, 18, 25, 18, 3, -25 },
  { 6686, 29, 25, 28, 2, -25 },
  { 6777, 23, 25, 19, -2, -25 },
  { 6849, 25, 36, 18, -4, -25 },
  { 6962, 19, 25, 16, -2, -25 },
  { 7022, 19, 40, 16, 0, -33 },
  { 7117, 5, 45, 17, 6, -35 },
  { 7146, 18, 40, 16, -3, -33 },
  { 7236, 19, 8, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC46PT7B_H_
