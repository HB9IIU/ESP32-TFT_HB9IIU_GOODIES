#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x26, 0x66, 0x40, 0xCC, 0x7A, 0xF7, 0xA0, 0x1E, 0x28, 0x53,
  0xF2, 0x85, 0x3F, 0x2C, 0x51, 0xE0, 0x08, 0x63, 0xDD, 0x70, 0xE1, 0x8A,
  0xBB, 0xE2, 0x08, 0x62, 0xF6, 0xB4, 0xAC, 0xAB, 0xD5, 0x15, 0x25, 0x2D,
  0x46, 0x1C, 0x78, 0xB1, 0xC3, 0x0E, 0xF7, 0x6E, 0xDD, 0xF8, 0x69, 0x60,
  0x19, 0x88, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x80, 0x10, 0x86, 0x31, 0x88,
  0x46, 0x33, 0x19, 0x80, 0x35, 0xBE, 0x7D, 0x2C, 0x21, 0x3F, 0xF2, 0x10,
  0x6D, 0x60, 0xFF, 0xF0, 0x06, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x61,
  0x80, 0x1C, 0xF6, 0xDB, 0x4F, 0x3C, 0xB6, 0xF9, 0xC0, 0x19, 0xFC, 0xE3,
  0x18, 0x84, 0x63, 0x00, 0x1E, 0x6C, 0x98, 0x30, 0xC1, 0x06, 0x18, 0x7D,
  0xF8, 0x3C, 0xB0, 0xC3, 0x38, 0xE1, 0x86, 0xBB, 0xC0, 0x0C, 0x71, 0xCA,
  0x69, 0x6F, 0xFF, 0x10, 0xC0, 0x3C, 0xF2, 0x18, 0x78, 0x60, 0x86, 0xFB,
  0xC0, 0x1C, 0xF2, 0x1A, 0x79, 0xBC, 0xF2, 0xF9, 0xC0, 0x3E, 0xF8, 0x30,
  0x41, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x3D, 0xB6, 0xDB, 0x39, 0xEC, 0xB2,
  0xD9, 0xC0, 0x3D, 0xF6, 0xDB, 0x6D, 0xF0, 0x86, 0xB3, 0x80, 0x2C, 0x80,
  0x36, 0x13, 0x10, 0x00, 0x66, 0x4C, 0x09, 0xF9, 0xC3, 0x84, 0xF8, 0x01,
  0xF0, 0x87, 0x0E, 0x7E, 0x40, 0x7A, 0xC2, 0x33, 0x31, 0x80, 0x46, 0x00,
  0x0F, 0x08, 0xC8, 0x29, 0xD5, 0x6A, 0xA7, 0x55, 0xBE, 0xC0, 0x20, 0x0F,
  0x00, 0x0E, 0x1C, 0x78, 0xF3, 0x66, 0xCF, 0xB3, 0x67, 0x8C, 0x3C, 0x7C,
  0x9B, 0x27, 0xCF, 0x93, 0x66, 0xF9, 0xF0, 0x1E, 0x79, 0xC3, 0x06, 0x0C,
  0x30, 0x20, 0x78, 0xF0, 0x3C, 0x7C, 0x9B, 0x36, 0x6C, 0xD9, 0xE6, 0xF9,
  0xE0, 0x3C, 0xF2, 0x18, 0x79, 0xE6, 0x30, 0xF3, 0xC0, 0x3C, 0xF2, 0x18,
  0x79, 0xE6, 0x30, 0xC3, 0x00, 0x1F, 0x3E, 0x30, 0x60, 0x6E, 0x6E, 0xC6,
  0x64, 0x7C, 0x7C, 0x33, 0x33, 0x22, 0x66, 0x7E, 0x7E, 0x66, 0xCC, 0xCC,
  0xCC, 0x3C, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x33, 0xE0, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x84, 0x30, 0xC3, 0x38, 0xE0, 0x37, 0x36, 0x2C, 0x78, 0x78,
  0x78, 0x58, 0xD8, 0xD8, 0xCC, 0x31, 0x88, 0xC6, 0x31, 0x98, 0xFF, 0x80,
  0x31, 0xCC, 0x73, 0x1D, 0xEE, 0x7A, 0x9F, 0xE5, 0xDB, 0x76, 0xD9, 0x36,
  0xC0, 0x31, 0x33, 0x33, 0x7B, 0x7A, 0x7E, 0x4E, 0xCE, 0xCE, 0xCC, 0x1E,
  0x3E, 0x63, 0x63, 0x66, 0x66, 0xC6, 0x46, 0x7C, 0x78, 0x3C, 0x7C, 0x9B,
  0x36, 0xCF, 0x98, 0x60, 0xC1, 0x80, 0x1E, 0x3E, 0x63, 0x63, 0x66, 0x66,
  0xC6, 0x46, 0x7C, 0x78, 0x18, 0x1C, 0x3C, 0x7C, 0x9B, 0x26, 0xCF, 0x16,
  0x6C, 0xD9, 0x98, 0x3D, 0xF6, 0x18, 0x30, 0xE1, 0x86, 0xFB, 0xC0, 0xFF,
  0xE2, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x00, 0x33, 0x32, 0x66, 0x66, 0x66,
  0x66, 0x6C, 0xCC, 0x7C, 0x78, 0xC7, 0x9B, 0x36, 0xCD, 0x9A, 0x3C, 0x70,
  0xE1, 0xC0, 0xCC, 0xF3, 0x2D, 0xDB, 0x76, 0xDD, 0x3F, 0xCE, 0xE3, 0xB8,
  0xEE, 0x33, 0x00, 0x33, 0x16, 0x1E, 0x1C, 0x1C, 0x18, 0x3C, 0x2C, 0x6C,
  0xCC, 0xCF, 0x25, 0x94, 0x71, 0x86, 0x18, 0x43, 0x00, 0x1E, 0x7C, 0x30,
  0x61, 0x83, 0x0C, 0x30, 0x7D, 0xF0, 0x1C, 0x41, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x84, 0x3C, 0xC9, 0x26, 0xDB, 0x64, 0x3C, 0x21, 0x86, 0x18, 0x41,
  0x0C, 0x30, 0xC2, 0x38, 0x18, 0x63, 0x9A, 0x4F, 0x30, 0xF0, 0xC9, 0x80,
  0x36, 0xF9, 0xB2, 0x6C, 0xD9, 0x36, 0x3C, 0x30, 0xC2, 0x1A, 0x7D, 0xB6,
  0xD3, 0xCF, 0x6F, 0x00, 0x1D, 0xE6, 0x10, 0xC3, 0x0D, 0x1C, 0x06, 0x0C,
  0x19, 0xB7, 0xCD, 0x93, 0x66, 0xC9, 0xB1, 0xA0, 0x18, 0xF6, 0xD6, 0xF3,
  0x0C, 0x9E, 0x07, 0x0E, 0x0C, 0x1E, 0x1C, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x20, 0xE0, 0x36, 0xF9, 0xB2, 0x6C, 0xD9, 0x36, 0x3C, 0x19,
  0x33, 0xC0, 0x30, 0xC2, 0x1B, 0x7D, 0xB6, 0xD3, 0xCB, 0x6D, 0x80, 0x33,
  0x02, 0x66, 0x64, 0xCC, 0xC0, 0x0C, 0x30, 0x02, 0x18, 0x61, 0x84, 0x30,
  0xC3, 0x0C, 0x63, 0x80, 0x30, 0x60, 0x81, 0x36, 0xCF, 0x1C, 0x38, 0xD9,
  0xB3, 0x60, 0x33, 0x26, 0x66, 0x64, 0xCC, 0xC0, 0x29, 0xBF, 0xDB, 0x6D,
  0xB4, 0x9E, 0x4B, 0x65, 0xB6, 0x29, 0xF6, 0xDB, 0x4F, 0x2C, 0xB6, 0x19,
  0xF6, 0xD3, 0xCF, 0x3D, 0x9C, 0x16, 0x7C, 0xD9, 0xB2, 0x6C, 0xDF, 0x3E,
  0x60, 0x83, 0x00, 0x36, 0xF9, 0xB2, 0x6C, 0xD9, 0x36, 0x3C, 0x18, 0x30,
  0xC0, 0x6B, 0xD8, 0xC4, 0x63, 0x18, 0x3B, 0xD8, 0xC3, 0x1A, 0xDE, 0x31,
  0xDC, 0xC6, 0x21, 0x1A, 0x60, 0x65, 0x96, 0xDB, 0x4F, 0x2D, 0x9E, 0xCE,
  0xE5, 0x6A, 0x73, 0x98, 0xD9, 0x9B, 0xBA, 0xAE, 0xBE, 0xFC, 0xDC, 0xD8,
  0x36, 0x6C, 0xF0, 0xC1, 0x87, 0x1A, 0x66, 0x32, 0x6C, 0xD1, 0xE3, 0xC7,
  0x0E, 0x18, 0x30, 0xC3, 0x80, 0x3C, 0xF0, 0x86, 0x30, 0x86, 0x3E, 0x1C,
  0x63, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x86, 0x18, 0xFF, 0xFC, 0x38, 0xE1,
  0x86, 0x10, 0x71, 0x8C, 0x30, 0x86, 0x38, 0xED, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 6, 1, -10 },
  { 9, 7, 10, 7, 0, -10 },
  { 18, 6, 12, 6, 0, -11 },
  { 27, 8, 10, 10, 1, -10 },
  { 37, 7, 10, 7, 0, -10 },
  { 46, 3, 4, 3, 1, -10 },
  { 48, 5, 12, 4, 0, -10 },
  { 56, 5, 12, 4, -1, -10 },
  { 64, 5, 6, 6, 1, -11 },
  { 68, 5, 6, 7, 1, -8 },
  { 72, 3, 4, 3, -1, -2 },
  { 74, 4, 2, 4, 0, -5 },
  { 75, 2, 2, 3, 0, -2 },
  { 76, 7, 10, 5, -1, -10 },
  { 85, 6, 10, 6, 0, -10 },
  { 93, 5, 10, 6, 1, -10 },
  { 100, 7, 10, 6, -1, -10 },
  { 109, 6, 10, 6, 0, -10 },
  { 117, 6, 10, 6, 0, -10 },
  { 125, 6, 10, 6, 0, -10 },
  { 133, 6, 10, 6, 0, -10 },
  { 141, 7, 10, 6, 0, -10 },
  { 150, 6, 10, 6, 0, -10 },
  { 158, 6, 10, 6, 0, -10 },
  { 166, 3, 8, 3, 0, -8 },
  { 169, 4, 10, 3, -1, -8 },
  { 174, 5, 6, 7, 1, -8 },
  { 178, 5, 4, 7, 1, -7 },
  { 181, 5, 6, 7, 1, -8 },
  { 185, 5, 10, 5, 0, -10 },
  { 192, 9, 11, 9, 0, -10 },
  { 205, 7, 10, 7, -1, -10 },
  { 214, 7, 10, 7, 0, -10 },
  { 223, 7, 10, 6, 0, -10 },
  { 232, 7, 10, 7, 0, -10 },
  { 241, 6, 10, 6, 0, -10 },
  { 249, 6, 10, 5, 0, -10 },
  { 257, 8, 10, 7, 0, -10 },
  { 267, 8, 10, 7, 0, -10 },
  { 277, 6, 10, 4, -1, -10 },
  { 285, 6, 13, 3, -2, -10 },
  { 295, 8, 10, 6, 0, -10 },
  { 305, 5, 10, 5, 0, -10 },
  { 312, 10, 10, 10, 0, -10 },
  { 325, 8, 10, 8, 0, -10 },
  { 335, 8, 10, 8, 0, -10 },
  { 345, 7, 10, 6, 0, -10 },
  { 354, 8, 12, 8, 0, -10 },
  { 366, 7, 10, 6, 0, -10 },
  { 375, 6, 10, 6, 0, -10 },
  { 383, 6, 10, 6, 1, -10 },
  { 391, 8, 10, 7, 0, -10 },
  { 401, 7, 10, 7, 1, -10 },
  { 410, 10, 10, 10, 1, -10 },
  { 423, 8, 10, 6, -1, -10 },
  { 433, 6, 10, 6, 1, -10 },
  { 441, 7, 10, 5, -1, -10 },
  { 450, 6, 12, 4, -1, -10 },
  { 459, 3, 10, 5, 1, -10 },
  { 463, 6, 12, 4, -1, -10 },
  { 472, 6, 6, 6, 0, -10 },
  { 477, 4, 1, 5, -1, 1 },
  { 478, 3, 3, 4, 2, -11 },
  { 480, 7, 8, 6, 0, -8 },
  { 487, 6, 11, 6, 0, -11 },
  { 496, 6, 8, 5, 0, -8 },
  { 502, 7, 11, 6, 0, -11 },
  { 512, 6, 8, 6, 0, -8 },
  { 518, 8, 14, 4, -2, -11 },
  { 532, 7, 11, 6, 0, -8 },
  { 542, 6, 11, 6, 0, -11 },
  { 551, 4, 11, 3, 0, -11 },
  { 557, 6, 14, 3, -2, -11 },
  { 568, 7, 11, 6, 0, -11 },
  { 578, 4, 11, 3, 0, -11 },
  { 584, 9, 8, 9, 0, -8 },
  { 593, 6, 8, 6, 0, -8 },
  { 599, 6, 8, 6, 0, -8 },
  { 605, 7, 11, 6, -1, -8 },
  { 615, 7, 11, 6, 0, -8 },
  { 625, 5, 8, 5, 0, -8 },
  { 630, 5, 8, 5, 0, -8 },
  { 635, 5, 9, 4, 0, -9 },
  { 641, 6, 8, 6, 0, -8 },
  { 647, 5, 8, 6, 1, -8 },
  { 652, 8, 8, 9, 1, -8 },
  { 660, 7, 8, 6, -1, -8 },
  { 667, 7, 11, 6, -1, -8 },
  { 677, 6, 8, 5, -1, -8 },
  { 683, 6, 12, 5, 0, -10 },
  { 692, 1, 14, 5, 2, -11 },
  { 694, 6, 12, 5, -1, -10 },
  { 703, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC14PT7B_H_
