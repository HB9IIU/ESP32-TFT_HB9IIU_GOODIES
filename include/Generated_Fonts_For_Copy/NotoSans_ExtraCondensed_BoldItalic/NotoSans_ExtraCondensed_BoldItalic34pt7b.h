#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x7C, 0xF7, 0x9F, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF3, 0xC0, 0x00, 0xE7, 0x80,
  0xF3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x7F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x83, 0x8E, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x73, 0x81, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x1E, 0x70, 0x0E,
  0x38, 0x07, 0x3C, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x00,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x0F, 0x24, 0x1E, 0xC0, 0x3D, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x02, 0xF2, 0x0D, 0xE2,
  0x13, 0xC7, 0x2F, 0x9F, 0xFE, 0x3F, 0xFC, 0x7F, 0xE0, 0x0E, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20, 0xFC, 0x0E, 0x0F, 0xE0,
  0xF0, 0x77, 0x07, 0x07, 0x38, 0x70, 0x39, 0xC3, 0x83, 0xCE, 0x38, 0x1C,
  0x71, 0xC0, 0xE3, 0x9C, 0x07, 0x1C, 0xE0, 0x39, 0xCE, 0x39, 0xCE, 0xF7,
  0xEE, 0xF7, 0x3F, 0xFF, 0x7B, 0x9D, 0xF3, 0x9C, 0xE2, 0x3D, 0xC7, 0x01,
  0xCE, 0x38, 0x1C, 0x71, 0xC0, 0xE7, 0x9E, 0x0E, 0x38, 0xE0, 0x71, 0xC7,
  0x07, 0x0E, 0x70, 0x78, 0x7F, 0x83, 0x81, 0xF8, 0x3C, 0x0F, 0x80, 0x00,
  0x60, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x79, 0xE0, 0x38, 0xF0,
  0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x78, 0xFF, 0x3C, 0xFF, 0xBE, 0xFB, 0xDE, 0x79, 0xFF, 0x7C,
  0x7F, 0x3C, 0x3F, 0x9E, 0x1F, 0x8F, 0x0F, 0xC7, 0xCF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0x3F, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xF0,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x07, 0x06, 0x70, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0x03, 0xF8, 0xFB, 0xC7, 0xBE, 0x31,
  0xC1, 0x10, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x78, 0x78, 0x70, 0xF0, 0x7F, 0xBF, 0xDF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xC0, 0x7F, 0x83, 0xFE, 0x1F, 0x7C, 0x78, 0xF3, 0xE3, 0xCF, 0x1F,
  0x7C, 0x7D, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xE1, 0xEF, 0x0F,
  0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7E, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xE3,
  0xFC, 0xFF, 0xBE, 0xF3, 0xBE, 0x27, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x00, 0x30, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F,
  0xBF, 0x06, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x60, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF0, 0xF3, 0xE0, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC8, 0x1F, 0x1F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0xEF, 0x01, 0xFC, 0x07, 0x78, 0x1C, 0xF0, 0x39,
  0xE0, 0xE7, 0xC3, 0x8F, 0x07, 0x1E, 0x1C, 0x3C, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC1,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC4, 0x0F, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x3C,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFC, 0x41, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x79, 0xC1, 0xEF, 0xC3, 0xFF, 0x87, 0xFF, 0x9F, 0x9F,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F,
  0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x1F, 0x3C, 0x3E, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xFC, 0x3E, 0x7C, 0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F,
  0x9F, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x60, 0x07, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3C,
  0x3E, 0x78, 0x7C, 0xF0, 0xF1, 0xE3, 0xE3, 0xEF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x0F, 0xBC, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x06, 0x0F, 0x1F, 0x1F, 0x1E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0xF8, 0xF0, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x70,
  0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xE1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x03, 0x81,
  0xFE, 0x3F, 0xE3, 0xFF, 0x31, 0xF2, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xC0, 0x78,
  0x07, 0x07, 0x80, 0x38, 0x78, 0x00, 0xE3, 0x87, 0xE7, 0x38, 0xFF, 0x39,
  0xC7, 0x39, 0xDC, 0x73, 0xCE, 0xE7, 0x1C, 0x77, 0x38, 0xE3, 0x71, 0xC7,
  0x3B, 0x9C, 0x79, 0xDC, 0xE3, 0x8E, 0xE7, 0x1C, 0x67, 0x39, 0xE7, 0x39,
  0xFF, 0x71, 0xC7, 0xDF, 0x0E, 0x3C, 0xF0, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x0C, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xEF, 0x01, 0xEF, 0x01, 0xEF, 0x03, 0xCF, 0x03, 0xCF, 0x03, 0xCF,
  0x07, 0x8F, 0x07, 0x8F, 0x0F, 0x8F, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x9F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xFC, 0x3C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0x38, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xCE,
  0x1F, 0x84, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x20, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0x83, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x7C,
  0x78, 0x3E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x1F, 0x87, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE0, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xE7,
  0x07, 0xE0, 0x41, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xCF, 0x8F, 0xF3, 0xE0,
  0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0x7C, 0x3C,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x83, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xFE, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0xF1, 0xF0,
  0x1E, 0x7C, 0x03, 0xCF, 0x00, 0xFB, 0xE0, 0x1E, 0xF8, 0x03, 0xDE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x07,
  0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xE0, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1,
  0xEF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x77, 0x83, 0xCE, 0x7B, 0xC1, 0xE7,
  0x39, 0xE0, 0xF3, 0xBD, 0xF0, 0x79, 0xDC, 0xF0, 0x3C, 0xFE, 0x78, 0x3C,
  0x7F, 0x3C, 0x1E, 0x3F, 0x1E, 0x0F, 0x1F, 0x9F, 0x07, 0x8F, 0x8F, 0x07,
  0x87, 0xC7, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE3, 0xE0, 0x07, 0xC0, 0xF0,
  0x7C, 0x0F, 0x0F, 0xC0, 0xF0, 0xFE, 0x1E, 0x0F, 0xE1, 0xE0, 0xFE, 0x1E,
  0x0F, 0xE1, 0xE1, 0xFE, 0x3E, 0x1E, 0xE3, 0xC1, 0xEF, 0x3C, 0x1E, 0xF3,
  0xC1, 0xEF, 0x3C, 0x3C, 0xF7, 0x83, 0xCF, 0x78, 0x3C, 0x77, 0x83, 0xC7,
  0xF8, 0x3C, 0x7F, 0x87, 0x87, 0xF0, 0x78, 0x7F, 0x07, 0x87, 0xF0, 0x78,
  0x3F, 0x0F, 0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x7C, 0x0F, 0x3E, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0xFB, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE,
  0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0,
  0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07,
  0x87, 0x87, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFD, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x0F, 0x3E,
  0x07, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xC0, 0x7F,
  0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F, 0x07,
  0xCF, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xBF, 0x0F, 0x1F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3D, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x78, 0xF0, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0x7C,
  0x00, 0x30, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7C,
  0x10, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x08, 0x0F, 0x06, 0x0F, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFE, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x07, 0xC3, 0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x87,
  0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0xC3, 0xC1,
  0xF1, 0xF0, 0x78, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0x80,
  0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x1E, 0x0F, 0xBC, 0x1F, 0x07,
  0x9E, 0x0F, 0x87, 0xCF, 0x07, 0xC3, 0xC7, 0x87, 0xE1, 0xE3, 0xC3, 0xE1,
  0xF1, 0xE3, 0xF0, 0xF0, 0xF1, 0xF8, 0xF8, 0x78, 0xFC, 0x78, 0x3C, 0xFE,
  0x3C, 0x1E, 0x77, 0x3E, 0x0F, 0x7B, 0x9E, 0x07, 0xBD, 0xCF, 0x03, 0xDC,
  0xEF, 0x01, 0xFE, 0x77, 0x80, 0xEE, 0x3F, 0xC0, 0x77, 0x1F, 0xC0, 0x7F,
  0x8F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xC3, 0xE0,
  0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78,
  0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xE3,
  0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF,
  0x01, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0xFF, 0x01, 0xDE, 0x07, 0xBC, 0x1E, 0x38, 0x3C, 0x78, 0xF0,
  0xF1, 0xC1, 0xE7, 0x81, 0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0xF9, 0xE7,
  0x8F, 0x3C, 0x07, 0x9E, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xE3, 0xE7, 0xCF,
  0x8F, 0x9E, 0x1F, 0x3C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xC3, 0xE7, 0x87,
  0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x7D, 0xF8, 0xFF, 0xF1, 0xFF, 0xC1,
  0xF7, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xBC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xF9,
  0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3E, 0x78, 0x79,
  0xF0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x9F, 0x3F, 0x3E, 0x7F, 0xF8, 0xFF,
  0xE1, 0xCF, 0x80, 0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xFE, 0x3E, 0x27, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x9E,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF1, 0xF0, 0xFB, 0xF0, 0xFF, 0xF0, 0xFE, 0xE0, 0x7C, 0xE0,
  0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x7D, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF,
  0x1E, 0xFF, 0xF7, 0xFF, 0x3F, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x08, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE7, 0x81, 0xFB,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C,
  0x3C, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1,
  0xE3, 0xE0, 0xF1, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xDE,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x82, 0x07, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xBC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xF8, 0xF9, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0xF9, 0xF1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE0, 0x03, 0x83, 0xC1, 0xE1, 0xF0,
  0x70, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7D,
  0xE0, 0x79, 0xE0, 0x79, 0xF0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF8, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x0E, 0x78,
  0x70, 0x7B, 0xF7, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0x3E, 0x3C,
  0x78, 0xF8, 0xF3, 0xE3, 0xC3, 0xCF, 0x0F, 0x1F, 0x3C, 0x3C, 0x78, 0xF1,
  0xF1, 0xE3, 0xC7, 0x87, 0x9E, 0x1E, 0x1E, 0x78, 0x78, 0xF9, 0xE1, 0xE3,
  0xC7, 0x8F, 0x8F, 0x3E, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F,
  0x1F, 0x1E, 0x00, 0x0E, 0x38, 0x1D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3,
  0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF3,
  0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0xF8, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC0, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE,
  0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x7B, 0xC7, 0xDF, 0xFC, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0x03, 0x8E,
  0x03, 0xDF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0xF8, 0x3C, 0x3C, 0x3E,
  0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xC3, 0xE1, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC, 0x3F, 0xFC, 0x1E, 0xFC,
  0x0F, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x1F, 0xBC,
  0x7F, 0xF1, 0xFF, 0xE3, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3C, 0xF8,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C,
  0x7D, 0xF8, 0xFF, 0xF1, 0xFF, 0xC1, 0xF7, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x0E,
  0x78, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xE3, 0xC2, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF2, 0x0F, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F,
  0xC0, 0x07, 0x03, 0xC0, 0xE0, 0x7F, 0x3F, 0xDF, 0xF7, 0xF8, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x23, 0xF8, 0xFE, 0x1F, 0x80, 0x1E, 0x1E, 0x7C, 0x78, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF3,
  0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x3E, 0x3C, 0x7C, 0x7D, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC1, 0xF7, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF,
  0x1F, 0x78, 0xF3, 0xC7, 0x9E, 0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0xF8, 0x7F, 0x87, 0xC7, 0xBC, 0x7E, 0x3D, 0xE3, 0xF3, 0xCF, 0x3F,
  0x1E, 0x79, 0xF8, 0xF3, 0xCF, 0xCF, 0x1E, 0xFE, 0x78, 0xF7, 0x77, 0x87,
  0xBB, 0xBC, 0x3F, 0xDD, 0xE1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xE0, 0x3C, 0xF0,
  0x3C, 0x78, 0x3E, 0x3C, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0x78,
  0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0xF0, 0x03, 0x9E, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x08, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x80,
  0x1F, 0x00, 0xBE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x01, 0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x05, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFE, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 13, 3, -24 },
  { 45, 17, 24, 16, 0, -24 },
  { 96, 15, 28, 14, 0, -26 },
  { 149, 21, 25, 24, 2, -25 },
  { 215, 17, 25, 18, 0, -25 },
  { 269, 6, 9, 8, 3, -24 },
  { 276, 12, 29, 9, 0, -24 },
  { 320, 12, 30, 9, -3, -25 },
  { 365, 12, 14, 14, 3, -26 },
  { 386, 14, 16, 16, 1, -20 },
  { 414, 8, 10, 8, -2, -5 },
  { 424, 9, 4, 10, 0, -11 },
  { 429, 5, 5, 8, 0, -5 },
  { 433, 18, 25, 13, -2, -25 },
  { 490, 14, 25, 14, 1, -25 },
  { 534, 11, 24, 15, 3, -24 },
  { 567, 16, 25, 14, -1, -25 },
  { 617, 15, 25, 14, 0, -25 },
  { 664, 15, 24, 15, 0, -24 },
  { 709, 15, 24, 14, 0, -24 },
  { 754, 15, 25, 14, 1, -25 },
  { 801, 16, 24, 14, 1, -24 },
  { 849, 15, 25, 14, 0, -25 },
  { 896, 15, 25, 14, 0, -25 },
  { 943, 8, 19, 8, 0, -19 },
  { 962, 10, 24, 8, -2, -19 },
  { 992, 14, 16, 16, 1, -20 },
  { 1020, 14, 10, 16, 1, -17 },
  { 1038, 14, 16, 16, 1, -20 },
  { 1066, 12, 25, 11, 1, -25 },
  { 1104, 21, 28, 22, 1, -25 },
  { 1178, 16, 24, 16, -2, -24 },
  { 1226, 16, 24, 16, 0, -24 },
  { 1274, 16, 25, 15, 1, -25 },
  { 1324, 17, 24, 17, 0, -24 },
  { 1375, 15, 24, 14, 0, -24 },
  { 1420, 15, 24, 13, 0, -24 },
  { 1465, 18, 25, 18, 1, -25 },
  { 1522, 19, 24, 18, 0, -24 },
  { 1579, 14, 24, 11, -1, -24 },
  { 1621, 15, 31, 8, -5, -24 },
  { 1680, 19, 24, 16, 0, -24 },
  { 1737, 11, 24, 13, 0, -24 },
  { 1770, 25, 24, 24, 0, -24 },
  { 1845, 20, 24, 19, 0, -24 },
  { 1905, 17, 25, 19, 1, -25 },
  { 1959, 17, 24, 16, 0, -24 },
  { 2010, 17, 31, 19, 1, -25 },
  { 2076, 16, 24, 16, 0, -24 },
  { 2124, 17, 25, 14, -1, -25 },
  { 2178, 14, 24, 13, 2, -24 },
  { 2220, 18, 24, 18, 1, -24 },
  { 2274, 16, 24, 16, 3, -24 },
  { 2322, 25, 24, 24, 2, -24 },
  { 2397, 19, 24, 15, -2, -24 },
  { 2454, 15, 24, 14, 3, -24 },
  { 2499, 17, 24, 13, -1, -24 },
  { 2550, 13, 29, 10, -1, -24 },
  { 2598, 7, 25, 13, 3, -25 },
  { 2620, 13, 29, 10, -2, -24 },
  { 2668, 15, 14, 15, 0, -24 },
  { 2695, 11, 2, 11, -3, 3 },
  { 2698, 6, 5, 10, 5, -26 },
  { 2702, 15, 19, 16, 1, -19 },
  { 2738, 15, 26, 16, 0, -26 },
  { 2787, 12, 19, 12, 1, -19 },
  { 2816, 16, 26, 16, 1, -26 },
  { 2868, 13, 19, 14, 1, -19 },
  { 2899, 17, 34, 9, -4, -26 },
  { 2972, 17, 27, 16, -1, -19 },
  { 3030, 15, 26, 16, 0, -26 },
  { 3079, 9, 26, 8, 0, -26 },
  { 3109, 13, 34, 8, -4, -26 },
  { 3165, 16, 26, 14, 0, -26 },
  { 3217, 10, 26, 8, 0, -26 },
  { 3250, 22, 19, 23, 0, -19 },
  { 3303, 15, 19, 16, 0, -19 },
  { 3339, 13, 19, 15, 1, -19 },
  { 3370, 17, 27, 16, -2, -19 },
  { 3428, 15, 27, 16, 1, -19 },
  { 3479, 13, 19, 11, 0, -19 },
  { 3510, 13, 19, 12, 0, -19 },
  { 3541, 10, 22, 10, 1, -22 },
  { 3569, 15, 19, 15, 1, -19 },
  { 3605, 13, 19, 14, 2, -19 },
  { 3636, 21, 19, 21, 2, -19 },
  { 3686, 17, 19, 14, -2, -19 },
  { 3727, 19, 27, 14, -3, -19 },
  { 3792, 14, 19, 12, -1, -19 },
  { 3826, 14, 29, 11, 0, -24 },
  { 3877, 4, 34, 13, 4, -26 },
  { 3894, 13, 29, 11, -2, -24 },
  { 3942, 14, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC34PT7B_H_
