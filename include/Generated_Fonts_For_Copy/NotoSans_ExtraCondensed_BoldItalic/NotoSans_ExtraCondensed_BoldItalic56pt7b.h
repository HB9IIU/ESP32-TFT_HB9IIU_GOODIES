#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x3F,
  0xC7, 0xF3, 0xF8, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0x30, 0xC0, 0x3F,
  0x98, 0x20, 0x1F, 0xCC, 0x00, 0x0F, 0xE6, 0x00, 0x07, 0xF7, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x7F, 0x80, 0x01, 0xBF,
  0xC0, 0x00, 0xCF, 0xE0, 0x00, 0xE7, 0xF0, 0x80, 0x63, 0xF8, 0x70, 0x33,
  0xF8, 0x3C, 0x19, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x00,
  0xFF, 0xF0, 0x0F, 0x80, 0x3F, 0x7E, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x7C,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x87, 0xC0, 0x07, 0xC3,
  0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x8F, 0xC0, 0x07,
  0xC1, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x7C, 0x04, 0x1F, 0x0F, 0x8F, 0x87,
  0xF3, 0xE3, 0xF3, 0xE3, 0xFF, 0x7C, 0x7C, 0xFC, 0xFF, 0xEF, 0xDF, 0x9F,
  0x1F, 0xFF, 0xFF, 0xE7, 0xE7, 0xEF, 0xDF, 0xF8, 0xF8, 0xF8, 0xFB, 0xFE,
  0x3F, 0x3E, 0x1F, 0x3F, 0x87, 0xC7, 0xC3, 0xE0, 0xC1, 0xF9, 0xF0, 0x7C,
  0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x7C, 0x00, 0x7C, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xE1, 0xF0, 0x07,
  0xE0, 0x7C, 0x7E, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x3F, 0x01, 0xFB, 0xF0,
  0x07, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x07, 0xF0, 0x7F,
  0xF8, 0x7F, 0x07, 0xFF, 0xE3, 0xF8, 0x7F, 0xFF, 0x1F, 0xC3, 0xFB, 0xF9,
  0xFC, 0x3F, 0x9F, 0xEF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0x7F, 0x03, 0xFF, 0x83, 0xF8,
  0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xBF, 0xC0, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x01,
  0x80, 0x00, 0x00, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x02, 0x07, 0xE0, 0x1C, 0x3F, 0x00, 0xF1, 0xF0, 0x0F,
  0xEF, 0x8F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xDF, 0x03, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x3E, 0x1F, 0xC0, 0xE0, 0xFC,
  0x03, 0x07, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x04, 0x1F,
  0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xF8,
  0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xF9, 0xFE,
  0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFD, 0xFC, 0x3E, 0x7F, 0x0E, 0x1F, 0x81, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0xF8, 0x1F, 0xC0,
  0x18, 0x07, 0xF0, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xC1, 0xFF, 0x00, 0x40,
  0x3F, 0xC0, 0x20, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x20, 0x01, 0xFE, 0x0F, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1E, 0xFE, 0x00, 0x0F, 0xBF, 0x80, 0x07,
  0xCF, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xFC, 0x00, 0x7C, 0x7F, 0x00,
  0x1F, 0x1F, 0xC0, 0x0F, 0x87, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xFE,
  0x00, 0xF8, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x1F, 0x03, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0x00, 0x1F, 0xE0, 0xC0, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0xDF,
  0xE0, 0x1F, 0xDF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF0,
  0x1F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF3, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF,
  0x1F, 0xC1, 0xFF, 0x1F, 0xC1, 0xFE, 0x1F, 0xE7, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xF9, 0xFC,
  0x01, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xF8, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x7F, 0x04, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x7E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0xFE, 0x0F, 0x83, 0xE0, 0x7F, 0xF1, 0xF0,
  0x7C, 0x1F, 0xFE, 0x3E, 0x1F, 0x07, 0xFF, 0xC7, 0xC3, 0xE1, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE7, 0xC3, 0xE0,
  0xF8, 0x7C, 0xF8, 0x7C, 0x1F, 0x0F, 0x9F, 0x1F, 0x07, 0xC1, 0xE3, 0xC3,
  0xE0, 0xF8, 0x3C, 0xF8, 0x7C, 0x1F, 0x0F, 0x9F, 0x0F, 0x83, 0xE1, 0xF3,
  0xE3, 0xE0, 0xF8, 0x3C, 0x78, 0x7C, 0x1F, 0x07, 0x8F, 0x0F, 0x83, 0xE1,
  0xF3, 0xE1, 0xF0, 0xFC, 0x3C, 0x7C, 0x3E, 0x1F, 0x8F, 0x8F, 0x87, 0xC7,
  0xF3, 0xE1, 0xF0, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xFB, 0xFF, 0x07, 0xC1,
  0xFE, 0x7F, 0xC0, 0xF8, 0x1F, 0x87, 0xF0, 0x1F, 0x00, 0x40, 0x30, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFC, 0x3C, 0x07,
  0xFC, 0x02, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x10, 0x07,
  0xFC, 0x1C, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x3F,
  0x81, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0x7F, 0x87, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x7C, 0x03, 0xFE, 0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0x07, 0xFF, 0x87, 0xF8, 0x3F, 0xFC,
  0x3F, 0x81, 0xFF, 0xE3, 0xFC, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF,
  0x07, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0xFF, 0xF8,
  0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x7E, 0xFE, 0x01, 0xFD,
  0xF8, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x3F,
  0x3F, 0x80, 0x3F, 0x3F, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0x9F, 0x8F, 0xE0,
  0x1F, 0xCF, 0xCF, 0xC7, 0xF0, 0x0F, 0xE3, 0xE7, 0xE7, 0xF0, 0x07, 0xE1,
  0xF7, 0xE3, 0xF8, 0x03, 0xF0, 0xFB, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xF8, 0x7F, 0x00,
  0x7E, 0x0F, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x07,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xC0, 0x7E, 0x01,
  0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0x07, 0xE0, 0x1F, 0xDF, 0x87, 0xF0,
  0x0F, 0xCF, 0xC3, 0xF8, 0x07, 0xE7, 0xE1, 0xFC, 0x03, 0xF3, 0xF0, 0xFE,
  0x03, 0xF9, 0xF8, 0x7E, 0x01, 0xFC, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x3F,
  0x80, 0x7E, 0x1F, 0x9F, 0xC0, 0x3F, 0x0F, 0xCF, 0xC0, 0x3F, 0x87, 0xE7,
  0xE0, 0x1F, 0xC3, 0xF3, 0xF0, 0x0F, 0xE1, 0xFF, 0xF8, 0x07, 0xE0, 0x7F,
  0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x1F, 0xFE, 0x01, 0xFC, 0x0F,
  0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0,
  0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF8,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xC7, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x81, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFD, 0xF8, 0x03, 0xFE, 0x03, 0x00, 0x7F, 0x80,
  0x20, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x60, 0x07, 0xF8, 0x0E, 0x01, 0xFF, 0x01, 0xF9, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x7F, 0x03,
  0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xFE, 0x07,
  0xF0, 0x7E, 0x07, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xFE,
  0x1F, 0xC0, 0x7E, 0x1F, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x7E, 0x3F, 0x80,
  0xFE, 0x3F, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x7E, 0x3F, 0x00, 0xFE, 0x7E,
  0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x7E, 0xFE,
  0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x00, 0xFF,
  0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x7D, 0xFC, 0x00, 0xFF, 0xF8, 0x7D,
  0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1,
  0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8,
  0x01, 0xFD, 0xF8, 0x01, 0xF9, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x07,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x8F, 0xC0, 0xFF, 0xEF, 0xE0, 0x7F,
  0xF7, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x7E, 0x01, 0xFF, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0xDF,
  0xE0, 0x0F, 0xDF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF1,
  0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x7F,
  0x83, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF,
  0xC0, 0x7E, 0x7F, 0xC0, 0x3E, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xE1, 0x83, 0xFC, 0x04, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x20, 0xFF, 0x07, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xF3, 0xF8,
  0x01, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xE7, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x41, 0xFE, 0x0F, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFC, 0x40, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x9F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF8, 0xFC,
  0x01, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x08, 0x00, 0xFE, 0x01, 0x80, 0x3F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0xF8, 0x03, 0xFB, 0xFE, 0x03, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x18, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x07, 0xF0,
  0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x3E,
  0x3F, 0xC3, 0xFE, 0x03, 0xE7, 0xFE, 0x7F, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0xC7, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0x1F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x87, 0xF0,
  0x7F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xE0, 0xF8, 0x03, 0xE3, 0xFE, 0x03, 0xE7, 0xFE, 0x03,
  0xEF, 0xFF, 0x07, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x07,
  0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0,
  0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF8, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC7, 0xFC, 0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0xDF, 0xFE, 0x00, 0xFD, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFC,
  0x01, 0xFD, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x18, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x7F, 0xCF, 0xC0,
  0x7F, 0xE7, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x07,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x80,
  0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x08, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x0F, 0xDF, 0xE0, 0x7E, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x83, 0x83, 0xFC, 0x04, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x10, 0x07, 0xF0,
  0xC0, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x60, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x06,
  0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x7E, 0x03, 0xFF, 0x3F, 0x00, 0x7F,
  0x1F, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xF9, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x1F, 0xDF,
  0x81, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x3F, 0xE0, 0xFE,
  0xFE, 0x0F, 0xF8, 0x3F, 0xBF, 0x83, 0xFE, 0x0F, 0xCF, 0xE1, 0xFF, 0x87,
  0xF3, 0xF8, 0x7F, 0xE1, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x3F, 0x8F, 0xFE,
  0x3F, 0x8F, 0xE3, 0xFF, 0x8F, 0xC3, 0xF9, 0xFF, 0xE7, 0xF0, 0xFE, 0x7D,
  0xF9, 0xF8, 0x3F, 0x9F, 0x7E, 0x7E, 0x0F, 0xEF, 0xDF, 0x3F, 0x83, 0xFB,
  0xE7, 0xCF, 0xC0, 0xFD, 0xF9, 0xF3, 0xF0, 0x3F, 0x7C, 0x7D, 0xF8, 0x0F,
  0xDF, 0x1F, 0x7E, 0x03, 0xFF, 0xC7, 0xDF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFE, 0x80, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 41, 14, 0, -40 },
  { 83, 20, 14, 22, 5, -40 },
  { 118, 28, 40, 27, 0, -40 },
  { 258, 25, 46, 24, 0, -43 },
  { 402, 35, 42, 39, 3, -41 },
  { 586, 29, 41, 29, 0, -40 },
  { 735, 10, 14, 14, 5, -40 },
  { 753, 18, 49, 15, 1, -40 },
  { 864, 18, 50, 15, -4, -41 },
  { 977, 21, 23, 23, 4, -43 },
  { 1038, 23, 27, 26, 2, -33 },
  { 1116, 12, 15, 13, -3, -7 },
  { 1139, 14, 6, 16, 1, -18 },
  { 1150, 9, 10, 13, 0, -9 },
  { 1162, 29, 40, 21, -3, -40 },
  { 1307, 23, 42, 24, 1, -41 },
  { 1428, 18, 40, 24, 5, -40 },
  { 1518, 26, 41, 24, -2, -41 },
  { 1652, 26, 42, 24, -1, -41 },
  { 1789, 26, 40, 24, -1, -40 },
  { 1919, 25, 41, 24, 0, -40 },
  { 2048, 25, 42, 24, 1, -41 },
  { 2180, 26, 40, 24, 1, -40 },
  { 2310, 25, 42, 24, 0, -41 },
  { 2442, 24, 42, 24, 0, -41 },
  { 2568, 13, 32, 14, 0, -31 },
  { 2620, 17, 39, 14, -3, -31 },
  { 2703, 23, 26, 26, 2, -33 },
  { 2778, 23, 17, 26, 2, -28 },
  { 2827, 23, 26, 26, 2, -33 },
  { 2902, 20, 42, 19, 1, -41 },
  { 3007, 35, 44, 36, 1, -40 },
  { 3200, 26, 40, 26, -3, -40 },
  { 3330, 27, 40, 27, 0, -40 },
  { 3465, 26, 42, 25, 2, -41 },
  { 3602, 28, 40, 29, 0, -40 },
  { 3742, 25, 40, 22, 0, -40 },
  { 3867, 25, 40, 21, 0, -40 },
  { 3992, 29, 42, 29, 2, -41 },
  { 4145, 32, 40, 30, 0, -40 },
  { 4305, 24, 40, 18, -2, -40 },
  { 4425, 25, 52, 14, -9, -40 },
  { 4588, 31, 40, 26, 0, -40 },
  { 4743, 18, 40, 22, 0, -40 },
  { 4833, 41, 40, 39, 0, -40 },
  { 5038, 33, 40, 31, 0, -40 },
  { 5203, 28, 42, 30, 2, -41 },
  { 5350, 28, 40, 26, 0, -40 },
  { 5490, 28, 51, 30, 2, -41 },
  { 5669, 26, 40, 26, 0, -40 },
  { 5799, 27, 42, 23, -1, -41 },
  { 5941, 22, 40, 22, 4, -40 },
  { 6051, 29, 41, 29, 2, -40 },
  { 6200, 26, 40, 26, 5, -40 },
  { 6330, 40, 40, 39, 4, -40 },
  { 6530, 32, 40, 25, -3, -40 },
  { 6690, 24, 40, 24, 5, -40 },
  { 6810, 28, 40, 22, -2, -40 },
  { 6950, 22, 49, 16, -2, -40 },
  { 7085, 11, 40, 21, 6, -40 },
  { 7140, 22, 49, 16, -4, -40 },
  { 7275, 24, 24, 24, 0, -40 },
  { 7347, 19, 4, 18, -5, 5 },
  { 7357, 10, 9, 17, 8, -43 },
  { 7369, 25, 32, 26, 1, -31 },
  { 7469, 25, 44, 26, 0, -43 },
  { 7607, 21, 32, 21, 1, -31 },
  { 7691, 28, 44, 26, 1, -43 },
  { 7845, 22, 32, 24, 1, -31 },
  { 7933, 28, 56, 16, -6, -43 },
  { 8129, 27, 44, 26, -1, -31 },
  { 8278, 24, 43, 26, 0, -43 },
  { 8407, 15, 43, 13, 0, -43 },
  { 8488, 22, 56, 13, -7, -43 },
  { 8642, 27, 43, 24, 0, -43 },
  { 8788, 16, 43, 13, 0, -43 },
  { 8874, 36, 31, 38, 0, -31 },
  { 9014, 24, 31, 26, 0, -31 },
  { 9107, 23, 32, 25, 1, -31 },
  { 9199, 28, 44, 26, -3, -31 },
  { 9353, 25, 44, 26, 1, -31 },
  { 9491, 21, 31, 18, 0, -31 },
  { 9573, 21, 32, 20, 0, -31 },
  { 9657, 16, 38, 16, 2, -37 },
  { 9733, 25, 32, 25, 1, -31 },
  { 9833, 22, 31, 22, 3, -31 },
  { 9919, 34, 31, 34, 3, -31 },
  { 10051, 28, 31, 23, -3, -31 },
  { 10160, 30, 44, 23, -4, -31 },
  { 10325, 23, 31, 19, -2, -31 },
  { 10415, 22, 49, 19, 1, -40 },
  { 10550, 6, 56, 21, 7, -43 },
  { 10592, 21, 49, 19, -3, -40 },
  { 10721, 23, 9, 26, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC56PT7B_H_
