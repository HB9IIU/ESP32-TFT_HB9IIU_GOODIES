#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC0, 0x02,
  0x1E, 0x38, 0x70, 0x77, 0x77, 0x66, 0xE6, 0xEE, 0xCE, 0x07, 0x60, 0x66,
  0x06, 0xC0, 0xCC, 0x3F, 0xF3, 0xFE, 0x19, 0x81, 0x98, 0x1B, 0x8F, 0xFC,
  0xFF, 0xC3, 0x30, 0x66, 0x06, 0x60, 0x66, 0x0E, 0xC0, 0x01, 0x01, 0xE1,
  0xFC, 0x7F, 0x3A, 0x8E, 0x83, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x2E,
  0x8B, 0xBF, 0xEF, 0xF1, 0xF8, 0x10, 0x04, 0x00, 0x18, 0x08, 0x78, 0x61,
  0xF8, 0xC3, 0x33, 0x06, 0x66, 0x1D, 0xD8, 0x33, 0x70, 0x66, 0xCE, 0xDF,
  0xBC, 0xF6, 0xDC, 0x9D, 0xB8, 0x36, 0x60, 0xCC, 0xC1, 0x99, 0x86, 0x37,
  0x0C, 0x7C, 0x30, 0x70, 0x03, 0x00, 0xFC, 0x0D, 0xC1, 0xDC, 0x1D, 0xC1,
  0xD8, 0x1F, 0x81, 0xF0, 0x1E, 0x73, 0xE6, 0x77, 0xEE, 0x7E, 0xE7, 0xCE,
  0x38, 0xE7, 0x8F, 0xFC, 0x7D, 0xE0, 0x77, 0x66, 0xEE, 0x07, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x60, 0x70, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30,
  0x70, 0xE0, 0x18, 0x1C, 0x9C, 0xFB, 0xFF, 0x1F, 0x7C, 0xFE, 0x6E, 0x24,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x3B, 0x9C, 0xEE, 0x70, 0x7D, 0xFF, 0xC0, 0x2F, 0xFE, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00,
  0x03, 0x03, 0xE1, 0xFC, 0x77, 0x39, 0xCE, 0x77, 0x1D, 0xC7, 0x71, 0xDC,
  0xE7, 0x3B, 0x8E, 0xE3, 0x39, 0xC7, 0xF1, 0xF8, 0x7C, 0x00, 0x0F, 0x1E,
  0x3E, 0x7E, 0xEE, 0x5C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x03, 0x81, 0xF8, 0x7F, 0x8E, 0x70, 0x8E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xE7, 0xFC,
  0xFF, 0x00, 0x07, 0x07, 0xF1, 0xFC, 0x47, 0x01, 0xC0, 0x70, 0x38, 0x7C,
  0x1E, 0x07, 0xC0, 0x78, 0x0E, 0x03, 0x81, 0xCC, 0xF3, 0xF8, 0xFC, 0x00,
  0x01, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x86, 0xE1, 0xB8, 0xCC, 0x77, 0x19,
  0xCF, 0xFB, 0xFE, 0xFF, 0x83, 0x80, 0xE0, 0x38, 0x1F, 0xC7, 0xF1, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0xF1, 0xFE, 0x27, 0x80, 0xE0, 0x38, 0x0E, 0x87,
  0x37, 0xCF, 0xE3, 0xF0, 0x03, 0xC3, 0xE1, 0xF8, 0xF0, 0x38, 0x1C, 0x07,
  0x63, 0xFC, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xC7, 0x31, 0xCE, 0xE3, 0xF8,
  0x7C, 0x00, 0x3F, 0xDF, 0xF0, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x07, 0x03,
  0xF1, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0xB8, 0x7C, 0x1E, 0x0F, 0xC7, 0x7B,
  0x8E, 0xE3, 0xB8, 0xEE, 0x73, 0xFC, 0x7E, 0x00, 0x07, 0x03, 0xE1, 0xFC,
  0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCF, 0x7B, 0xDF, 0xE3, 0xF8, 0x0E, 0x07,
  0x01, 0xC9, 0xE3, 0xF0, 0xF8, 0x00, 0x18, 0xF3, 0x8E, 0x00, 0x00, 0x00,
  0x00, 0x8F, 0x38, 0xE0, 0x0C, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE3, 0x87, 0x0C, 0x38, 0x60, 0x00, 0x80, 0xC1, 0xE3, 0xE7, 0xC7,
  0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x80, 0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x3E, 0x7C,
  0xF8, 0x70, 0x20, 0x00, 0x1C, 0x7E, 0x7F, 0x47, 0x07, 0x06, 0x0E, 0x1C,
  0x38, 0x70, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0xC0, 0x00, 0xC0, 0x1F,
  0xC0, 0xE3, 0x86, 0x06, 0x30, 0x0D, 0x8F, 0xB6, 0x6C, 0xD3, 0x33, 0xCC,
  0xCF, 0x63, 0x6D, 0x99, 0xB6, 0x66, 0x9B, 0xB2, 0x3B, 0x8C, 0x00, 0x30,
  0x00, 0xE0, 0x81, 0xFE, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1B,
  0x0E, 0xC3, 0xB0, 0xCC, 0x73, 0x1C, 0xCF, 0xF3, 0xFD, 0xFF, 0x71, 0xDC,
  0x7E, 0x1F, 0x87, 0x1F, 0xC3, 0xFC, 0x73, 0x8C, 0x73, 0x8E, 0x73, 0xCF,
  0xF1, 0xF8, 0x3F, 0x8E, 0x39, 0xC7, 0x38, 0xE7, 0x3D, 0xCF, 0x3F, 0xC7,
  0xF0, 0x03, 0x81, 0xFC, 0x7F, 0x1E, 0x23, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3D, 0x83, 0xF0, 0x7E,
  0x00, 0x1F, 0xC1, 0xFE, 0x1D, 0xE1, 0xCF, 0x38, 0xF3, 0x8F, 0x38, 0xF3,
  0x8E, 0x38, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0x73, 0xCF, 0xF8, 0xFF, 0x0F,
  0xC0, 0x1F, 0xC7, 0xF1, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x3F,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0x8F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF1,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xFC, 0x3F, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0xFF, 0x1F, 0xE3, 0xC2, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE3, 0xEE, 0x7C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x38, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x1C, 0x38, 0xE1, 0xC7, 0x1C,
  0x38, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0x87, 0x1C,
  0x38, 0xE3, 0x87, 0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x78, 0x1F, 0xC3, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x0F, 0xE3, 0xF8, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0x1C, 0x78,
  0xE7, 0x07, 0x38, 0x33, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70,
  0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x1F,
  0xFF, 0xFF, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x6C, 0xFC, 0x37, 0x6E, 0x3B, 0xF7, 0x1D,
  0xF3, 0x0E, 0xFB, 0x86, 0x79, 0xC7, 0x3C, 0xE3, 0x9C, 0x71, 0xCE, 0x70,
  0x1E, 0x1C, 0x78, 0x61, 0xE3, 0x87, 0x8E, 0x3F, 0x38, 0xFC, 0xC3, 0xF7,
  0x0D, 0xDC, 0x33, 0x71, 0xCD, 0xC7, 0x3E, 0x1C, 0xF8, 0x63, 0xE3, 0x8F,
  0x8E, 0x1C, 0x38, 0x70, 0x03, 0x81, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0xE1,
  0xDC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xEE, 0x1D, 0xC7, 0x3F,
  0xE3, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xFC, 0x73, 0x8E, 0x73, 0x8E, 0x71,
  0xCE, 0x39, 0xFE, 0x3F, 0xCF, 0xE1, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F,
  0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xEE, 0x1D, 0xC7, 0x3F, 0xE3, 0xF8,
  0x7E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1F, 0xC3, 0xFC, 0x77, 0x8C,
  0x73, 0x8E, 0x71, 0xCE, 0x71, 0xFE, 0x3F, 0x8F, 0xE1, 0xDC, 0x3B, 0x87,
  0x71, 0xC7, 0x38, 0xE7, 0x1C, 0x03, 0x01, 0xFC, 0x7F, 0x1E, 0x43, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0x0E,
  0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38,
  0xF3, 0x8E, 0x38, 0xE7, 0x8E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xF1,
  0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0xE1,
  0xFC, 0x3B, 0x8E, 0x71, 0xCE, 0x39, 0xCE, 0x39, 0xC7, 0x70, 0xEE, 0x1D,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE3, 0x87, 0xE3,
  0x8E, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9C, 0xE7, 0x9C, 0xED, 0x98, 0xED,
  0xB8, 0xFD, 0xB8, 0xD9, 0xF0, 0xD9, 0xF0, 0xF9, 0xE0, 0xF3, 0xE0, 0xF3,
  0xE0, 0xE3, 0xC0, 0xE3, 0xC0, 0x1E, 0x78, 0x73, 0x83, 0xB8, 0x1D, 0x80,
  0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x77,
  0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x78, 0xE3, 0xF8, 0xEE, 0x71, 0x9C,
  0x6E, 0x1F, 0x87, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xFF, 0x3F, 0xC7,
  0xF8, 0x0F, 0x87, 0xC3, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x3C, 0x3E, 0x1F, 0x00,
  0xE7, 0x18, 0xC6, 0x39, 0xCE, 0x73, 0x8C, 0x63, 0x1C, 0xE7, 0x38, 0x0F,
  0x87, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x3E, 0x1E, 0x1F, 0x00, 0x07, 0x01,
  0xC0, 0xF0, 0x3E, 0x1F, 0x8E, 0x63, 0x19, 0xC7, 0xE1, 0xC0, 0xFF, 0xFE,
  0xF3, 0x9C, 0x70, 0x0E, 0xE3, 0xDC, 0xFF, 0x1C, 0xE7, 0x1C, 0xE3, 0x9C,
  0x73, 0x9C, 0xE3, 0x9C, 0x73, 0xDE, 0x3F, 0x87, 0xB0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3B, 0x8F, 0xF3, 0xFC, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xC7,
  0x73, 0x9C, 0xEF, 0x7B, 0xFC, 0xDE, 0x00, 0x07, 0x0F, 0xCF, 0xC7, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x8F, 0xC3, 0xE0, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x0E, 0xE1, 0xFE, 0x3F, 0xC3, 0x9C, 0x71, 0xC7,
  0x1C, 0x71, 0x87, 0x18, 0xE3, 0x8E, 0x38, 0xF7, 0x87, 0xF0, 0x7B, 0x00,
  0x07, 0x0F, 0xCF, 0xE7, 0x37, 0x1B, 0xBD, 0xFC, 0xF0, 0x60, 0x70, 0x1C,
  0x4F, 0xE3, 0xE0, 0x00, 0x60, 0x1F, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x3E,
  0x0F, 0xC0, 0xFC, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x80,
  0xF0, 0x04, 0x00, 0x07, 0x70, 0xFF, 0x1F, 0xE1, 0xCE, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0x7B, 0xC3, 0xF8, 0x3F, 0x80, 0x38,
  0x03, 0x88, 0x70, 0xFF, 0x0F, 0xE0, 0x10, 0x00, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3B, 0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x19, 0xCE, 0x73,
  0x98, 0xEE, 0x3B, 0x8C, 0xE7, 0x00, 0x08, 0x71, 0xC7, 0x00, 0xE3, 0x8E,
  0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x80, 0x01, 0x01, 0xC0, 0xE0,
  0x70, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x87, 0xC3, 0xC0, 0x80, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x37, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x80, 0x1C,
  0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0xCE, 0x38, 0xE0,
  0x3B, 0x9C, 0x7F, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xEE, 0x31, 0xDC,
  0xE3, 0x39, 0xCE, 0x73, 0x9C, 0xC7, 0x3B, 0x8C, 0x67, 0x38, 0xCE, 0x73,
  0x80, 0x1B, 0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x19, 0xCE, 0x73,
  0x98, 0xEE, 0x3B, 0x8C, 0xE7, 0x00, 0x07, 0x07, 0xE3, 0xF8, 0xE7, 0x71,
  0xDC, 0x77, 0x1D, 0x86, 0xE3, 0xB8, 0xE7, 0x71, 0xFC, 0x3E, 0x00, 0x1D,
  0xC3, 0xFC, 0x7F, 0x8E, 0x71, 0xCE, 0x71, 0xCE, 0x39, 0xC7, 0x39, 0xC7,
  0x39, 0xEF, 0x3F, 0xC7, 0xF0, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0xE3, 0xFC, 0xFF, 0x1C, 0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x8C, 0xE3,
  0x9C, 0x73, 0xDE, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x3B, 0x9F, 0x8F, 0xC7, 0xA3, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0E, 0x00, 0x0E, 0x1F, 0xCF, 0xCE, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x27, 0x9F, 0x8F, 0x80, 0x18, 0xE3, 0xFF,
  0xFD, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x00, 0x38, 0xE7, 0x18,
  0xE7, 0x1C, 0xE3, 0x1C, 0xE3, 0x1C, 0xE3, 0x9C, 0x73, 0x8C, 0x73, 0xDC,
  0x3F, 0x87, 0xB0, 0xE3, 0xF1, 0xF8, 0xDC, 0xEE, 0x73, 0x71, 0xB8, 0xD8,
  0x7C, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0xE3, 0x8F, 0x9E, 0x7E, 0x79, 0xB9,
  0xEE, 0xED, 0xBB, 0xBE, 0xCF, 0xFF, 0x3E, 0xF8, 0xFB, 0x63, 0xEF, 0x8F,
  0x3C, 0x3C, 0xF0, 0xE3, 0x80, 0x1C, 0xE3, 0x9C, 0x77, 0x0E, 0xC0, 0xF8,
  0x1E, 0x03, 0x80, 0xF8, 0x1F, 0x07, 0xE1, 0xDC, 0x39, 0x8E, 0x38, 0x1C,
  0x30, 0xC7, 0x0C, 0x70, 0xCE, 0x0C, 0xE0, 0xDC, 0x0D, 0xC0, 0xD8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x78,
  0x0F, 0x00, 0x40, 0x00, 0x1F, 0xC7, 0xE3, 0xF8, 0x1C, 0x07, 0x03, 0x80,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x13, 0xF8, 0xFE, 0x00, 0x07, 0x83, 0xC3,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x78, 0x30, 0x3C, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x3E, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07,
  0x0F, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xF0, 0xC0, 0x70, 0xFF,
  0xF7, 0xF0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 12, 16, 11, 0, -16 },
  { 45, 10, 18, 10, 0, -17 },
  { 68, 15, 17, 16, 1, -17 },
  { 100, 12, 17, 12, 0, -17 },
  { 126, 4, 6, 6, 2, -16 },
  { 129, 8, 20, 6, 0, -16 },
  { 149, 8, 21, 6, -2, -17 },
  { 170, 8, 10, 9, 2, -18 },
  { 180, 9, 11, 11, 1, -14 },
  { 193, 5, 6, 5, -1, -3 },
  { 197, 6, 3, 7, 0, -8 },
  { 200, 4, 4, 5, 0, -4 },
  { 202, 12, 17, 9, -1, -17 },
  { 228, 10, 17, 10, 0, -17 },
  { 250, 8, 16, 10, 2, -16 },
  { 266, 11, 17, 10, -1, -17 },
  { 290, 10, 17, 10, 0, -17 },
  { 312, 10, 16, 10, 0, -16 },
  { 332, 10, 16, 10, 0, -16 },
  { 352, 10, 17, 10, 1, -17 },
  { 374, 10, 16, 10, 1, -16 },
  { 394, 10, 17, 10, 0, -17 },
  { 416, 10, 17, 10, 0, -17 },
  { 438, 6, 13, 6, 0, -13 },
  { 448, 7, 16, 6, -1, -13 },
  { 462, 9, 11, 11, 1, -14 },
  { 475, 9, 7, 11, 1, -12 },
  { 483, 9, 11, 11, 1, -14 },
  { 496, 8, 17, 8, 1, -17 },
  { 513, 14, 19, 15, 1, -17 },
  { 547, 10, 16, 11, -1, -16 },
  { 567, 11, 16, 11, 0, -16 },
  { 589, 11, 17, 10, 1, -17 },
  { 613, 12, 16, 12, 0, -16 },
  { 637, 10, 16, 9, 0, -16 },
  { 657, 10, 16, 9, 0, -16 },
  { 677, 12, 17, 12, 1, -17 },
  { 703, 13, 16, 12, 0, -16 },
  { 729, 10, 16, 7, -1, -16 },
  { 749, 11, 21, 6, -4, -16 },
  { 778, 13, 16, 11, 0, -16 },
  { 804, 7, 16, 9, 0, -16 },
  { 818, 17, 16, 16, 0, -16 },
  { 852, 14, 16, 13, 0, -16 },
  { 880, 11, 17, 13, 1, -17 },
  { 904, 11, 16, 11, 0, -16 },
  { 926, 11, 21, 13, 1, -17 },
  { 955, 11, 16, 11, 0, -16 },
  { 977, 11, 17, 9, 0, -17 },
  { 1001, 9, 16, 9, 2, -16 },
  { 1019, 12, 16, 12, 1, -16 },
  { 1043, 11, 16, 11, 2, -16 },
  { 1065, 16, 16, 16, 2, -16 },
  { 1097, 13, 16, 10, -1, -16 },
  { 1123, 10, 16, 10, 2, -16 },
  { 1143, 11, 16, 9, -1, -16 },
  { 1165, 9, 20, 7, -1, -16 },
  { 1188, 5, 17, 9, 2, -17 },
  { 1199, 9, 20, 7, -2, -16 },
  { 1222, 10, 9, 10, 0, -16 },
  { 1234, 8, 2, 7, -2, 2 },
  { 1236, 5, 4, 7, 3, -18 },
  { 1239, 11, 13, 11, 0, -13 },
  { 1257, 10, 17, 11, 0, -17 },
  { 1279, 9, 13, 8, 0, -13 },
  { 1294, 12, 17, 11, 0, -17 },
  { 1320, 9, 13, 10, 0, -13 },
  { 1335, 12, 24, 6, -3, -18 },
  { 1371, 12, 19, 11, -1, -13 },
  { 1400, 10, 17, 11, 0, -17 },
  { 1422, 6, 18, 5, 0, -18 },
  { 1436, 9, 24, 5, -3, -18 },
  { 1463, 11, 17, 10, 0, -17 },
  { 1487, 6, 17, 5, 0, -17 },
  { 1500, 15, 13, 15, 0, -13 },
  { 1525, 10, 13, 11, 0, -13 },
  { 1542, 10, 13, 10, 0, -13 },
  { 1559, 11, 18, 11, -1, -13 },
  { 1584, 11, 19, 11, 0, -13 },
  { 1611, 9, 13, 7, 0, -13 },
  { 1626, 9, 13, 8, 0, -13 },
  { 1641, 6, 15, 7, 1, -15 },
  { 1653, 11, 13, 10, 0, -13 },
  { 1671, 9, 13, 9, 1, -13 },
  { 1686, 14, 13, 14, 1, -13 },
  { 1709, 11, 13, 9, -1, -13 },
  { 1727, 12, 19, 9, -2, -13 },
  { 1756, 10, 13, 8, -1, -13 },
  { 1773, 9, 20, 8, 0, -16 },
  { 1796, 2, 23, 9, 3, -18 },
  { 1802, 8, 20, 8, -1, -16 },
  { 1822, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC23PT7B_H_
