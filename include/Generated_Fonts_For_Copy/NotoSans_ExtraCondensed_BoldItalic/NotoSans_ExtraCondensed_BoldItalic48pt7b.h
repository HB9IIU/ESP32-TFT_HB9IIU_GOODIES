#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0,
  0x00, 0x7F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF0,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0xF8, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7,
  0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xB1, 0x80, 0x7C,
  0xC2, 0x03, 0xF3, 0x00, 0x0F, 0xCC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1B,
  0xF8, 0x00, 0x67, 0xE1, 0x01, 0x9F, 0x84, 0x06, 0xFC, 0x1C, 0x33, 0xF0,
  0x7E, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x7F, 0xE0, 0x3C, 0x01, 0xF7,
  0xC0, 0xF8, 0x03, 0xC7, 0x81, 0xE0, 0x0F, 0x8F, 0x07, 0xC0, 0x1E, 0x1E,
  0x0F, 0x00, 0x3C, 0x3C, 0x3E, 0x00, 0xF8, 0xF8, 0x78, 0x01, 0xE1, 0xF1,
  0xF0, 0x03, 0xC3, 0xE3, 0xC0, 0x07, 0x87, 0x8F, 0x80, 0x0F, 0x0F, 0x3E,
  0x00, 0x1E, 0x3E, 0x7C, 0x7C, 0x7C, 0x79, 0xF1, 0xFC, 0x79, 0xF3, 0xC7,
  0xFC, 0xF7, 0xCF, 0x9F, 0xF9, 0xFF, 0x9E, 0x7C, 0xF3, 0xFE, 0x7C, 0xF1,
  0xE3, 0xF8, 0xF3, 0xE3, 0xE1, 0xC3, 0xE7, 0xC7, 0x80, 0x07, 0x8F, 0x0F,
  0x00, 0x1F, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0xF8,
  0x03, 0xE1, 0xE1, 0xF0, 0x07, 0x83, 0xC3, 0xC0, 0x1F, 0x07, 0x8F, 0x80,
  0x3C, 0x0F, 0x1F, 0x00, 0xF8, 0x1E, 0x7C, 0x01, 0xE0, 0x3F, 0xF8, 0x07,
  0xC0, 0x7F, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xC3, 0xFF, 0x8F, 0xC3, 0xFF,
  0xC7, 0xE1, 0xFF, 0xF3, 0xE1, 0xF9, 0xFB, 0xF1, 0xF8, 0xFD, 0xF0, 0xFC,
  0x7F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3F, 0x03, 0xFC, 0x1F,
  0x81, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFD, 0xFC, 0x07, 0xF8, 0x7F,
  0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x61, 0xF0, 0x1E, 0x7C, 0x07, 0xDE, 0x3B, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xF7,
  0xC1, 0xF9, 0xF0, 0x3E, 0x7E, 0x07, 0x0F, 0x80, 0x83, 0x80, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8,
  0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF9, 0xFB, 0xF1, 0xE7, 0xE3, 0x8F, 0xC2, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7C, 0x3F, 0x80,
  0xF0, 0x7F, 0x00, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1C, 0x1F, 0xC0, 0x20, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x80, 0x1F, 0xC3, 0x80, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xF3, 0xF0, 0x07, 0x9F, 0x80,
  0x3E, 0x7E, 0x00, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xFC, 0x07, 0xC3, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x3F, 0x07, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFD, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x02, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE1, 0x00, 0x7F, 0x0F, 0x0F, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xE3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0x3F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7E, 0x1F, 0x81, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0xFE, 0x7F, 0x07, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x1F, 0xC7,
  0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFE, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFB, 0xF0, 0x0F, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x40, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x3E, 0x07, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x10, 0x00,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0x7E, 0x20,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x03, 0x80,
  0xF0, 0xF8, 0x3F, 0xE3, 0xC3, 0xC3, 0xFF, 0x8F, 0x1E, 0x0F, 0xFE, 0x3C,
  0x78, 0x7C, 0xF8, 0xF3, 0xE3, 0xE3, 0xC3, 0xCF, 0x0F, 0x0F, 0x0F, 0x3C,
  0x78, 0x3C, 0x3D, 0xE1, 0xE1, 0xF1, 0xE7, 0x8F, 0x87, 0x87, 0x9E, 0x3C,
  0x1E, 0x1E, 0x78, 0xF0, 0x78, 0x79, 0xE3, 0xC3, 0xE3, 0xCF, 0x0F, 0x0F,
  0x0F, 0x3C, 0x3C, 0x7C, 0x38, 0xF0, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0xCF,
  0x0F, 0x0F, 0xF7, 0xFC, 0x3C, 0x3F, 0xDF, 0xE0, 0xF0, 0x7E, 0x3F, 0x03,
  0xC0, 0x20, 0x20, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x40, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7E, 0x00,
  0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0x81,
  0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x87, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0x83, 0x03, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0x03, 0xFC, 0x38, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF3,
  0xFF, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x70, 0x1F,
  0xE0, 0x08, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xFC, 0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xFF,
  0x1F, 0xC3, 0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xBF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xF7, 0xC3, 0xEF, 0xC0, 0x7E, 0xF8, 0xFD,
  0xF8, 0x0F, 0x9F, 0x1F, 0x7E, 0x03, 0xF3, 0xE3, 0xEF, 0xC0, 0x7E, 0x7C,
  0xF9, 0xF8, 0x0F, 0xCF, 0x9F, 0x3F, 0x01, 0xF1, 0xF7, 0xC7, 0xE0, 0x3E,
  0x3E, 0xF9, 0xF8, 0x0F, 0xC7, 0xFF, 0x3F, 0x01, 0xF8, 0xFF, 0xC7, 0xE0,
  0x3F, 0x1F, 0xF8, 0xFC, 0x07, 0xC3, 0xFE, 0x1F, 0x01, 0xF8, 0x7F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xF0, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0x80, 0xFC, 0x3F,
  0x83, 0xF0, 0x1F, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0x03, 0xFE,
  0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7E,
  0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x7C, 0x07, 0xFF, 0x0F, 0xC0, 0x7D,
  0xF0, 0xFC, 0x0F, 0xDF, 0x0F, 0xC0, 0xFD, 0xF0, 0xFC, 0x0F, 0xDF, 0x0F,
  0x80, 0xF9, 0xF9, 0xF8, 0x0F, 0x9F, 0x9F, 0x81, 0xF8, 0xF9, 0xF8, 0x1F,
  0x8F, 0x9F, 0x81, 0xF8, 0xF9, 0xF0, 0x1F, 0x0F, 0xFF, 0x01, 0xF0, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x3F, 0x07, 0xFE, 0x03,
  0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x03,
  0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7C, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x3F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83,
  0xF0, 0xFE, 0x07, 0xE7, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8,
  0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0x1E, 0x03, 0xFC, 0x08, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x02, 0x00, 0x7E, 0x07, 0x01, 0xFC, 0x0F, 0xDF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x0F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x01,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x7E,
  0x01, 0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x01,
  0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0,
  0x3F, 0x3F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x81, 0xF8, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xC1, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xF8, 0x7E, 0x07, 0xE3, 0xFF, 0x0F, 0xC0, 0xFC, 0x7F, 0xE3,
  0xF0, 0x1F, 0x8F, 0xFC, 0x7E, 0x03, 0xF3, 0xEF, 0x8F, 0xC0, 0x7E, 0x7D,
  0xF3, 0xF0, 0x0F, 0x9F, 0x3E, 0x7E, 0x01, 0xF3, 0xE7, 0xDF, 0x80, 0x3E,
  0x7C, 0xFB, 0xF0, 0x07, 0xDF, 0x1F, 0x7E, 0x00, 0xFB, 0xE3, 0xFF, 0x80,
  0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x9F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E,
  0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x87, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F,
  0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF,
  0xC0, 0xFE, 0x7F, 0x1F, 0x8F, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x00, 0x60,
  0x04, 0x07, 0xF3, 0xE0, 0x7F, 0xCF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xDF, 0x01, 0xFE, 0x7C, 0x03, 0xF1, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x1C, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x7D, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3E, 0xFF, 0x81, 0xF3, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC1, 0xFC, 0x10, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x04, 0x3F,
  0x86, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x60, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7,
  0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07,
  0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xDF, 0x00, 0x3F, 0x9F,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0,
  0xF9, 0xF8, 0x3F, 0x3F, 0x3F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x04, 0x3F, 0xC7, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x7F, 0x3E, 0x00, 0xFF,
  0x3E, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x9F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xCF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x80, 0x3F, 0x80, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x0C, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC7, 0xF0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x00,
  0x00, 0x20, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7C, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0x80,
  0x20, 0x0F, 0x9F, 0xC3, 0xF8, 0x1F, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xBF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0xFF, 0x1F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x07, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3,
  0xE0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7C, 0x3F,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x07,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x3F,
  0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x3E, 0x7F, 0x01,
  0xF7, 0xFC, 0x0F, 0x7F, 0xE0, 0xFB, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x8F,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF1, 0xF9, 0xFC, 0x3F,
  0x3F, 0x07, 0xEF, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xF8, 0xFC, 0x00, 0xFB, 0xFE, 0x00, 0xFB, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xE7, 0xC0,
  0xFF, 0xBE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1,
  0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0x03,
  0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x1F, 0x7E, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF3, 0xC1, 0xF8, 0x10, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x80,
  0xFE, 0x30, 0x7F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x11, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0x87, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFB, 0xE0, 0x7F, 0xDF, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x81,
  0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E, 0x7C,
  0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xE0, 0xFD, 0xF8, 0x3F, 0x83, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F, 0x87, 0xF8,
  0x7C, 0x7E, 0x3F, 0xC3, 0xF1, 0xF0, 0xFF, 0x0F, 0xC7, 0xC3, 0xFC, 0x3E,
  0x1F, 0x1F, 0xF1, 0xF8, 0x7C, 0x7B, 0xC7, 0xC1, 0xF3, 0xEF, 0x1F, 0x07,
  0xCF, 0xBC, 0xFC, 0x1F, 0x3D, 0xF3, 0xE0, 0x7D, 0xF7, 0xDF, 0x81, 0xF7,
  0xDF, 0x7C, 0x07, 0xDE, 0x7D, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xC7,
  0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xF8,
  0x03, 0xF3, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x80,
  0x1F, 0x9F, 0x80, 0x3F, 0x9F, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xE8, 0x00,
  0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 34, 12, 0, -34 },
  { 61, 16, 12, 19, 5, -34 },
  { 85, 24, 34, 23, 0, -34 },
  { 187, 22, 39, 20, 0, -36 },
  { 295, 31, 35, 34, 2, -35 },
  { 431, 25, 35, 25, 0, -35 },
  { 541, 8, 12, 12, 5, -34 },
  { 553, 16, 42, 13, 1, -34 },
  { 637, 16, 43, 13, -4, -35 },
  { 723, 18, 20, 20, 4, -37 },
  { 768, 19, 23, 22, 2, -28 },
  { 823, 11, 13, 11, -3, -6 },
  { 841, 12, 6, 14, 1, -16 },
  { 850, 7, 7, 11, 0, -7 },
  { 857, 25, 35, 18, -3, -35 },
  { 967, 20, 35, 20, 1, -35 },
  { 1055, 15, 34, 21, 5, -34 },
  { 1119, 23, 35, 20, -2, -35 },
  { 1220, 22, 35, 20, -1, -35 },
  { 1317, 22, 34, 21, -1, -34 },
  { 1411, 21, 34, 20, 0, -34 },
  { 1501, 21, 35, 20, 1, -35 },
  { 1593, 22, 34, 20, 1, -34 },
  { 1687, 22, 35, 20, 0, -35 },
  { 1784, 21, 35, 20, 0, -35 },
  { 1876, 12, 27, 12, 0, -27 },
  { 1917, 15, 34, 12, -3, -27 },
  { 1981, 20, 23, 22, 2, -29 },
  { 2039, 20, 14, 22, 2, -24 },
  { 2074, 20, 23, 22, 2, -29 },
  { 2132, 17, 35, 16, 1, -35 },
  { 2207, 30, 39, 31, 1, -35 },
  { 2354, 23, 34, 23, -3, -34 },
  { 2452, 23, 34, 23, 0, -34 },
  { 2550, 22, 35, 21, 2, -35 },
  { 2647, 24, 34, 25, 0, -34 },
  { 2749, 21, 34, 19, 0, -34 },
  { 2839, 21, 34, 18, 0, -34 },
  { 2929, 25, 35, 25, 2, -35 },
  { 3039, 27, 34, 26, 0, -34 },
  { 3154, 21, 34, 15, -2, -34 },
  { 3244, 21, 44, 12, -7, -34 },
  { 3360, 27, 34, 22, 0, -34 },
  { 3475, 16, 34, 19, 0, -34 },
  { 3543, 35, 34, 33, 0, -34 },
  { 3692, 28, 34, 27, 0, -34 },
  { 3811, 24, 35, 26, 2, -35 },
  { 3916, 24, 34, 22, 0, -34 },
  { 4018, 24, 43, 26, 2, -35 },
  { 4147, 23, 34, 22, 0, -34 },
  { 4245, 23, 35, 20, -1, -35 },
  { 4346, 20, 34, 19, 3, -34 },
  { 4431, 25, 34, 25, 2, -34 },
  { 4538, 22, 34, 22, 4, -34 },
  { 4632, 35, 34, 34, 3, -34 },
  { 4781, 28, 34, 21, -3, -34 },
  { 4900, 21, 34, 20, 4, -34 },
  { 4990, 24, 34, 19, -2, -34 },
  { 5092, 19, 42, 14, -2, -34 },
  { 5192, 10, 35, 18, 5, -35 },
  { 5236, 20, 42, 14, -4, -34 },
  { 5341, 21, 20, 21, 0, -34 },
  { 5394, 17, 3, 16, -5, 4 },
  { 5401, 9, 8, 14, 7, -37 },
  { 5410, 22, 27, 22, 1, -27 },
  { 5485, 21, 36, 22, 0, -36 },
  { 5580, 18, 27, 18, 1, -27 },
  { 5641, 24, 36, 22, 1, -36 },
  { 5749, 19, 27, 20, 1, -27 },
  { 5814, 25, 49, 13, -6, -37 },
  { 5968, 24, 39, 22, -1, -27 },
  { 6085, 21, 36, 22, 0, -36 },
  { 6180, 13, 37, 11, 0, -37 },
  { 6241, 19, 49, 11, -6, -37 },
  { 6358, 23, 36, 20, 0, -36 },
  { 6462, 14, 36, 11, 0, -36 },
  { 6525, 31, 27, 32, 0, -27 },
  { 6630, 21, 27, 22, 0, -27 },
  { 6701, 19, 28, 21, 1, -27 },
  { 6768, 24, 38, 22, -3, -27 },
  { 6882, 21, 39, 22, 1, -27 },
  { 6985, 18, 27, 15, 0, -27 },
  { 7046, 18, 27, 17, 0, -27 },
  { 7107, 14, 32, 14, 2, -32 },
  { 7163, 21, 26, 22, 1, -26 },
  { 7232, 19, 26, 19, 3, -26 },
  { 7294, 30, 26, 29, 2, -26 },
  { 7392, 24, 26, 19, -2, -26 },
  { 7470, 26, 38, 19, -4, -26 },
  { 7594, 20, 26, 16, -2, -26 },
  { 7659, 19, 42, 16, 1, -34 },
  { 7759, 5, 48, 18, 6, -37 },
  { 7789, 19, 42, 16, -3, -34 },
  { 7889, 20, 8, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC48PT7B_H_
