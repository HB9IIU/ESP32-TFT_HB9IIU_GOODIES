#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0xFF, 0x8F, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xF9, 0xC7, 0x80, 0x3F, 0xC6, 0x0C, 0x00, 0xFF, 0x38, 0x00, 0x03, 0xFC,
  0xE0, 0x00, 0x0F, 0xF3, 0x80, 0x00, 0x3F, 0xCC, 0x00, 0x00, 0xFF, 0xB0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0x7F, 0xC0, 0x00, 0x19, 0xFF, 0x00, 0x00, 0x67, 0xFC, 0x10, 0x03, 0x9F,
  0xF0, 0x20, 0x0E, 0x7F, 0x81, 0xC0, 0x31, 0xFE, 0x07, 0xC0, 0xCF, 0xF8,
  0x1F, 0xC7, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xC3, 0xFE, 0x3F,
  0x0F, 0xE7, 0xF1, 0xFF, 0xCF, 0xC3, 0xF1, 0xF8, 0xFF, 0xF9, 0xF9, 0xFC,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x3F, 0x1F, 0xFF, 0x9F, 0xFF, 0x9F, 0xCF,
  0xE7, 0xF7, 0xFF, 0xC7, 0xE3, 0xF0, 0xFC, 0xFF, 0xE3, 0xF1, 0xF8, 0x3F,
  0x1F, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x8F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x9F, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x01, 0xFF, 0xF0,
  0x7F, 0x80, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0x87, 0xF8, 0x3F, 0xFF,
  0xE3, 0xFC, 0x1F, 0xF7, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0x7F, 0x83, 0xFC,
  0x3F, 0xDF, 0xE1, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0x01, 0xFC, 0x00, 0xE0, 0xFE,
  0x00, 0x78, 0x7F, 0x00, 0x3F, 0x3F, 0x03, 0x3F, 0xFF, 0x8F, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0xE0, 0x1F, 0x0F, 0xF8, 0x07, 0x03, 0xF0, 0x01, 0x81, 0xF0,
  0x00, 0x80, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0x8F, 0xF7, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0xC1, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xDF,
  0xE1, 0xFE, 0x7F, 0x83, 0xF3, 0xFC, 0x0F, 0x8F, 0xF0, 0x18, 0x3F, 0xC0,
  0x20, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0x00,
  0x3F, 0x03, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x18, 0x01, 0xFF, 0x00,
  0x10, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0xC0, 0x1F,
  0xF0, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x21, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x1F,
  0xF8, 0x30, 0x00, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFD, 0xFE, 0x00,
  0x03, 0xE7, 0xF8, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x03,
  0xF3, 0xFC, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x03, 0xF0,
  0xFF, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x7F,
  0x80, 0x1F, 0x81, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x3F, 0xC0,
  0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x10, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x40, 0x01, 0xFF, 0x83, 0x80, 0x1F, 0xF8, 0x1F, 0x03, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF9,
  0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x8F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC,
  0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFF, 0xC1, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFB, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7E, 0x01, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF3, 0xFF, 0x0F, 0x03, 0xFE, 0x08, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x7F, 0xC0, 0xF8, 0x1F, 0x80, 0xFF, 0xF8, 0x7C, 0x0F, 0xC0,
  0xFF, 0xFC, 0x3E, 0x0F, 0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xC0, 0xFF, 0xFF,
  0x0F, 0x87, 0xE0, 0xFE, 0x1F, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF1, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0xF8, 0x3F,
  0x03, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x7E, 0x1F, 0x81, 0xF8,
  0x3F, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x9F,
  0x87, 0xE0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0, 0x3F, 0x07, 0xC7, 0xE1, 0xF8,
  0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x1F, 0x81, 0xF1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x7C, 0x1F, 0x87, 0xF0, 0xF8, 0x3E,
  0x0F, 0xC7, 0xF8, 0xFC, 0x1F, 0x07, 0xF7, 0xFF, 0xFC, 0x0F, 0x83, 0xFF,
  0xFF, 0xFC, 0x07, 0xC0, 0xFF, 0xCF, 0xFE, 0x03, 0xE0, 0x7F, 0xC7, 0xFE,
  0x01, 0xF0, 0x1F, 0xC1, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF,
  0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0xF0, 0x03,
  0xFF, 0x80, 0x60, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x06, 0x00, 0x7F,
  0xF8, 0x7C, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03,
  0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x0F, 0xFE, 0x00, 0x08,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE0,
  0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x04, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xF8, 0x1F, 0xCF, 0xF0, 0x07, 0xF9,
  0xF8, 0x1F, 0xDF, 0xE0, 0x07, 0xF9, 0xF8, 0x3F, 0x9F, 0xE0, 0x07, 0xF9,
  0xFC, 0x3F, 0x9F, 0xE0, 0x07, 0xF1, 0xFC, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1,
  0xFC, 0x7F, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x7F, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFC, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFD, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFD, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1,
  0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xE1,
  0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x81,
  0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0x3F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0xFE, 0x07, 0xF8, 0x03, 0xFD, 0xFC, 0x0F, 0xF0, 0x07, 0xFB, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0xFF, 0x00,
  0x7F, 0x9F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0xFF, 0x00, 0x7F, 0x83,
  0xF9, 0xFC, 0x00, 0xFF, 0x07, 0xF7, 0xF8, 0x01, 0xFC, 0x0F, 0xEF, 0xF0,
  0x07, 0xF8, 0x1F, 0xDF, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xE0,
  0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x1F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF1, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x87,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0x80, 0xE0,
  0x07, 0xFE, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x08, 0x00, 0x1F, 0xF0,
  0x1C, 0x00, 0x7F, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0,
  0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFF, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x3F, 0x80, 0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xF0, 0xFF,
  0x80, 0x7F, 0x83, 0xF7, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF7, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF7, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE7, 0xF1, 0xFE,
  0x00, 0x7F, 0x8F, 0xE7, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE7, 0xF3, 0xFC,
  0x00, 0x7F, 0x9F, 0xC7, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xC7, 0xE7, 0xFC,
  0x00, 0x7F, 0xBF, 0x87, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0x87, 0xE7, 0xF8,
  0x00, 0x7F, 0xBF, 0x87, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xEF, 0xF0,
  0x00, 0x7F, 0xFF, 0x07, 0xEF, 0xF0, 0x00, 0x7F, 0x7E, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF,
  0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFE, 0x3F,
  0xC0, 0x3F, 0xFC, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xDF, 0xE0,
  0x07, 0xFE, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x0C, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xDF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0x00,
  0x7F, 0x3F, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFE, 0x0C, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x02, 0x03, 0xFE, 0x07, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x1F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFB, 0xF8,
  0x00, 0x7F, 0xFD, 0xFC, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC3,
  0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x02, 0x07, 0xFC, 0x07, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x04, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0,
  0x03, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x03, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x10, 0x00, 0x7F, 0xE0, 0x0E, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xDF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFB,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F,
  0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x3F, 0x8F, 0xF8, 0x1F, 0xE0, 0x07, 0xE3, 0xFF, 0x8F, 0xFE, 0x00,
  0xFC, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x3F,
  0xF8, 0x03, 0xF3, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0x01, 0xFD, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07,
  0xE1, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xE0, 0x03, 0xF9, 0xFF, 0xF0, 0x01,
  0xFD, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xE0, 0x03, 0xFD,
  0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x83, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x3F, 0xFE, 0xFE, 0x01, 0xFF, 0xFB, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xDF, 0xE0, 0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF,
  0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xDF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE2, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF8, 0x0C,
  0x07, 0xF8, 0x02, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x08,
  0x01, 0xFF, 0x07, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x98, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFE, 0x7F,
  0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFD,
  0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xFC, 0x0F,
  0xF1, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x7F,
  0x87, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x1F, 0xE3, 0xFF,
  0xE1, 0xFE, 0x0F, 0xF1, 0xFB, 0xF0, 0xFE, 0x07, 0xF0, 0xFD, 0xF8, 0xFF,
  0x03, 0xF8, 0xFE, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xBF, 0x9F, 0xC0, 0x3F, 0x9F, 0x9F,
  0xDF, 0xE0, 0x1F, 0xDF, 0xCF, 0xEF, 0xE0, 0x0F, 0xEF, 0xC7, 0xF7, 0xF0,
  0x07, 0xF7, 0xE3, 0xF7, 0xF8, 0x03, 0xFF, 0xF1, 0xFB, 0xF8, 0x01, 0xFF,
  0xF0, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x06, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x11, 0xFF, 0x80, 0x01, 0x3F, 0xFE, 0x00, 0x77, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xEC, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 19, 48, 17, 0, -47 },
  { 115, 23, 17, 26, 6, -47 },
  { 164, 33, 47, 32, 0, -47 },
  { 358, 30, 54, 28, 0, -50 },
  { 561, 42, 49, 46, 3, -48 },
  { 819, 34, 49, 34, 0, -48 },
  { 1028, 12, 17, 16, 6, -47 },
  { 1054, 22, 57, 18, 1, -47 },
  { 1211, 22, 58, 18, -5, -48 },
  { 1371, 25, 28, 27, 5, -51 },
  { 1459, 27, 31, 31, 3, -39 },
  { 1564, 15, 18, 16, -4, -9 },
  { 1598, 17, 8, 19, 1, -22 },
  { 1615, 10, 11, 16, 0, -10 },
  { 1629, 34, 48, 25, -4, -48 },
  { 1833, 28, 49, 28, 1, -48 },
  { 2005, 22, 47, 29, 6, -47 },
  { 2135, 32, 48, 28, -3, -48 },
  { 2327, 30, 49, 28, -1, -48 },
  { 2511, 30, 47, 29, -1, -47 },
  { 2688, 29, 48, 28, 0, -47 },
  { 2862, 29, 49, 28, 2, -48 },
  { 3040, 30, 47, 28, 2, -47 },
  { 3217, 30, 49, 28, 0, -48 },
  { 3401, 29, 49, 28, 0, -48 },
  { 3579, 16, 38, 16, 0, -37 },
  { 3655, 20, 46, 16, -4, -37 },
  { 3770, 28, 31, 31, 2, -39 },
  { 3879, 27, 20, 31, 3, -33 },
  { 3947, 27, 31, 31, 3, -39 },
  { 4052, 23, 49, 22, 2, -48 },
  { 4193, 41, 53, 43, 2, -48 },
  { 4465, 31, 47, 31, -4, -47 },
  { 4648, 32, 47, 31, 0, -47 },
  { 4836, 31, 49, 29, 2, -48 },
  { 5026, 33, 47, 34, 0, -47 },
  { 5220, 30, 47, 26, 0, -47 },
  { 5397, 29, 47, 25, 0, -47 },
  { 5568, 35, 49, 35, 2, -48 },
  { 5783, 37, 47, 35, 0, -47 },
  { 6001, 29, 47, 21, -3, -47 },
  { 6172, 29, 61, 16, -10, -47 },
  { 6394, 37, 47, 30, 0, -47 },
  { 6612, 21, 47, 25, 0, -47 },
  { 6736, 48, 47, 46, 0, -47 },
  { 7018, 39, 47, 37, 0, -47 },
  { 7248, 34, 49, 36, 2, -48 },
  { 7457, 33, 47, 30, 0, -47 },
  { 7651, 34, 59, 36, 2, -48 },
  { 7902, 31, 47, 31, 0, -47 },
  { 8085, 31, 49, 27, -1, -48 },
  { 8275, 26, 47, 26, 5, -47 },
  { 8428, 35, 48, 34, 2, -47 },
  { 8638, 30, 47, 31, 6, -47 },
  { 8815, 48, 47, 46, 4, -47 },
  { 9097, 38, 47, 29, -4, -47 },
  { 9321, 28, 47, 28, 6, -47 },
  { 9486, 33, 47, 26, -3, -47 },
  { 9680, 27, 58, 19, -3, -47 },
  { 9876, 13, 48, 25, 7, -48 },
  { 9954, 26, 58, 19, -5, -47 },
  { 10143, 29, 28, 29, 0, -47 },
  { 10245, 22, 4, 21, -6, 6 },
  { 10256, 12, 11, 20, 10, -51 },
  { 10273, 30, 38, 30, 1, -37 },
  { 10416, 30, 51, 30, -1, -50 },
  { 10608, 25, 38, 24, 1, -37 },
  { 10727, 33, 51, 30, 1, -50 },
  { 10938, 26, 38, 28, 1, -37 },
  { 11062, 34, 66, 18, -8, -50 },
  { 11343, 33, 53, 30, -2, -37 },
  { 11562, 30, 50, 30, -1, -50 },
  { 11750, 19, 50, 15, -1, -50 },
  { 11869, 26, 66, 15, -8, -50 },
  { 12084, 31, 50, 28, 0, -50 },
  { 12278, 20, 50, 15, -1, -50 },
  { 12403, 43, 37, 44, 0, -37 },
  { 12602, 29, 37, 30, 0, -37 },
  { 12737, 27, 38, 29, 1, -37 },
  { 12866, 33, 53, 30, -4, -37 },
  { 13085, 30, 53, 30, 1, -37 },
  { 13284, 25, 37, 21, 0, -37 },
  { 13400, 25, 38, 24, 0, -37 },
  { 13519, 19, 45, 19, 2, -44 },
  { 13626, 29, 37, 30, 1, -36 },
  { 13761, 26, 36, 26, 4, -36 },
  { 13878, 41, 36, 40, 3, -36 },
  { 14063, 33, 36, 27, -3, -36 },
  { 14212, 35, 52, 27, -5, -36 },
  { 14440, 27, 36, 22, -3, -36 },
  { 14562, 26, 57, 22, 1, -47 },
  { 14748, 7, 66, 25, 8, -51 },
  { 14806, 25, 57, 22, -4, -47 },
  { 14985, 28, 11, 31, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC66PT7B_H_
