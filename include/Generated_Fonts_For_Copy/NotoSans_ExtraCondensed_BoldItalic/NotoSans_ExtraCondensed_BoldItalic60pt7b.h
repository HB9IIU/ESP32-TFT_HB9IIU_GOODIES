#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x3F,
  0xC7, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF8, 0xFF,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xDC, 0xF0, 0x07, 0xF3, 0x86, 0x00, 0xFE,
  0x60, 0x00, 0x3F, 0xCC, 0x00, 0x07, 0xF9, 0x80, 0x00, 0xFF, 0x70, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1B, 0xFC, 0x00, 0x03, 0x7F, 0x80, 0x00, 0xE7, 0xF0, 0x00,
  0x1C, 0xFE, 0x08, 0x03, 0x1F, 0xC1, 0xC0, 0x67, 0xF8, 0x3C, 0x0C, 0xFF,
  0x07, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0x7E, 0x01,
  0xF0, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x3E, 0x00, 0x3E,
  0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x87, 0xE0, 0x01, 0xF0,
  0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x3F, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7,
  0xE3, 0xE1, 0xFF, 0x3F, 0x1F, 0x9F, 0x8F, 0xFE, 0xFC, 0xFC, 0xFC, 0x7F,
  0xFB, 0xFF, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0x8F, 0x8F, 0x9F, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3F, 0xE3, 0xF1, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xC3,
  0xF0, 0x00, 0x7E, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x0F,
  0xC7, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x1F,
  0x80, 0x07, 0xC1, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC1, 0xF0, 0x01, 0xF8,
  0x1F, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x07, 0xC7, 0xE0, 0x07, 0xE0, 0x1F, 0x1F, 0x80, 0x1F, 0x00,
  0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x3F, 0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xF1, 0xFE, 0x0F,
  0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xE7, 0xF0, 0xFF, 0x3F, 0xDF, 0xC1, 0xFC,
  0x3F, 0xBF, 0x87, 0xF0, 0x7F, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC0,
  0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0xC1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x06, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0x7E, 0x07, 0xFD, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7C, 0x3F,
  0x80, 0xE0, 0xF8, 0x01, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1F, 0x1F, 0xDF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x7F,
  0x81, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0x8F,
  0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9,
  0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE3, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x07,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0xFE, 0x7F,
  0xFF, 0xCF, 0xE7, 0xF0, 0xF8, 0xFE, 0x0E, 0x1F, 0xC0, 0x87, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x00, 0x78, 0x0F, 0xF0,
  0x07, 0x00, 0xFF, 0x00, 0x20, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0x01, 0xFF, 0x00, 0x60, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x03,
  0xFE, 0x0C, 0x00, 0x7F, 0xC0, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xF3, 0xF8, 0x00, 0x1F,
  0x7F, 0x80, 0x03, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xC7, 0xF0,
  0x00, 0xF8, 0xFF, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x3E,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7C, 0x1F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x10, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x82, 0x00,
  0x1F, 0xE0, 0x70, 0x0F, 0xFC, 0x0F, 0xE7, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x0C,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0,
  0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0,
  0xFF, 0x87, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xF0, 0x0F, 0xF3, 0xF8,
  0x01, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x30, 0x3F, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x78, 0x7F, 0xC1,
  0x80, 0xFF, 0x04, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x07,
  0xF8, 0x3E, 0x07, 0xE0, 0x7F, 0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xE1, 0xF0,
  0xFC, 0x1F, 0xFF, 0x87, 0xC3, 0xE0, 0xFE, 0x7E, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x8F,
  0xC3, 0xE0, 0xFC, 0x3E, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x7C, 0x0F,
  0x83, 0xE3, 0xE1, 0xF0, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF8, 0x7C, 0x7C,
  0x3F, 0x07, 0xC1, 0xF1, 0xF0, 0xF8, 0x1F, 0x07, 0xC7, 0xC3, 0xE0, 0xFC,
  0x1E, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xE3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0x78, 0x3E, 0x0F, 0xDF, 0xF7,
  0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xE0, 0x7F, 0xDF, 0xF8, 0x0F, 0xC1,
  0xFE, 0x3F, 0xC0, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x06, 0x00,
  0x01, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F,
  0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xF8,
  0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0x18, 0x03, 0xFE, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0x8F, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0x3C, 0x03, 0xFF, 0x00, 0x10, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0x07, 0xFF,
  0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x63, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x8F,
  0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0,
  0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xE0, 0x7E,
  0xFF, 0x00, 0x7F, 0x7E, 0x07, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0xFE, 0xFE,
  0x00, 0xFF, 0x7F, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF1, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x1F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF3, 0xF9, 0xFE, 0x00, 0xFE,
  0x7F, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF7, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xF7, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0xFC,
  0x3F, 0x80, 0x1F, 0xC7, 0xFF, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xFC, 0x3F,
  0x80, 0x3F, 0x83, 0xFF, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x7F, 0x80,
  0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0x00, 0x7F,
  0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFE,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0x80, 0x3F, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xFF,
  0x07, 0xF0, 0x07, 0xF3, 0xF0, 0x7F, 0x00, 0x7F, 0x3F, 0x07, 0xF0, 0x07,
  0xF3, 0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0xFE,
  0x00, 0xFF, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE1, 0xFD, 0xFC, 0x00, 0xFE, 0x1F, 0xDF, 0xC0, 0x1F,
  0xC1, 0xFD, 0xFC, 0x01, 0xFC, 0x1F, 0xDF, 0xC0, 0x1F, 0xC0, 0xFD, 0xFC,
  0x01, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xF8, 0x03, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF0,
  0x07, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F,
  0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x78, 0x03, 0xFF,
  0x00, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x02, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0xFF, 0x00,
  0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE1, 0xFC, 0x07,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFF, 0xE0, 0xFF,
  0x03, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0x87, 0xF8, 0x0F,
  0xE1, 0xFB, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0, 0x3F, 0x8F,
  0xEF, 0xC7, 0xF8, 0x07, 0xF1, 0xF9, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x3F,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE7, 0xE7, 0xF8, 0x03, 0xF9, 0xF8, 0xFC, 0xFE,
  0x00, 0x7F, 0x7F, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xC7, 0xF7, 0xF0, 0x01,
  0xFD, 0xF8, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xBF, 0xC0, 0x07, 0xEF,
  0xC3, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFC,
  0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x1F, 0xF1, 0xFC, 0x07, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xF0, 0x7F, 0x87, 0xFE, 0x1F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83,
  0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF7,
  0xF0, 0x0F, 0xFC, 0xFE, 0x01, 0xFF, 0x9F, 0xC0, 0x1F, 0xC3, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F,
  0xF0, 0x7F, 0x83, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xF0, 0x0F, 0xCF, 0xFC, 0x01, 0xF8,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0x1C, 0x07, 0xFC, 0x08, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0x01, 0xFF, 0x1E, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xFD, 0xFE, 0x00, 0x7F, 0xF7, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xF0, 0x0F,
  0xF0, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0xFE, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x7F, 0x8F, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x8F, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x60, 0x7F, 0xC7, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x19, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0xE7, 0xF0,
  0x03, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xBF, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x01, 0xFE, 0x00, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0xDF, 0xF0, 0x0F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x06, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x07,
  0xE3, 0xFE, 0x1F, 0xF0, 0x0F, 0xDF, 0xFE, 0x7F, 0xF0, 0x1F, 0xBF, 0xFD,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0x9F, 0xFC, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x7F, 0xC0, 0x3F, 0x3F, 0xF8, 0x0F, 0xDF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFC, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0xFF, 0x80, 0x07, 0xE7, 0xFF, 0x00, 0x1F, 0xBF,
  0xFE, 0x00, 0x7E, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFF, 0x06, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x0F,
  0xF9, 0xFC, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0x40,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0xC0, 0xFD, 0xFE, 0x03, 0xF7, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07,
  0x07, 0xF8, 0x04, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC2, 0x00, 0xFF, 0x0F, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x00,
  0xFF, 0xCF, 0xC0, 0x1F, 0xE3, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F,
  0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFE,
  0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x81, 0xFC, 0xFE,
  0x0F, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0xE0, 0xFE, 0x3F, 0x83, 0xFF, 0x07,
  0xF1, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFF, 0xE1, 0xFC, 0x1F, 0x87, 0xDF, 0x0F, 0xE0,
  0xFC, 0x7E, 0xF8, 0xFE, 0x07, 0xE3, 0xF7, 0xC7, 0xF0, 0x3F, 0x1F, 0x7E,
  0x3F, 0x81, 0xF9, 0xFB, 0xF3, 0xF8, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0xFE,
  0xFC, 0xFC, 0xFC, 0x07, 0xF7, 0xE7, 0xEF, 0xE0, 0x3F, 0xBF, 0x3F, 0x7F,
  0x01, 0xFF, 0xF1, 0xFB, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF8,
  0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x43, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00, 0xDF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFE, 0xC0, 0x07, 0xFE, 0x40, 0x00, 0x3C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 17, 44, 15, 0, -43 },
  { 95, 21, 16, 24, 6, -43 },
  { 137, 30, 43, 29, 0, -43 },
  { 299, 27, 49, 25, 0, -46 },
  { 465, 38, 44, 42, 3, -43 },
  { 674, 31, 44, 31, 0, -43 },
  { 845, 10, 16, 15, 6, -43 },
  { 865, 20, 52, 16, 1, -43 },
  { 995, 20, 53, 16, -5, -44 },
  { 1128, 22, 25, 25, 5, -46 },
  { 1197, 25, 29, 28, 2, -36 },
  { 1288, 13, 16, 14, -3, -8 },
  { 1314, 15, 8, 17, 1, -20 },
  { 1329, 9, 10, 14, 0, -9 },
  { 1341, 30, 43, 22, -3, -43 },
  { 1503, 25, 44, 25, 1, -43 },
  { 1641, 19, 43, 26, 6, -43 },
  { 1744, 28, 43, 25, -2, -43 },
  { 1895, 28, 44, 25, -1, -43 },
  { 2049, 28, 43, 26, -1, -43 },
  { 2200, 27, 44, 25, 0, -43 },
  { 2349, 27, 45, 25, 1, -44 },
  { 2501, 28, 43, 25, 1, -43 },
  { 2652, 27, 44, 25, 0, -43 },
  { 2801, 26, 45, 25, 0, -44 },
  { 2948, 14, 34, 15, 0, -33 },
  { 3008, 18, 41, 15, -3, -33 },
  { 3101, 25, 29, 28, 2, -36 },
  { 3192, 25, 18, 28, 2, -30 },
  { 3249, 25, 29, 28, 2, -36 },
  { 3340, 22, 44, 20, 1, -43 },
  { 3461, 38, 48, 39, 1, -43 },
  { 3689, 28, 43, 28, -4, -43 },
  { 3840, 29, 43, 29, 0, -43 },
  { 3996, 28, 44, 26, 2, -43 },
  { 4150, 30, 43, 31, 0, -43 },
  { 4312, 27, 43, 24, 0, -43 },
  { 4458, 27, 43, 23, 0, -43 },
  { 4604, 31, 44, 32, 2, -43 },
  { 4775, 34, 43, 32, 0, -43 },
  { 4958, 26, 43, 19, -3, -43 },
  { 5098, 26, 56, 15, -9, -43 },
  { 5280, 33, 43, 28, 0, -43 },
  { 5458, 19, 43, 23, 0, -43 },
  { 5561, 44, 43, 42, 0, -43 },
  { 5798, 36, 43, 34, 0, -43 },
  { 5992, 30, 45, 33, 2, -44 },
  { 6161, 30, 43, 28, 0, -43 },
  { 6323, 30, 54, 33, 2, -44 },
  { 6526, 28, 43, 28, 0, -43 },
  { 6677, 29, 44, 25, -1, -43 },
  { 6837, 24, 43, 24, 4, -43 },
  { 6966, 31, 44, 31, 2, -43 },
  { 7137, 28, 43, 28, 5, -43 },
  { 7288, 43, 43, 42, 4, -43 },
  { 7520, 34, 43, 26, -3, -43 },
  { 7703, 26, 43, 26, 5, -43 },
  { 7843, 29, 43, 23, -2, -43 },
  { 7999, 23, 53, 17, -2, -43 },
  { 8152, 12, 43, 23, 6, -43 },
  { 8217, 23, 53, 17, -4, -43 },
  { 8370, 26, 26, 26, 0, -43 },
  { 8455, 21, 4, 19, -6, 5 },
  { 8466, 11, 10, 18, 9, -46 },
  { 8480, 27, 34, 28, 1, -33 },
  { 8595, 27, 47, 28, 0, -46 },
  { 8754, 23, 34, 22, 1, -33 },
  { 8852, 30, 47, 28, 1, -46 },
  { 9029, 24, 34, 25, 1, -33 },
  { 9131, 31, 60, 17, -7, -46 },
  { 9364, 30, 47, 28, -2, -33 },
  { 9541, 26, 46, 28, 0, -46 },
  { 9691, 17, 46, 14, 0, -46 },
  { 9789, 25, 60, 14, -8, -46 },
  { 9977, 29, 46, 26, 0, -46 },
  { 10144, 17, 46, 14, 0, -46 },
  { 10242, 39, 33, 40, 0, -33 },
  { 10403, 26, 33, 28, 0, -33 },
  { 10511, 25, 34, 27, 1, -33 },
  { 10618, 30, 47, 28, -3, -33 },
  { 10795, 27, 47, 28, 1, -33 },
  { 10954, 22, 33, 19, 0, -33 },
  { 11045, 22, 34, 22, 0, -33 },
  { 11139, 17, 41, 18, 2, -40 },
  { 11227, 26, 34, 27, 1, -33 },
  { 11338, 23, 33, 24, 4, -33 },
  { 11433, 37, 33, 37, 3, -33 },
  { 11586, 30, 33, 24, -3, -33 },
  { 11710, 32, 47, 24, -5, -33 },
  { 11898, 24, 33, 20, -2, -33 },
  { 11997, 24, 52, 20, 1, -43 },
  { 12153, 7, 60, 22, 7, -46 },
  { 12206, 24, 52, 20, -4, -43 },
  { 12362, 25, 10, 28, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC60PT7B_H_
