#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7B, 0xE0, 0x4D, 0x2C, 0x7F, 0x37, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0x56, 0x80, 0x5D, 0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A,
  0x40, 0x77, 0x60, 0xEA, 0xE9, 0x60, 0xE9, 0x60, 0x7B, 0x20, 0x79, 0x60,
  0x7B, 0x60, 0x69, 0x40, 0xEB, 0x60, 0xF5, 0x60, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xDA, 0x7F, 0xFE, 0x5F, 0x6E, 0xE0, 0x72, 0x60, 0x76,
  0xE0, 0x6A, 0x60, 0x7A, 0x40, 0x72, 0xF0, 0x6E, 0xD0, 0x5B, 0x29, 0x2C,
  0x6B, 0x60, 0x6B, 0x55, 0xFD, 0x56, 0xAA, 0x76, 0xE0, 0x77, 0x40, 0x76,
  0xE4, 0x77, 0x60, 0x79, 0x60, 0xE9, 0x40, 0x76, 0xE0, 0xFA, 0xAD, 0xBD,
  0x40, 0x69, 0x60, 0xEA, 0x6A, 0x60, 0x6A, 0x80, 0xF0, 0x5A, 0x80, 0x54,
  0xC0, 0x80, 0xF7, 0x00, 0x4A, 0xDC, 0xEC, 0x2E, 0xDC, 0xFC, 0x25, 0x25,
  0x80, 0xF7, 0x60, 0x4A, 0xDC, 0x4A, 0x80, 0x21, 0x25, 0x80, 0x4F, 0x6C,
  0x5A, 0x80, 0xFD, 0xD0, 0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x20,
  0xE8, 0xDC, 0x6A, 0xB7, 0x00, 0xFA, 0x00, 0xFE, 0xA0, 0xEB, 0x00, 0xBA,
  0x40, 0xEC, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 2, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 3, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 1, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 1, 0, -3 },
  { 45, 1, 4, 1, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 4, 4, 4, 0, -4 },
  { 54, 2, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 2, 0, -4 },
  { 63, 3, 4, 2, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 3, 5, 1, -1, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 4, 4, 3, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 3, 5, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 2, 0, -4 },
  { 89, 3, 4, 2, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 2, 4, 3, 1, -4 },
  { 94, 5, 4, 4, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 2, 4, 3, 1, -4 },
  { 100, 3, 4, 2, 0, -4 },
  { 102, 2, 5, 2, 0, -4 },
  { 104, 1, 4, 2, 1, -4 },
  { 105, 2, 5, 2, 0, -4 },
  { 107, 3, 2, 3, 0, -4 },
  { 108, 2, 1, 2, -1, 0 },
  { 109, 1, 1, 2, 1, -5 },
  { 110, 3, 3, 3, 0, -3 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 2, 3, 2, 0, -3 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 2, 3, 3, 0, -3 },
  { 118, 3, 6, 2, -1, -5 },
  { 121, 3, 4, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 2, 5, 1, 0, -5 },
  { 127, 3, 6, 1, -1, -5 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 5, 1, 0, -5 },
  { 134, 4, 3, 4, 0, -3 },
  { 136, 3, 3, 3, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 4, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 2, 3, 2, 0, -3 },
  { 145, 2, 3, 2, 0, -3 },
  { 146, 2, 4, 2, 0, -4 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 3, 2, 0, -3 },
  { 151, 4, 3, 4, 0, -3 },
  { 153, 3, 3, 2, 0, -3 },
  { 155, 3, 4, 2, 0, -3 },
  { 157, 2, 3, 2, 0, -3 },
  { 158, 2, 5, 2, 0, -4 },
  { 160, 1, 6, 2, 1, -5 },
  { 161, 2, 5, 2, 0, -4 },
  { 163, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC6PT7B_H_
