#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF1,
  0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFD, 0xCF, 0x80, 0x1F, 0xE7, 0x0E, 0x00, 0xFF, 0x1C,
  0x10, 0x03, 0xFC, 0x60, 0x00, 0x0F, 0xF3, 0x80, 0x00, 0x3F, 0xCE, 0x00,
  0x00, 0xFF, 0xB8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1D, 0xFF, 0x00, 0x00, 0x77, 0xFC,
  0x00, 0x01, 0x8F, 0xF0, 0x40, 0x0E, 0x3F, 0xC0, 0x80, 0x39, 0xFF, 0x07,
  0x80, 0xE7, 0xFC, 0x1F, 0x03, 0x3F, 0xE0, 0x7F, 0x8D, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF8,
  0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0xFF, 0xCF,
  0xE3, 0xF8, 0xFC, 0x7F, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x7E, 0x7F,
  0x3F, 0x8F, 0xFF, 0xDF, 0xFF, 0x8F, 0xC7, 0xF7, 0xF7, 0xFF, 0xC7, 0xF1,
  0xF8, 0xFC, 0xFF, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC7, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x10, 0x1F, 0xC7, 0xE0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0,
  0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x07, 0xE0, 0x1F,
  0x87, 0xE0, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xC0, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0x87, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFE, 0x1F, 0xF7, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x1F,
  0xE1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x81, 0xFC, 0x00, 0xF0, 0xFE, 0x00,
  0x7E, 0x7F, 0x01, 0x3F, 0xFF, 0x8F, 0xBF, 0xFF, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x1F, 0x07, 0xF8, 0x07, 0x03, 0xF0, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x1F, 0x8F, 0xF7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F,
  0x80, 0x7F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x07, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0x7F, 0x87,
  0xF1, 0xFE, 0x0F, 0x8F, 0xF8, 0x1C, 0x3F, 0xC0, 0x20, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x3F, 0x81,
  0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0x18, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0x1F, 0xFE,
  0x00, 0x70, 0x0F, 0xFC, 0x00, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x40, 0x00, 0x7F, 0xC0,
  0xC0, 0x03, 0xFF, 0x81, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7D, 0xFE, 0x00, 0x01, 0xFB,
  0xFC, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x3F, 0x3F,
  0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x01, 0xF1, 0xFF, 0x00, 0x07, 0xE3, 0xFC,
  0x00, 0x1F, 0x87, 0xF8, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xE0,
  0x03, 0xF0, 0x7F, 0x80, 0x07, 0xE0, 0xFF, 0x00, 0x1F, 0x81, 0xFE, 0x00,
  0x7E, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x08, 0x00, 0x3F, 0xF0, 0x38,
  0x01, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x20, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0xCF,
  0xF8, 0x03, 0xFE, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xCF, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xE7,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0x9F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC,
  0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0x8F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x04, 0x01, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x83, 0xFE, 0x0C, 0x03, 0xFC, 0x20,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0xFC, 0x1F, 0x80, 0xFF, 0xFC, 0x3E, 0x1F,
  0x81, 0xFF, 0xFC, 0x1F, 0x0F, 0xC0, 0xFF, 0xFE, 0x0F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x07, 0xC7, 0xE0, 0xFE, 0x1F, 0x87, 0xE3, 0xE0, 0x7E, 0x0F, 0x83,
  0xF3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x7E, 0x1F, 0x81,
  0xF8, 0x1F, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x9F, 0x07, 0xE0, 0x7E, 0x0F,
  0xDF, 0x83, 0xF0, 0x3F, 0x07, 0xCF, 0xC3, 0xF0, 0x3F, 0x03, 0xE7, 0xE1,
  0xF8, 0x1F, 0x83, 0xF3, 0xF0, 0xFC, 0x0F, 0xC1, 0xF1, 0xF0, 0x7E, 0x0F,
  0xE0, 0xF8, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x87, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC7, 0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x81,
  0xFF, 0xDF, 0xFE, 0x07, 0xC0, 0xFF, 0xCF, 0xFE, 0x03, 0xE0, 0x3F, 0xC3,
  0xFE, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x07,
  0xF9, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xF9, 0xF8, 0x01, 0xFF, 0xC0, 0x30, 0x01, 0xFF, 0x80, 0x10, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x00, 0x7F, 0xF8,
  0x7C, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x08, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF,
  0x07, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0x81, 0xFF, 0xFF,
  0x00, 0x3F, 0xDF, 0xC0, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x7F, 0x7F,
  0x80, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x3F, 0x9F,
  0xE0, 0x07, 0xF9, 0xFC, 0x3F, 0x9F, 0xF0, 0x03, 0xFC, 0xFE, 0x1F, 0xCF,
  0xF0, 0x03, 0xFC, 0x7F, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0x8F, 0xE3,
  0xFC, 0x00, 0xFF, 0x1F, 0xCF, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE7, 0xF1,
  0xFF, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFB, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFD, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFF,
  0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFD, 0xFC, 0x07, 0xF0,
  0x01, 0xFD, 0xFC, 0x0F, 0xF0, 0x03, 0xFD, 0xFC, 0x0F, 0xF0, 0x03, 0xFD,
  0xFE, 0x0F, 0xF0, 0x03, 0xFD, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xBF, 0xC0, 0x0F, 0xE0,
  0x7F, 0xBF, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE,
  0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x30, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x00, 0xFF, 0x80, 0x70, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x80, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F,
  0x81, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF7, 0xE0, 0xFF, 0x80, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x00, 0xFF,
  0x0F, 0xEF, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xEF, 0xE1, 0xFE, 0x00, 0xFF,
  0x0F, 0xEF, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xCF, 0xE3, 0xFC, 0x00, 0xFF,
  0x1F, 0xCF, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0x8F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0x8F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0x8F, 0xEF, 0xF8, 0x00, 0xFF,
  0x7F, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x9F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x87, 0xF0, 0x0F,
  0xFF, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0x01, 0xFF, 0xFB, 0xF8, 0x03, 0xFF,
  0xCF, 0xE0, 0x07, 0xFE, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xF0,
  0x00, 0x7F, 0x9F, 0xF8, 0x00, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0xFC, 0x00,
  0xFE, 0x7F, 0xF0, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFC, 0x38, 0x0F, 0xFC, 0x04, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x20, 0x1F, 0xF0,
  0x38, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x7F,
  0xF3, 0xFC, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0x8F, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xE1, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x1F, 0xF8, 0x1E, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xBF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0x9F, 0xE0, 0x03, 0xFF,
  0xEF, 0xF0, 0x03, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xE7,
  0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x00, 0x3F, 0xE0, 0x0E, 0x00,
  0x3F, 0xF0, 0x07, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xCF, 0xFC,
  0x00, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x77, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xFE,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xC7, 0xFE, 0x0F, 0xF8, 0x01, 0xFD, 0xFF, 0xE3,
  0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x7F, 0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF1, 0xFF, 0xE3, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x81, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xFF, 0x00, 0x7E, 0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xE0,
  0x1F, 0xBF, 0xFF, 0x81, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF3, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0,
  0x7F, 0x8F, 0xF8, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03,
  0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xDF, 0xF0, 0x0F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xC7, 0xF8,
  0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xF0, 0x00, 0x7F,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xF8, 0x00, 0xFF, 0x7F,
  0xFC, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xFC,
  0x1C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0x9F, 0xC0, 0x3F, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC3,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0xE0, 0x07, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFE, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x3F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3C, 0x0F,
  0xF8, 0x04, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x08, 0x01, 0xFF, 0x07, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFD, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x83, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xCF,
  0xE0, 0x0F, 0xFE, 0x3F, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x7F,
  0x81, 0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0x87, 0xF8, 0x1F, 0xE3,
  0xF7, 0xE1, 0xFC, 0x07, 0xF9, 0xFD, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x7E,
  0x3F, 0xC0, 0x7F, 0x9F, 0x9F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE7, 0xE7, 0xF8,
  0x07, 0xF3, 0xF1, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0xFE, 0xFF, 0x00, 0x7F,
  0x7F, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0x8F, 0xEF, 0xE0, 0x07, 0xF7, 0xE3,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x04, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x11, 0xFF, 0xC0, 0x01,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xEC, 0x00, 0x1F, 0xFC, 0x80, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 19, 49, 17, 0, -48 },
  { 118, 24, 17, 26, 6, -48 },
  { 169, 34, 48, 32, 0, -48 },
  { 373, 30, 55, 28, 0, -51 },
  { 580, 42, 50, 47, 3, -49 },
  { 843, 34, 49, 35, 0, -48 },
  { 1052, 12, 17, 16, 6, -48 },
  { 1078, 22, 59, 18, 1, -48 },
  { 1241, 22, 60, 18, -5, -49 },
  { 1406, 25, 27, 27, 5, -51 },
  { 1491, 27, 32, 31, 3, -40 },
  { 1599, 15, 18, 16, -4, -9 },
  { 1633, 17, 8, 19, 1, -22 },
  { 1650, 10, 11, 16, 0, -10 },
  { 1664, 35, 48, 25, -4, -48 },
  { 1874, 28, 50, 28, 1, -49 },
  { 2049, 22, 48, 29, 6, -48 },
  { 2181, 32, 49, 28, -3, -49 },
  { 2377, 31, 50, 28, -1, -49 },
  { 2571, 31, 48, 29, -1, -48 },
  { 2757, 30, 49, 28, 0, -48 },
  { 2941, 29, 50, 28, 2, -49 },
  { 3123, 31, 48, 28, 2, -48 },
  { 3309, 30, 50, 28, 0, -49 },
  { 3497, 29, 50, 28, 0, -49 },
  { 3679, 16, 38, 16, 0, -37 },
  { 3755, 20, 46, 16, -4, -37 },
  { 3870, 28, 32, 31, 2, -40 },
  { 3982, 27, 20, 31, 3, -34 },
  { 4050, 27, 32, 31, 3, -40 },
  { 4158, 23, 50, 22, 2, -49 },
  { 4302, 41, 53, 43, 2, -48 },
  { 4574, 31, 48, 31, -4, -48 },
  { 4760, 33, 48, 32, 0, -48 },
  { 4958, 32, 50, 29, 2, -49 },
  { 5158, 34, 48, 34, 0, -48 },
  { 5362, 30, 48, 27, 0, -48 },
  { 5542, 30, 48, 26, 0, -48 },
  { 5722, 35, 50, 35, 2, -49 },
  { 5941, 38, 48, 36, 0, -48 },
  { 6169, 29, 48, 21, -3, -48 },
  { 6343, 29, 62, 17, -10, -48 },
  { 6568, 37, 48, 31, 0, -48 },
  { 6790, 22, 48, 26, 0, -48 },
  { 6922, 49, 48, 47, 0, -48 },
  { 7216, 40, 48, 38, 0, -48 },
  { 7456, 34, 50, 36, 2, -49 },
  { 7669, 33, 48, 31, 0, -48 },
  { 7867, 34, 60, 36, 2, -49 },
  { 8122, 32, 48, 31, 0, -48 },
  { 8314, 32, 50, 28, -1, -49 },
  { 8514, 27, 48, 27, 5, -48 },
  { 8676, 35, 49, 35, 2, -48 },
  { 8891, 31, 48, 31, 6, -48 },
  { 9077, 48, 48, 47, 5, -48 },
  { 9365, 38, 48, 29, -4, -48 },
  { 9593, 29, 48, 28, 6, -48 },
  { 9767, 34, 48, 26, -3, -48 },
  { 9971, 27, 59, 19, -3, -48 },
  { 10171, 14, 48, 25, 7, -48 },
  { 10255, 27, 59, 19, -5, -48 },
  { 10455, 29, 29, 29, 0, -48 },
  { 10561, 22, 4, 22, -6, 6 },
  { 10572, 12, 10, 20, 10, -51 },
  { 10587, 30, 38, 31, 1, -37 },
  { 10730, 31, 52, 31, -1, -51 },
  { 10932, 26, 38, 25, 1, -37 },
  { 11056, 33, 52, 31, 1, -51 },
  { 11271, 27, 38, 28, 1, -37 },
  { 11400, 34, 67, 19, -8, -51 },
  { 11685, 33, 53, 31, -2, -37 },
  { 11904, 30, 51, 31, -1, -51 },
  { 12096, 19, 51, 15, -1, -51 },
  { 12218, 27, 67, 15, -9, -51 },
  { 12445, 32, 51, 28, 0, -51 },
  { 12649, 20, 51, 15, -1, -51 },
  { 12777, 44, 37, 45, 0, -37 },
  { 12981, 29, 37, 31, 0, -37 },
  { 13116, 27, 38, 30, 1, -37 },
  { 13245, 34, 53, 31, -4, -37 },
  { 13471, 30, 53, 31, 1, -37 },
  { 13670, 25, 37, 22, 0, -37 },
  { 13786, 25, 38, 24, 0, -37 },
  { 13905, 20, 45, 20, 2, -44 },
  { 14018, 30, 38, 30, 1, -37 },
  { 14161, 26, 37, 27, 4, -37 },
  { 14282, 42, 37, 41, 3, -37 },
  { 14477, 33, 37, 27, -3, -37 },
  { 14630, 36, 53, 27, -5, -37 },
  { 14869, 28, 37, 23, -3, -37 },
  { 14999, 26, 59, 23, 1, -48 },
  { 15191, 8, 66, 25, 8, -51 },
  { 15257, 26, 59, 23, -4, -48 },
  { 15449, 28, 11, 31, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC67PT7B_H_
