#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0x80, 0xF0, 0x6F, 0x6E, 0xC0, 0x69, 0xFC, 0x56, 0xBE, 0xB5,
  0x00, 0x66, 0x5A, 0xE0, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xE4, 0x5D,
  0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xDC, 0x7A, 0x80, 0x65, 0x2C,
  0x65, 0x1C, 0x2E, 0xF4, 0x6B, 0x9C, 0x6B, 0xDC, 0x65, 0x28, 0x6D, 0x5C,
  0x77, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0x65,
  0x08, 0x33, 0xFB, 0xE8, 0x30, 0x6D, 0xFA, 0x6D, 0xDE, 0x74, 0x88, 0xE0,
  0x65, 0xAA, 0xC0, 0x69, 0xCC, 0x69, 0xC8, 0x74, 0xBA, 0xE0, 0x55, 0x6A,
  0xA0, 0x69, 0x4C, 0x25, 0x25, 0x80, 0x56, 0x4A, 0xA0, 0x5A, 0xC0, 0x4A,
  0xF7, 0x6B, 0x00, 0x55, 0xBA, 0xA0, 0x75, 0x9A, 0xE0, 0x6D, 0xC8, 0x75,
  0x9A, 0xE2, 0x6D, 0xDA, 0x69, 0x1C, 0x69, 0x2C, 0x55, 0xAA, 0xE0, 0xBB,
  0x48, 0x6E, 0xAA, 0x94, 0xD0, 0x76, 0x4C, 0xA0, 0xFA, 0x48, 0x65, 0x4C,
  0x6A, 0x49, 0x00, 0xF8, 0x24, 0x95, 0x80, 0x4E, 0x80, 0xE0, 0x80, 0x76,
  0xF0, 0x4E, 0xDC, 0x72, 0x60, 0x36, 0xAA, 0xE0, 0x77, 0x60, 0x36, 0x44,
  0x44, 0x80, 0x76, 0xF5, 0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0,
  0x4F, 0x6A, 0x5A, 0x80, 0x75, 0x6D, 0x60, 0x76, 0xD0, 0x76, 0xE0, 0x76,
  0xE9, 0x00, 0x76, 0xF4, 0x80, 0x72, 0x40, 0x71, 0x60, 0x7A, 0xC0, 0x76,
  0xF0, 0xB7, 0x20, 0xAD, 0xBD, 0x40, 0xE9, 0x60, 0x55, 0x22, 0x4C, 0xEA,
  0x60, 0x69, 0x69, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 3, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 6, 2, -1, -5 },
  { 22, 2, 3, 3, 1, -5 },
  { 23, 3, 3, 3, 0, -4 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 2, 5, 3, 1, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 2, 5, 2, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 3, 3, 0, -4 },
  { 57, 3, 3, 3, 0, -4 },
  { 59, 3, 5, 2, 0, -5 },
  { 61, 5, 6, 5, 0, -5 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 3, 5, 3, 0, -5 },
  { 69, 4, 5, 3, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 3, 5, 3, 0, -5 },
  { 77, 3, 5, 3, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 3, 5, 2, 0, -5 },
  { 87, 3, 6, 2, -1, -5 },
  { 90, 4, 5, 3, 0, -5 },
  { 93, 2, 5, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 4, 6, 4, 0, -5 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 3, 5, 3, 1, -5 },
  { 121, 6, 5, 5, 0, -5 },
  { 125, 4, 5, 3, 0, -5 },
  { 128, 3, 5, 3, 1, -5 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 3, 6, 2, 0, -5 },
  { 135, 1, 5, 3, 1, -5 },
  { 136, 3, 6, 2, -1, -5 },
  { 139, 3, 3, 3, 0, -5 },
  { 141, 3, 1, 2, -1, 0 },
  { 142, 1, 1, 2, 1, -5 },
  { 143, 3, 4, 3, 0, -4 },
  { 145, 3, 5, 3, 0, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 4, 5, 3, 0, -5 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 4, 7, 2, -1, -5 },
  { 158, 3, 6, 3, 0, -4 },
  { 161, 3, 5, 3, 0, -5 },
  { 163, 2, 5, 2, 0, -5 },
  { 165, 3, 7, 2, -1, -5 },
  { 168, 3, 5, 3, 0, -5 },
  { 170, 2, 5, 2, 0, -5 },
  { 172, 5, 4, 5, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 3, 4, 3, 0, -4 },
  { 179, 3, 6, 3, 0, -4 },
  { 182, 3, 6, 3, 0, -4 },
  { 185, 3, 4, 2, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 2, 5, 2, 0, -5 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 4, 3, 0, -4 },
  { 195, 5, 4, 4, 0, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 4, 6, 3, -1, -4 },
  { 203, 3, 4, 2, 0, -4 },
  { 205, 3, 6, 2, 0, -5 },
  { 208, 1, 7, 3, 1, -5 },
  { 209, 2, 6, 2, 0, -5 },
  { 211, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC7PT7B_H_
