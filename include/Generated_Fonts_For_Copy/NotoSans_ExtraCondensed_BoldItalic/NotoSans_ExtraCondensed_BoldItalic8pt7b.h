#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xA0, 0xF8, 0x35, 0x77, 0xAC, 0x36, 0x42, 0xEC, 0x6D, 0xAE,
  0xF3, 0xAC, 0x26, 0x6F, 0xAF, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0xDF, 0x00, 0x44, 0xF4, 0xC0, 0xC0, 0x80, 0x12, 0x44, 0x88, 0x2E, 0xDB,
  0x80, 0x75, 0xA0, 0x67, 0x26, 0x4E, 0x67, 0x26, 0x2E, 0x32, 0x6A, 0xE4,
  0x74, 0x62, 0x2C, 0x34, 0x6A, 0xAE, 0x72, 0x26, 0x4C, 0x65, 0x6E, 0xAE,
  0x6E, 0xB3, 0x80, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x65,
  0xA1, 0x00, 0x32, 0x6F, 0xBF, 0x41, 0x80, 0x13, 0x33, 0x7D, 0x65, 0x76,
  0xAE, 0x34, 0x48, 0x86, 0x65, 0x55, 0xBE, 0x74, 0x46, 0x8E, 0x74, 0x46,
  0x88, 0x34, 0x4B, 0x96, 0x5A, 0x94, 0xE9, 0x50, 0x69, 0x25, 0x80, 0x24,
  0x94, 0x94, 0x55, 0x66, 0xAA, 0x49, 0x29, 0xC0, 0x6D, 0xB7, 0xAE, 0xAA,
  0xA0, 0x4B, 0x5D, 0x6B, 0x58, 0x35, 0x59, 0x96, 0x65, 0x56, 0x88, 0x35,
  0x59, 0x96, 0x20, 0x65, 0x56, 0xAA, 0x75, 0x46, 0x2C, 0xEA, 0x49, 0x00,
  0x55, 0x5D, 0xBE, 0xB7, 0x6D, 0x00, 0xAD, 0x7D, 0xEB, 0x50, 0x56, 0x66,
  0xAA, 0xBB, 0x49, 0x00, 0x72, 0x24, 0x8E, 0x69, 0x49, 0x30, 0xFC, 0x32,
  0x22, 0x22, 0xC0, 0x2D, 0xD0, 0xE0, 0xC0, 0x7A, 0xAE, 0x44, 0x7A, 0xAE,
  0x72, 0x60, 0x11, 0x7A, 0xAE, 0x7E, 0x70, 0x33, 0x62, 0x44, 0x4C, 0x7A,
  0xAE, 0x2C, 0x49, 0xDB, 0x40, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x45, 0x6C,
  0xAA, 0x56, 0xA0, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x76, 0xF0, 0x7A, 0xAE,
  0x88, 0x7A, 0xAE, 0x24, 0x72, 0x40, 0xE9, 0x60, 0x79, 0x4C, 0x7A, 0xAE,
  0xBA, 0x44, 0xAD, 0x75, 0xE0, 0x74, 0x4A, 0x39, 0x88, 0x44, 0x60, 0x6A,
  0x60, 0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 3, 0, -6 },
  { 10, 5, 6, 6, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 2, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 3, 3, 3, 1, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 4, 6, 3, 0, -6 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 2, 6, 3, 1, -6 },
  { 39, 4, 6, 3, 0, -6 },
  { 42, 4, 6, 3, 0, -6 },
  { 45, 4, 6, 3, 0, -6 },
  { 48, 4, 6, 3, 0, -6 },
  { 51, 4, 6, 3, 0, -6 },
  { 54, 4, 6, 3, 0, -6 },
  { 57, 4, 6, 3, 0, -6 },
  { 60, 3, 6, 3, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 5, 7, 5, 0, -6 },
  { 79, 4, 6, 4, -1, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 3, 0, -6 },
  { 94, 4, 6, 3, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 5, 6, 4, 0, -6 },
  { 104, 3, 6, 3, 0, -6 },
  { 107, 3, 8, 2, -1, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 3, 6, 3, 0, -6 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 5, 6, 4, 0, -6 },
  { 125, 4, 6, 4, 0, -6 },
  { 128, 4, 6, 4, 0, -6 },
  { 131, 4, 7, 4, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 4, 6, 3, 0, -6 },
  { 141, 3, 6, 3, 1, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 3, 6, 4, 1, -6 },
  { 150, 5, 6, 6, 1, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 3, 6, 3, 1, -6 },
  { 160, 4, 6, 3, 0, -6 },
  { 163, 3, 7, 2, 0, -6 },
  { 166, 1, 6, 3, 1, -6 },
  { 167, 4, 7, 2, -1, -6 },
  { 171, 3, 4, 3, 0, -6 },
  { 173, 3, 1, 3, -1, 0 },
  { 174, 2, 1, 2, 1, -6 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 4, 6, 4, 0, -6 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 4, 8, 2, -1, -6 },
  { 191, 4, 6, 4, 0, -4 },
  { 194, 3, 6, 4, 0, -6 },
  { 197, 2, 6, 2, 0, -6 },
  { 199, 3, 8, 2, -1, -6 },
  { 202, 4, 6, 3, 0, -6 },
  { 205, 2, 6, 2, 0, -6 },
  { 207, 5, 4, 5, 0, -4 },
  { 210, 3, 4, 4, 0, -4 },
  { 212, 3, 4, 4, 0, -4 },
  { 214, 4, 6, 4, 0, -4 },
  { 217, 4, 6, 4, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 3, 5, 2, 0, -5 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 4, 3, 0, -4 },
  { 230, 5, 4, 5, 0, -4 },
  { 233, 4, 4, 3, 0, -4 },
  { 235, 5, 6, 3, -1, -4 },
  { 239, 3, 4, 3, 0, -4 },
  { 241, 3, 7, 3, 0, -6 },
  { 244, 1, 8, 3, 1, -6 },
  { 245, 3, 7, 3, 0, -6 },
  { 248, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC8PT7B_H_
