#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x7D, 0xF3,
  0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xCF, 0x8F, 0x3E, 0x3C, 0xF1,
  0xF3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x71,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x1E,
  0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x07,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xC7, 0x80,
  0x1C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8E, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xDC,
  0x0F, 0xB1, 0x03, 0xC8, 0x00, 0xF2, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x02, 0xFC, 0x00, 0xBF, 0x10, 0x6F, 0x86, 0x1B, 0xE1, 0xE7, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x80, 0x3C, 0x07, 0xF0, 0x1E,
  0x07, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xCE, 0x0F, 0x03, 0xC7, 0x87,
  0x01, 0xE3, 0x87, 0x80, 0xF1, 0xC3, 0x80, 0x71, 0xE3, 0xC0, 0x78, 0xF3,
  0xC0, 0x3C, 0x79, 0xE0, 0x1E, 0x39, 0xE1, 0x0F, 0x3C, 0xF3, 0xF7, 0x9E,
  0xF3, 0xFB, 0xFE, 0x7B, 0xFF, 0xFE, 0x79, 0xCF, 0x7F, 0x39, 0xE7, 0x9E,
  0x3C, 0xE3, 0xC0, 0x1C, 0xF1, 0xE0, 0x1E, 0x78, 0xF0, 0x1E, 0x3C, 0x78,
  0x0F, 0x1E, 0x38, 0x0F, 0x0E, 0x3C, 0x07, 0x87, 0x1E, 0x07, 0x83, 0x8E,
  0x03, 0xC1, 0xEF, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F, 0x81, 0xE0, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7D, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF1, 0xF1, 0xFF, 0x1F, 0x3F, 0xF9, 0xF3, 0xEF, 0xBE, 0x7C, 0xFF,
  0xE7, 0xC7, 0xFC, 0xF8, 0x7F, 0xCF, 0x87, 0xF8, 0xF8, 0x3F, 0x8F, 0x83,
  0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFE, 0xFC, 0x3F,
  0x8F, 0xC0, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF9, 0xE3, 0xC0,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x0F, 0x82,
  0x1E, 0x07, 0x3C, 0x0F, 0xF8, 0xDF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F,
  0xFC, 0x7F, 0x81, 0xFF, 0x07, 0xEF, 0x0F, 0x9F, 0x0E, 0x3E, 0x0C, 0x30,
  0x00, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0x78, 0x7C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x3D,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xFB, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x8F, 0xFC, 0xFB, 0xE3, 0x9F, 0x08, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0x87, 0xC0, 0x60, 0xF8, 0x08, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x06, 0x0F, 0xC0, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC4, 0x01, 0xF0, 0xE0, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1D, 0xF0, 0x07, 0xBE, 0x01,
  0xEF, 0x80, 0x39, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0xC0, 0x70, 0xF8, 0x1E,
  0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE4, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x73, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE2, 0x03, 0xF0,
  0xE1, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE2,
  0x00, 0xFB, 0xF0, 0x7D, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0xF8,
  0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xFD, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xCF, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xFC, 0x0F, 0x9F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3F, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF9, 0xF0, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xEF, 0x83, 0xCF, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x83, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0xFC,
  0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x00,
  0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x03, 0xE0, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF, 0x1E, 0xFC, 0x41, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x0F, 0x1E, 0x1F, 0xE7, 0x8E, 0x1F, 0xF3, 0xCF, 0x1F,
  0xF9, 0xE7, 0x0E, 0x3C, 0xF3, 0x8F, 0x1C, 0x7B, 0xC7, 0x1E, 0x39, 0xC7,
  0x8F, 0x1C, 0xE3, 0x87, 0x8E, 0xF1, 0xC3, 0x87, 0x79, 0xE3, 0xC7, 0x3C,
  0xF1, 0xE3, 0x9C, 0x78, 0xF3, 0xCE, 0x3C, 0xF9, 0xC7, 0x1F, 0xFF, 0xC3,
  0x87, 0xEF, 0xE1, 0xC3, 0xE7, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x30, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x7F,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xC1,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x20, 0x7F, 0x38, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x7F, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F,
  0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x30,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xF1, 0xF8, 0x7F, 0x8F,
  0x87, 0xFC, 0x7C, 0x3F, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x7F,
  0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x4F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x81, 0xF0,
  0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01,
  0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xDE,
  0x0F, 0xF8, 0x1E, 0xF0, 0xF7, 0xC1, 0xF7, 0x87, 0xBE, 0x0F, 0xBC, 0x7F,
  0xE0, 0x7D, 0xE3, 0xDF, 0x03, 0xEF, 0x3E, 0xF8, 0x1E, 0x79, 0xE7, 0xC1,
  0xF3, 0xCF, 0x3E, 0x0F, 0x9E, 0xF3, 0xE0, 0x7C, 0xF7, 0x9F, 0x03, 0xC7,
  0xF8, 0xF8, 0x3E, 0x3F, 0xC7, 0xC1, 0xF1, 0xFE, 0x3C, 0x0F, 0x8F, 0xE3,
  0xE0, 0x7C, 0x7F, 0x1F, 0x03, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1,
  0xF0, 0xF8, 0x7C, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x07,
  0xF0, 0x3E, 0x07, 0xF8, 0x3C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F,
  0xF8, 0x7C, 0x0F, 0x78, 0x7C, 0x0F, 0x7C, 0x78, 0x1F, 0x7C, 0xF8, 0x1F,
  0x7C, 0xF8, 0x1F, 0x3C, 0xF8, 0x1F, 0x3C, 0xF8, 0x1E, 0x3C, 0xF0, 0x3E,
  0x3F, 0xF0, 0x3E, 0x3F, 0xF0, 0x3E, 0x3F, 0xF0, 0x3C, 0x1F, 0xE0, 0x7C,
  0x1F, 0xE0, 0x7C, 0x1F, 0xE0, 0x7C, 0x1F, 0xE0, 0x7C, 0x1F, 0xE0, 0x78,
  0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE1, 0xF0, 0x7E, 0x0F,
  0x83, 0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7C, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C,
  0x7E, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7F, 0x7F, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E,
  0x7F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xC3, 0x81, 0xF0, 0x20, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x10, 0x0F, 0x83, 0x03, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0x7E,
  0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xFB, 0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0x81, 0xF7, 0x80,
  0xF8, 0x1F, 0x78, 0x0F, 0x81, 0xFF, 0x81, 0xF8, 0x3E, 0xF8, 0x1F, 0x83,
  0xEF, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7C, 0xF8,
  0x7F, 0x0F, 0x8F, 0x87, 0xF0, 0xF8, 0xF8, 0xFF, 0x0F, 0x8F, 0x8F, 0xF1,
  0xF0, 0xF8, 0xFF, 0x1F, 0x0F, 0x9E, 0xF3, 0xE0, 0xF9, 0xEF, 0x3E, 0x0F,
  0xBE, 0xF3, 0xE0, 0xFB, 0xCF, 0x7C, 0x0F, 0xBC, 0xF7, 0xC0, 0xFF, 0x8F,
  0x78, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xFC,
  0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1,
  0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF8, 0xF8,
  0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F,
  0x1F, 0x1F, 0x0F, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x3E, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFD, 0xF9,
  0xF3, 0xE3, 0xE3, 0xC7, 0x80, 0x03, 0xE7, 0xC3, 0xFD, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0x3F, 0x8F, 0xC7, 0xE7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0x78, 0x0F, 0x9E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x9F, 0x03, 0xEF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x0F, 0xCF, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F, 0x87, 0xE7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x3E, 0x1F, 0x9F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF7, 0xF8,
  0x3C, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xF8,
  0x87, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x21, 0xF8,
  0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x7F, 0x78, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x3F, 0x3F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0x78, 0x03, 0xE7, 0x80,
  0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xF1, 0xE7, 0xC3, 0xCF,
  0x07, 0xBE, 0x1F, 0x7C, 0x7E, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xF0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x23, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x1F, 0xDE, 0x03,
  0xFD, 0xE0, 0x7F, 0xFE, 0x0F, 0xCF, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFB,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0xC0,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0x07, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFD, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE0, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0x8F,
  0xC1, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x1E, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x3F, 0x1F, 0x03, 0xDF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x1F, 0xDF, 0xEF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x1F, 0x1E, 0x0F, 0x07, 0x8F, 0x87, 0xC3, 0xE3, 0xE1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x07, 0x87, 0xC7,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0x8F, 0x83, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x80, 0x0F, 0x1F, 0x07, 0x9F, 0xC3, 0xDF, 0xE1, 0xFF, 0xF1, 0xFD,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3,
  0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x3E,
  0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8,
  0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xC7, 0xC0,
  0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x3F, 0xFE, 0x07, 0xF3, 0xF0, 0x7E, 0x3F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3E,
  0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC1, 0xFD, 0xE0, 0xFF, 0x78, 0x7F, 0xFE,
  0x1F, 0x3F, 0x8F, 0x87, 0xE3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0x78, 0x0F, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x1E, 0x1E, 0x78, 0x3D, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC3, 0xFC, 0x87, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF0, 0x87, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x81, 0xF1, 0x87, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0xF3, 0xFF,
  0x7F, 0xE7, 0xFE, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3,
  0xE3, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C,
  0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xF7, 0x83, 0xF3, 0xC0, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0x78,
  0x3E, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0x79,
  0xF0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x78, 0x3E, 0x0F, 0xBC, 0x3F, 0x0F, 0x9E, 0x1F, 0x87, 0xDF, 0x0F,
  0xC3, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xE3, 0xE7, 0xF9, 0xF1, 0xF3,
  0xFC, 0xF8, 0xF9, 0xDE, 0x78, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBC, 0x1F,
  0xF3, 0xDE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x81,
  0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x3C, 0x7C, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xBE,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 29, 10, 0, -29 },
  { 45, 14, 11, 16, 4, -29 },
  { 65, 20, 29, 19, 0, -29 },
  { 138, 18, 32, 17, 0, -30 },
  { 210, 25, 29, 28, 2, -29 },
  { 301, 20, 29, 21, 0, -29 },
  { 374, 7, 11, 10, 4, -29 },
  { 384, 13, 35, 11, 1, -29 },
  { 441, 13, 35, 11, -3, -29 },
  { 498, 15, 17, 16, 3, -31 },
  { 530, 16, 19, 19, 2, -24 },
  { 568, 9, 10, 9, -2, -5 },
  { 580, 11, 5, 12, 0, -13 },
  { 587, 6, 6, 9, 0, -6 },
  { 592, 20, 29, 15, -2, -29 },
  { 665, 16, 29, 17, 1, -29 },
  { 723, 13, 29, 17, 4, -29 },
  { 771, 19, 29, 17, -2, -29 },
  { 840, 19, 29, 17, -1, -29 },
  { 909, 19, 29, 17, -1, -29 },
  { 978, 18, 29, 17, 0, -29 },
  { 1044, 18, 29, 17, 1, -29 },
  { 1110, 18, 29, 17, 1, -29 },
  { 1176, 18, 29, 17, 0, -29 },
  { 1242, 17, 29, 17, 0, -29 },
  { 1304, 10, 22, 10, 0, -22 },
  { 1332, 12, 27, 10, -2, -22 },
  { 1373, 17, 19, 19, 1, -24 },
  { 1414, 16, 12, 19, 2, -20 },
  { 1438, 16, 19, 19, 2, -24 },
  { 1476, 14, 29, 13, 1, -29 },
  { 1527, 25, 32, 26, 1, -29 },
  { 1627, 18, 29, 19, -2, -29 },
  { 1693, 19, 29, 19, 0, -29 },
  { 1762, 19, 29, 18, 1, -29 },
  { 1831, 20, 29, 21, 0, -29 },
  { 1904, 18, 29, 16, 0, -29 },
  { 1970, 18, 29, 15, 0, -29 },
  { 2036, 21, 29, 21, 1, -29 },
  { 2113, 23, 29, 21, 0, -29 },
  { 2197, 18, 29, 13, -2, -29 },
  { 2263, 17, 37, 10, -6, -29 },
  { 2342, 22, 29, 18, 0, -29 },
  { 2422, 13, 29, 15, 0, -29 },
  { 2470, 29, 29, 28, 0, -29 },
  { 2576, 24, 29, 22, 0, -29 },
  { 2663, 21, 29, 22, 1, -29 },
  { 2740, 20, 29, 18, 0, -29 },
  { 2813, 21, 36, 22, 1, -29 },
  { 2908, 19, 29, 19, 0, -29 },
  { 2977, 19, 29, 16, -1, -29 },
  { 3046, 16, 29, 16, 3, -29 },
  { 3104, 21, 29, 21, 1, -29 },
  { 3181, 18, 29, 19, 4, -29 },
  { 3247, 28, 29, 28, 3, -29 },
  { 3349, 22, 29, 18, -2, -29 },
  { 3429, 17, 29, 17, 4, -29 },
  { 3491, 20, 29, 16, -2, -29 },
  { 3564, 16, 35, 11, -2, -29 },
  { 3634, 8, 29, 15, 4, -29 },
  { 3663, 16, 35, 11, -3, -29 },
  { 3733, 17, 18, 17, 0, -29 },
  { 3772, 14, 3, 13, -4, 3 },
  { 3778, 7, 7, 12, 6, -31 },
  { 3785, 18, 22, 18, 1, -22 },
  { 3835, 18, 30, 18, 0, -30 },
  { 3903, 15, 22, 15, 1, -22 },
  { 3945, 20, 30, 18, 1, -30 },
  { 4020, 15, 22, 17, 1, -22 },
  { 4062, 21, 41, 11, -5, -31 },
  { 4170, 20, 32, 18, -1, -22 },
  { 4250, 17, 30, 18, 0, -30 },
  { 4314, 11, 30, 9, 0, -30 },
  { 4356, 16, 40, 9, -5, -30 },
  { 4436, 19, 30, 17, 0, -30 },
  { 4508, 11, 30, 9, 0, -30 },
  { 4550, 26, 22, 27, 0, -22 },
  { 4622, 17, 22, 18, 0, -22 },
  { 4669, 16, 22, 18, 1, -22 },
  { 4713, 20, 31, 18, -2, -22 },
  { 4791, 18, 32, 18, 1, -22 },
  { 4863, 15, 22, 13, 0, -22 },
  { 4905, 15, 22, 14, 0, -22 },
  { 4947, 12, 26, 12, 1, -26 },
  { 4986, 17, 22, 18, 1, -22 },
  { 5033, 16, 22, 16, 2, -22 },
  { 5077, 25, 22, 25, 2, -22 },
  { 5146, 20, 22, 16, -2, -22 },
  { 5201, 21, 32, 16, -3, -22 },
  { 5285, 17, 22, 14, -2, -22 },
  { 5332, 16, 35, 14, 0, -29 },
  { 5402, 4, 40, 15, 5, -31 },
  { 5422, 15, 35, 14, -2, -29 },
  { 5488, 17, 6, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC40PT7B_H_
