#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x70, 0x00, 0x18, 0xE3, 0x80,
  0x6F, 0xDB, 0xB6, 0x6C, 0xC0, 0x0E, 0xC3, 0x60, 0xD8, 0x26, 0x3F, 0xD6,
  0xC1, 0x30, 0xC8, 0xFF, 0xBF, 0xE6, 0x41, 0xB0, 0x6C, 0x33, 0x00, 0x02,
  0x03, 0x87, 0xE7, 0xE3, 0x41, 0xA0, 0xF0, 0x3C, 0x0F, 0x07, 0x83, 0xDA,
  0xEF, 0xE7, 0xE0, 0x40, 0x20, 0x38, 0x63, 0x66, 0x13, 0x31, 0x9B, 0x0C,
  0x90, 0x6D, 0xBB, 0x6B, 0xDE, 0xDB, 0x0D, 0x98, 0x6C, 0x86, 0x6C, 0x33,
  0x63, 0x1E, 0x38, 0xF0, 0x0F, 0x06, 0xE1, 0xB8, 0x6C, 0x1F, 0x07, 0x81,
  0xC1, 0xF7, 0x6F, 0xBB, 0xEC, 0x73, 0x9C, 0xFF, 0x9E, 0xE0, 0x7F, 0xEC,
  0x0E, 0x38, 0x61, 0xC3, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x06, 0x18, 0x31, 0xC0, 0x19, 0x33, 0xDF, 0xF3, 0x9F,
  0x33, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x37, 0x76, 0xEC, 0x7B, 0xFE, 0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x00, 0x0F, 0x0F, 0x8E, 0xE6, 0x77, 0x3B, 0x99, 0x8C, 0xC6, 0x67, 0x73,
  0xB9, 0x9D, 0xC7, 0xC3, 0xC0, 0x1C, 0xF7, 0xFF, 0x58, 0x63, 0x8E, 0x30,
  0xC3, 0x1C, 0x71, 0x80, 0x0F, 0x87, 0xF1, 0x9C, 0x07, 0x01, 0x80, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0x3F, 0x80, 0x1F, 0x1F,
  0xC8, 0xE0, 0x70, 0x30, 0x78, 0x70, 0x7C, 0x07, 0x03, 0x81, 0x91, 0xCF,
  0xC7, 0xC0, 0x03, 0x83, 0x81, 0xC1, 0xE1, 0xF0, 0xB8, 0xD8, 0xCC, 0x46,
  0x7F, 0xBF, 0xC1, 0x80, 0xC0, 0xE0, 0x1F, 0x8F, 0xCE, 0x06, 0x03, 0x01,
  0xF1, 0xF8, 0x4E, 0x07, 0x03, 0x81, 0x91, 0xCF, 0xC7, 0xC0, 0x01, 0x03,
  0xC3, 0xE3, 0x03, 0x81, 0x81, 0xFC, 0xFE, 0x77, 0x33, 0x99, 0xDC, 0xE6,
  0xE3, 0xF0, 0xF0, 0x3F, 0xCF, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x1F, 0x1F, 0xCC,
  0xE6, 0x73, 0x31, 0xF8, 0x70, 0x7C, 0x67, 0x73, 0xB9, 0xDC, 0xCF, 0xE3,
  0xE0, 0x04, 0x0F, 0x8F, 0xC6, 0x77, 0x3B, 0x9D, 0xCC, 0xEE, 0x7F, 0x1F,
  0x81, 0x81, 0xC1, 0xC7, 0xE3, 0xE0, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x67,
  0x38, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x31, 0xC7, 0x18, 0xE3, 0x00,
  0x01, 0x07, 0x1F, 0x7C, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x0F, 0x7C, 0xF0,
  0xC0, 0x80, 0x3E, 0x3F, 0x27, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x60, 0xE0, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x63, 0x33, 0x7D,
  0xB2, 0x6D, 0xB2, 0x69, 0xB2, 0x49, 0x92, 0x4D, 0xB3, 0xF9, 0x99, 0x86,
  0x00, 0x30, 0x40, 0xFE, 0x01, 0x80, 0x07, 0x83, 0xC1, 0xE1, 0xB0, 0xD8,
  0xEC, 0x66, 0x33, 0x3F, 0x9F, 0xDC, 0x6C, 0x3E, 0x1F, 0x0C, 0x1F, 0x87,
  0xF3, 0x9C, 0xE7, 0x31, 0x8C, 0xE3, 0xE1, 0xFC, 0x73, 0x98, 0xE6, 0x33,
  0x9C, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0x8E, 0x4E, 0x07, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x8F, 0xC3, 0xE0, 0x1F, 0x87, 0xF3, 0x9C,
  0xE7, 0x39, 0xCC, 0x73, 0x1D, 0xC7, 0x71, 0x9C, 0xE6, 0x3B, 0xBC, 0xFE,
  0x3F, 0x00, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0x81, 0xF8, 0xF8, 0xFC, 0x70,
  0x38, 0x18, 0x1C, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0x81,
  0x80, 0xF8, 0xFC, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x0F, 0xCF,
  0xF3, 0x89, 0xC0, 0x70, 0x38, 0x0E, 0x7B, 0x9E, 0xEB, 0xB8, 0xCE, 0x33,
  0x9C, 0xFF, 0x1F, 0x80, 0x1C, 0xE3, 0x1C, 0xE3, 0x9C, 0x63, 0x8C, 0x7F,
  0x8F, 0xF3, 0xFE, 0x71, 0x8E, 0x31, 0x8E, 0x71, 0xCE, 0x39, 0xC6, 0x00,
  0x1F, 0x87, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x07, 0x07, 0xC7, 0xE0, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0xF8, 0x78,
  0x00, 0x18, 0xE3, 0x38, 0xEE, 0x1D, 0xC3, 0x70, 0x7C, 0x0F, 0x83, 0xF0,
  0x7E, 0x0C, 0xC1, 0x98, 0x73, 0x8E, 0x71, 0xCE, 0x00, 0x1C, 0x63, 0x8E,
  0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x38, 0xFF, 0xF0, 0x1C, 0x1E, 0x38, 0x78,
  0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0xC7, 0x9F, 0x0F, 0xB6, 0x3F, 0x7C, 0x6F,
  0xB8, 0xDF, 0x61, 0x9C, 0xC7, 0x39, 0x8E, 0x67, 0x18, 0xCE, 0x00, 0x1C,
  0x71, 0xC6, 0x3C, 0x63, 0xC6, 0x3E, 0xE3, 0x6E, 0x36, 0xC7, 0x6C, 0x66,
  0xC6, 0x7C, 0x67, 0xCE, 0x38, 0xE3, 0x8C, 0x38, 0x02, 0x07, 0xE3, 0xF8,
  0xE7, 0x71, 0xD8, 0x7E, 0x1F, 0x87, 0xE1, 0xB8, 0xEC, 0x3B, 0x9C, 0xE7,
  0x3F, 0x87, 0xC0, 0x1F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xCC, 0x73, 0x39,
  0xFC, 0x7E, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x02, 0x07, 0xE3,
  0xF8, 0xE7, 0x71, 0xD8, 0x7E, 0x1F, 0x87, 0xE1, 0xB8, 0xEC, 0x3B, 0x9C,
  0xE7, 0x3F, 0x87, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x1F, 0x0F, 0xCE, 0x67,
  0x33, 0x19, 0x9C, 0xFC, 0xFC, 0x7E, 0x37, 0x19, 0x9C, 0xCE, 0x77, 0x38,
  0x1F, 0x9F, 0xCE, 0x46, 0x03, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x01,
  0x99, 0xCF, 0xC7, 0xC0, 0x7F, 0x7F, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x39, 0xCC, 0x77, 0x19, 0xC6, 0x73,
  0x98, 0xEE, 0x3B, 0x8C, 0xE3, 0x31, 0xCC, 0x73, 0xB8, 0xFE, 0x1F, 0x00,
  0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0x73, 0x31, 0xB8, 0xD8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0x00, 0x63, 0x8E, 0xC7, 0x19, 0x8E, 0x73, 0x3C, 0xC6,
  0x7B, 0x8D, 0xB6, 0x1B, 0x6C, 0x36, 0xF8, 0x7B, 0x61, 0xF6, 0xC3, 0xEF,
  0x87, 0x9E, 0x0F, 0x3C, 0x1C, 0x70, 0x00, 0x1C, 0xE3, 0x98, 0x37, 0x06,
  0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xFC, 0x3B, 0x86,
  0x31, 0xC6, 0x00, 0xC7, 0xE6, 0xEE, 0xEC, 0xFC, 0x78, 0x78, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x1F, 0xC7, 0xF0, 0x38, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x7F, 0x3F, 0x80, 0x0F,
  0x0F, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x78, 0xF8, 0xCC, 0xEE, 0x66, 0x66, 0x67, 0x73, 0x33, 0x1E,
  0x3C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x78, 0xF0, 0x06, 0x07, 0x07, 0x83, 0xE3, 0x31, 0x99, 0x8D, 0xC7, 0xFE,
  0xE6, 0x70, 0x1D, 0x9F, 0xCC, 0xEE, 0x77, 0x33, 0x1B, 0x9D, 0xCE, 0xE7,
  0x3F, 0x1D, 0x80, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0xEE, 0xE7,
  0x73, 0xB1, 0xD8, 0xCC, 0xEE, 0x77, 0xF3, 0x70, 0x1F, 0x3E, 0x3A, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xE4, 0x7C, 0x7C, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x1D, 0x8F, 0xE3, 0x39, 0xCE, 0x63, 0x18, 0xCE, 0x33, 0x9C, 0xE7, 0x1F,
  0x87, 0x60, 0x1E, 0x3F, 0x33, 0x73, 0x6F, 0x7E, 0xE0, 0xE0, 0xE0, 0x7E,
  0x3C, 0x03, 0xC1, 0xE0, 0x60, 0x18, 0x0F, 0x87, 0xC0, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x3C, 0x0F,
  0x03, 0x00, 0x0E, 0xC7, 0xF1, 0x9C, 0xE7, 0x39, 0x8C, 0x67, 0x39, 0xCE,
  0x73, 0x8F, 0xC3, 0xB0, 0x1C, 0x07, 0x33, 0x8F, 0xE1, 0xE0, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0xF1, 0xFC, 0xEE, 0xE7, 0x73, 0x39, 0x99, 0xCC, 0xEE,
  0x77, 0x33, 0x18, 0x1C, 0x61, 0x80, 0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x18,
  0xE3, 0x8E, 0x00, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x5C, 0x3C,
  0x1C, 0x00, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x31, 0xCC, 0xC3, 0x71, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0xEE, 0x39, 0x8C, 0x60, 0x1C, 0x61, 0x8E,
  0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x00, 0x37, 0x71, 0xFF,
  0xCE, 0xEE, 0xE6, 0x77, 0x33, 0xB1, 0x99, 0x9C, 0xCC, 0xE6, 0xE6, 0x77,
  0x33, 0xB3, 0x98, 0x37, 0x1F, 0xCE, 0xEE, 0x77, 0x33, 0x99, 0x8C, 0xCE,
  0xE7, 0x73, 0x31, 0x80, 0x1E, 0x1F, 0x8C, 0xCE, 0x76, 0x33, 0x1B, 0x8D,
  0xCE, 0xE6, 0x3F, 0x0F, 0x00, 0x1B, 0x87, 0xF1, 0xDC, 0xE7, 0x39, 0xCC,
  0x73, 0x18, 0xCE, 0x73, 0x9F, 0xC6, 0xE1, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x00, 0x1D, 0x9F, 0xCC, 0xEE, 0x76, 0x33, 0x1B, 0x8D, 0xCE, 0xE7, 0x3F,
  0x1D, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x36, 0x7C, 0xFB, 0x87, 0x0E,
  0x18, 0x30, 0xE1, 0xC3, 0x80, 0x3E, 0x7D, 0xCB, 0x87, 0x87, 0x87, 0x0E,
  0x9D, 0xFB, 0xE0, 0x31, 0x9F, 0xF6, 0x33, 0x9C, 0xC6, 0x31, 0xEF, 0x00,
  0x39, 0x99, 0xCC, 0xEE, 0x67, 0x33, 0x19, 0x9C, 0xCE, 0xE6, 0x7F, 0x1D,
  0x80, 0xE7, 0xE6, 0xE6, 0xEE, 0xEC, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0x60,
  0xE7, 0x3E, 0xF7, 0xEF, 0x6C, 0xA6, 0xDE, 0xED, 0xEC, 0xD6, 0xCF, 0x78,
  0xF7, 0x8E, 0x78, 0xE7, 0x00, 0x39, 0xC6, 0x61, 0xB0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x36, 0x1D, 0x8E, 0x70, 0x1C, 0xE3, 0x98, 0x73, 0x0E,
  0xE1, 0xD8, 0x1F, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x81, 0x70, 0x1C, 0x07, 0x00, 0x1F, 0x3F, 0x07, 0x0E, 0x0C, 0x1C, 0x38,
  0x30, 0x70, 0x7E, 0xFC, 0x07, 0x0F, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x78,
  0xE0, 0x70, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x0F, 0x06, 0x1E, 0x38, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0x61, 0xFF,
  0xBF, 0x84,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 10, 14, 10, 0, -14 },
  { 35, 9, 16, 8, 0, -15 },
  { 53, 13, 14, 14, 1, -14 },
  { 76, 10, 14, 10, 0, -14 },
  { 94, 3, 5, 5, 2, -14 },
  { 96, 7, 17, 5, 0, -14 },
  { 111, 7, 18, 5, -2, -15 },
  { 127, 7, 8, 8, 2, -15 },
  { 134, 8, 10, 9, 1, -12 },
  { 144, 4, 6, 5, -1, -3 },
  { 147, 5, 3, 6, 0, -7 },
  { 149, 3, 3, 5, 0, -3 },
  { 151, 10, 14, 7, -1, -14 },
  { 169, 9, 14, 8, 0, -14 },
  { 185, 6, 14, 9, 2, -14 },
  { 196, 10, 14, 8, -1, -14 },
  { 214, 9, 14, 8, 0, -14 },
  { 230, 9, 14, 9, 0, -14 },
  { 246, 9, 14, 8, 0, -14 },
  { 262, 9, 15, 8, 0, -15 },
  { 279, 10, 14, 8, 0, -14 },
  { 297, 9, 14, 8, 0, -14 },
  { 313, 9, 15, 8, 0, -15 },
  { 330, 5, 11, 5, 0, -11 },
  { 337, 6, 14, 5, -1, -11 },
  { 348, 8, 10, 9, 1, -12 },
  { 358, 8, 6, 9, 1, -10 },
  { 364, 8, 10, 9, 1, -12 },
  { 374, 8, 14, 7, 0, -14 },
  { 388, 13, 16, 13, 0, -14 },
  { 414, 9, 14, 9, -1, -14 },
  { 430, 10, 14, 10, 0, -14 },
  { 448, 9, 14, 9, 1, -14 },
  { 464, 10, 14, 10, 0, -14 },
  { 482, 9, 14, 8, 0, -14 },
  { 498, 9, 14, 8, 0, -14 },
  { 514, 10, 14, 11, 1, -14 },
  { 532, 11, 14, 11, 0, -14 },
  { 552, 9, 14, 6, -1, -14 },
  { 568, 9, 18, 5, -3, -14 },
  { 589, 11, 14, 9, 0, -14 },
  { 609, 6, 14, 8, 0, -14 },
  { 620, 15, 14, 14, 0, -14 },
  { 647, 12, 14, 11, 0, -14 },
  { 668, 10, 15, 11, 1, -15 },
  { 687, 10, 14, 9, 0, -14 },
  { 705, 10, 18, 11, 1, -15 },
  { 728, 9, 14, 9, 0, -14 },
  { 744, 9, 14, 8, 0, -14 },
  { 760, 8, 14, 8, 1, -14 },
  { 774, 10, 14, 10, 1, -14 },
  { 792, 9, 14, 9, 2, -14 },
  { 808, 15, 14, 14, 1, -14 },
  { 835, 11, 14, 9, -1, -14 },
  { 855, 8, 14, 9, 2, -14 },
  { 869, 10, 14, 8, -1, -14 },
  { 887, 8, 17, 6, -1, -14 },
  { 904, 4, 14, 8, 2, -14 },
  { 911, 7, 17, 6, -1, -14 },
  { 926, 9, 8, 9, 0, -14 },
  { 935, 7, 1, 6, -2, 2 },
  { 936, 4, 3, 6, 3, -15 },
  { 938, 9, 11, 9, 0, -11 },
  { 951, 9, 15, 9, 0, -15 },
  { 968, 8, 11, 7, 0, -11 },
  { 979, 10, 15, 9, 0, -15 },
  { 998, 8, 11, 8, 0, -11 },
  { 1009, 10, 20, 6, -2, -15 },
  { 1034, 10, 16, 9, -1, -11 },
  { 1054, 9, 15, 9, 0, -15 },
  { 1071, 6, 15, 5, 0, -15 },
  { 1083, 9, 20, 5, -3, -15 },
  { 1106, 10, 15, 9, 0, -15 },
  { 1125, 6, 15, 5, 0, -15 },
  { 1137, 13, 11, 13, 0, -11 },
  { 1155, 9, 11, 9, 0, -11 },
  { 1168, 9, 11, 9, 0, -11 },
  { 1181, 10, 16, 9, -1, -11 },
  { 1201, 9, 16, 9, 0, -11 },
  { 1219, 7, 11, 6, 0, -11 },
  { 1229, 7, 11, 7, 0, -11 },
  { 1239, 5, 13, 6, 1, -13 },
  { 1248, 9, 11, 9, 0, -11 },
  { 1261, 8, 11, 8, 1, -11 },
  { 1272, 12, 11, 12, 1, -11 },
  { 1289, 10, 11, 8, -1, -11 },
  { 1303, 11, 16, 8, -2, -11 },
  { 1325, 8, 11, 7, -1, -11 },
  { 1336, 8, 17, 7, 0, -14 },
  { 1353, 3, 20, 7, 2, -15 },
  { 1361, 8, 17, 7, -1, -14 },
  { 1378, 8, 4, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC20PT7B_H_
