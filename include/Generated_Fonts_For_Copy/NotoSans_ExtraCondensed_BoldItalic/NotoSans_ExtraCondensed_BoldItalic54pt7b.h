#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x3F, 0x8F, 0xE7,
  0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F,
  0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C,
  0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFB, 0x7C, 0x07, 0xF3, 0x18, 0x07, 0xE3, 0x08, 0x07, 0xE6,
  0x00, 0x07, 0xE6, 0x00, 0x07, 0xF6, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x33, 0xF8, 0x40, 0x33,
  0xF8, 0x60, 0x33, 0xF8, 0x78, 0x37, 0xF0, 0x7E, 0x6F, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x07, 0xC0,
  0x1F, 0xFE, 0x03, 0xE0, 0x0F, 0xCF, 0x80, 0xF8, 0x03, 0xE3, 0xE0, 0x7C,
  0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xC3, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0xFC, 0x00, 0xF8, 0x3E,
  0x3E, 0x00, 0x3E, 0x1F, 0x1F, 0x80, 0x0F, 0x87, 0xC7, 0xC0, 0x03, 0xE1,
  0xF3, 0xE0, 0xE0, 0xF8, 0xF8, 0xF8, 0xFF, 0x3E, 0x3E, 0x7C, 0x7F, 0xCF,
  0x9F, 0x9F, 0x3F, 0xFB, 0xFF, 0xCF, 0x8F, 0xFE, 0xFF, 0xE3, 0xE7, 0xCF,
  0x9F, 0xF9, 0xF1, 0xF1, 0xF7, 0xFC, 0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x00, 0x1F, 0x9F, 0x0F, 0x80, 0x07, 0xC7, 0xC3, 0xE0, 0x03, 0xF1,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x1F,
  0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x7C, 0x01,
  0xF0, 0x3E, 0x3E, 0x00, 0x7C, 0x0F, 0x8F, 0x80, 0x3E, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFC,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x7F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF,
  0x8F, 0xC3, 0xF9, 0xFD, 0xFC, 0x3F, 0x1F, 0xDF, 0x87, 0xF1, 0xFF, 0xF8,
  0x7E, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x7F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xCF, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x30, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC7, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x30, 0xFC, 0x03, 0xCF, 0xC0, 0x7E, 0xF8, 0x77, 0xFF,
  0xBF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xBF, 0x03,
  0xF1, 0xF8, 0x1F, 0x1F, 0xC0, 0xE1, 0xF8, 0x04, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x00, 0x1E, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0,
  0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F,
  0xE7, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF,
  0xCF, 0xF7, 0xE1, 0xF9, 0xF8, 0x7C, 0xFE, 0x0E, 0x3F, 0x81, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xC7, 0xF8, 0x03, 0xC0, 0xFF, 0x00, 0xE0, 0x3F, 0xC0,
  0x10, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x08, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xE3, 0xFE, 0x01,
  0x80, 0xFF, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE1, 0x00, 0x0F, 0xE0, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xDF, 0xC0, 0x03, 0xEF, 0xC0, 0x01,
  0xE7, 0xE0, 0x01, 0xF7, 0xF0, 0x01, 0xF3, 0xF8, 0x00, 0xF1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x78, 0x7F, 0x00, 0x7C, 0x3F, 0x80,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xE0, 0x3E, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x04,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x80, 0x1F, 0xE0, 0xE0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x02, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xCF, 0xC0, 0x1F, 0x9F, 0xE0, 0x3F, 0xBF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F,
  0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFE, 0x07, 0xF1, 0xFE, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x3F, 0xC7, 0xF0, 0x7F, 0x87,
  0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F,
  0x83, 0xFC, 0x7F, 0x0F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0x7F, 0x07, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0x83, 0xF8, 0x60,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x7E, 0x07, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0x83, 0xFF, 0xC7,
  0xC3, 0xE1, 0xFF, 0xF1, 0xF1, 0xF0, 0xFC, 0x7C, 0x7C, 0x7C, 0x3E, 0x1E,
  0x1F, 0x1E, 0x1F, 0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xE1, 0xE3, 0xE3, 0xE0,
  0xF8, 0x78, 0xF0, 0xF8, 0x3C, 0x1E, 0x7C, 0x3C, 0x1F, 0x0F, 0x9F, 0x1F,
  0x07, 0xC3, 0xE7, 0xC7, 0xC1, 0xF0, 0xF1, 0xE1, 0xF0, 0xF8, 0x3C, 0x78,
  0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x87, 0x8F, 0x87, 0xC7, 0xE3, 0xE3,
  0xE1, 0xF1, 0xF8, 0xF0, 0xF8, 0x7C, 0xFE, 0x7C, 0x3E, 0x1F, 0xFF, 0xFE,
  0x0F, 0x87, 0xFD, 0xFF, 0x03, 0xE0, 0xFE, 0x3F, 0x80, 0xF8, 0x0E, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x00, 0x01, 0xF8,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC7, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F,
  0xC3, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83,
  0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFC, 0x78, 0x0F, 0xF8, 0x08, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x7F, 0x81, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xE1,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0x87, 0xC0, 0x7F, 0xE0, 0x18, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0x03, 0xFF, 0x87, 0xF0,
  0x3F, 0xF8, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xF0, 0xFF, 0x07, 0xFF,
  0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xC1, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x02, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x5F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80,
  0xFD, 0xF0, 0x1F, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0xFC, 0x03, 0xF7, 0xC0,
  0xFD, 0xF8, 0x07, 0xEF, 0x81, 0xFF, 0xF0, 0x1F, 0xDF, 0x87, 0xEF, 0xE0,
  0x3F, 0xBF, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x7E, 0xFE, 0x01, 0xF9, 0xF9, 0xF9, 0xFC, 0x07, 0xF3, 0xF3, 0xF3, 0xF8,
  0x0F, 0xE7, 0xE7, 0xC7, 0xE0, 0x1F, 0x8F, 0xDF, 0x8F, 0xC0, 0x3F, 0x1F,
  0xBE, 0x3F, 0x80, 0x7E, 0x3F, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0xF8, 0xFE,
  0x03, 0xF8, 0xFF, 0xE1, 0xF8, 0x07, 0xE1, 0xFF, 0xC3, 0xF0, 0x0F, 0xC3,
  0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xF0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0xFE, 0x01,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0x81, 0xFC, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC1, 0xF8, 0x07,
  0xEF, 0xC1, 0xF8, 0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xEF, 0xC3, 0xF8, 0x07,
  0xEF, 0xC3, 0xF8, 0x0F, 0xE7, 0xE3, 0xF0, 0x0F, 0xE7, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE3, 0xF0, 0x0F, 0xC7, 0xE7, 0xF0, 0x0F, 0xC7, 0xE7, 0xF0, 0x1F,
  0xC7, 0xE7, 0xE0, 0x1F, 0xC3, 0xF7, 0xE0, 0x1F, 0x83, 0xF7, 0xE0, 0x1F,
  0x83, 0xF7, 0xE0, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xC0, 0x3F,
  0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x7F,
  0x01, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0x7E,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x3F,
  0x83, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07,
  0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x87,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0x8F, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x03,
  0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x18, 0x03, 0xFC, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x04, 0x00, 0x7F, 0x01, 0xC0, 0x3F, 0xC0, 0x7C, 0x3F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3,
  0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0x01, 0xFC, 0x7E, 0x03, 0xFC,
  0x07, 0xE1, 0xF8, 0x1F, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0xC0, 0xFE, 0x1F,
  0x83, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0,
  0x7E, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xDF, 0x0F, 0xE0, 0xFE,
  0x3F, 0xFC, 0x3F, 0x03, 0xF8, 0xFF, 0xF1, 0xFC, 0x0F, 0xE3, 0xEF, 0xC7,
  0xE0, 0x3F, 0x9F, 0xBF, 0x3F, 0x80, 0xFE, 0x7E, 0xFC, 0xFE, 0x03, 0xFB,
  0xF3, 0xF3, 0xF0, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0x3E, 0x3F, 0x7F,
  0x00, 0xFD, 0xF8, 0xFF, 0xF8, 0x03, 0xF7, 0xE3, 0xFF, 0xE0, 0x0F, 0xDF,
  0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E,
  0x03, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x7F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xEF, 0xE0, 0x3F, 0xCF, 0xC0,
  0x1F, 0x8F, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF9, 0xF0, 0x03, 0xF3, 0xFC, 0x07, 0xF7, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8,
  0x7F, 0x87, 0xF0, 0x7F, 0xCF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFD, 0xFF, 0xC0, 0xFD, 0xFF, 0x80, 0xF8, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0x0F, 0xF0, 0x60,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x1F,
  0xF7, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x9F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFD, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x1F, 0xC7, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF9, 0xFC, 0x3F, 0x87, 0xE3, 0xF8,
  0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE7,
  0xF1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x10, 0x7F, 0x03, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x04, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF3, 0xF0,
  0x0F, 0xFC, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFB, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x02, 0x00,
  0x7F, 0x80, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF1,
  0xF0, 0x03, 0xF3, 0xFC, 0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x23, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x01, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xF7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0xFF, 0x8F, 0xF8, 0x1F, 0xBF, 0xF3, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x3F, 0xE3, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x87, 0xE0, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xE0,
  0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x1F, 0x87,
  0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x1F,
  0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xC7, 0xF8, 0x0F, 0x9F, 0xF0, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0xFF, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x8F, 0xF0, 0x03, 0xF3, 0xFF,
  0x00, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFD, 0xFF, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE0, 0x40, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x3F, 0x01, 0xFF,
  0xBF, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE3,
  0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xF8, 0x7F, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xC0, 0x1F, 0x9F, 0xC0, 0x04, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x3E, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE4, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xE0, 0xC1, 0xFC, 0x04,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x80,
  0x7F, 0x8C, 0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE1,
  0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x20,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x04, 0x00,
  0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0,
  0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xEF, 0xC0,
  0x3F, 0x8F, 0xC0, 0x04, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7E, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x1F, 0xBF, 0x83, 0xFC, 0x1F, 0xDF,
  0xC3, 0xFE, 0x0F, 0xCF, 0xE1, 0xFF, 0x07, 0xE7, 0xF0, 0xFF, 0x87, 0xF3,
  0xF8, 0xFF, 0xC3, 0xF1, 0xF8, 0x7F, 0xE3, 0xF8, 0xFC, 0x7F, 0xF1, 0xF8,
  0x7E, 0x3E, 0xF8, 0xFC, 0x3F, 0x1F, 0x7C, 0xFE, 0x1F, 0x9F, 0xBE, 0x7E,
  0x0F, 0xCF, 0xBF, 0x3F, 0x07, 0xE7, 0xDF, 0xBF, 0x03, 0xF7, 0xCF, 0xDF,
  0x81, 0xFB, 0xE7, 0xFF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0x7F, 0xF1, 0xF7,
  0xE0, 0x3F, 0xF8, 0xFB, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F,
  0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x04, 0xFF, 0x00, 0x17, 0xFF, 0x80, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 16, 40, 14, 0, -39 },
  { 81, 19, 14, 21, 5, -39 },
  { 115, 27, 39, 26, 0, -39 },
  { 247, 24, 44, 23, 0, -41 },
  { 379, 34, 39, 38, 3, -39 },
  { 545, 28, 40, 28, 0, -39 },
  { 685, 9, 14, 13, 5, -39 },
  { 701, 18, 48, 15, 1, -39 },
  { 809, 18, 48, 15, -4, -39 },
  { 917, 20, 22, 22, 4, -41 },
  { 972, 22, 26, 25, 2, -32 },
  { 1044, 12, 14, 13, -3, -7 },
  { 1065, 14, 7, 16, 1, -18 },
  { 1078, 8, 9, 13, 0, -8 },
  { 1087, 28, 39, 20, -3, -39 },
  { 1224, 22, 40, 23, 1, -39 },
  { 1334, 18, 39, 23, 5, -39 },
  { 1422, 26, 39, 23, -2, -39 },
  { 1549, 25, 40, 23, -1, -39 },
  { 1674, 25, 39, 23, -1, -39 },
  { 1796, 24, 40, 23, 0, -39 },
  { 1916, 24, 40, 23, 1, -39 },
  { 2036, 25, 39, 23, 1, -39 },
  { 2158, 24, 40, 23, 0, -39 },
  { 2278, 23, 40, 23, 0, -39 },
  { 2393, 13, 31, 13, 0, -30 },
  { 2444, 16, 37, 13, -3, -30 },
  { 2518, 22, 26, 25, 2, -32 },
  { 2590, 22, 16, 25, 2, -27 },
  { 2634, 22, 26, 25, 2, -32 },
  { 2706, 19, 40, 18, 1, -39 },
  { 2801, 34, 43, 35, 1, -39 },
  { 2984, 25, 39, 25, -3, -39 },
  { 3106, 26, 39, 26, 0, -39 },
  { 3233, 25, 40, 24, 2, -39 },
  { 3358, 27, 39, 28, 0, -39 },
  { 3490, 24, 39, 21, 0, -39 },
  { 3607, 24, 39, 21, 0, -39 },
  { 3724, 28, 40, 28, 2, -39 },
  { 3864, 31, 39, 29, 0, -39 },
  { 4016, 23, 39, 17, -2, -39 },
  { 4129, 23, 50, 13, -8, -39 },
  { 4273, 30, 39, 25, 0, -39 },
  { 4420, 18, 39, 21, 0, -39 },
  { 4508, 39, 39, 38, 0, -39 },
  { 4699, 32, 39, 30, 0, -39 },
  { 4855, 27, 40, 29, 2, -39 },
  { 4990, 27, 39, 25, 0, -39 },
  { 5122, 27, 48, 29, 2, -39 },
  { 5284, 26, 39, 25, 0, -39 },
  { 5411, 26, 40, 22, -1, -39 },
  { 5541, 22, 39, 21, 4, -39 },
  { 5649, 28, 40, 28, 2, -39 },
  { 5789, 25, 39, 25, 5, -39 },
  { 5911, 38, 39, 38, 4, -39 },
  { 6097, 31, 39, 24, -3, -39 },
  { 6249, 23, 39, 23, 5, -39 },
  { 6362, 27, 39, 21, -2, -39 },
  { 6494, 21, 48, 15, -2, -39 },
  { 6620, 12, 39, 20, 5, -39 },
  { 6679, 22, 48, 15, -4, -39 },
  { 6811, 23, 24, 23, 0, -39 },
  { 6880, 18, 3, 18, -5, 5 },
  { 6887, 10, 8, 16, 8, -41 },
  { 6897, 24, 31, 25, 1, -30 },
  { 6990, 24, 42, 25, 0, -41 },
  { 7116, 20, 31, 20, 1, -30 },
  { 7194, 27, 42, 25, 1, -41 },
  { 7336, 21, 31, 23, 1, -30 },
  { 7418, 27, 54, 15, -6, -41 },
  { 7601, 26, 43, 25, -1, -30 },
  { 7741, 24, 41, 25, 0, -41 },
  { 7864, 15, 41, 12, 0, -41 },
  { 7941, 22, 54, 12, -7, -41 },
  { 8090, 26, 41, 23, 0, -41 },
  { 8224, 15, 41, 12, 0, -41 },
  { 8301, 35, 30, 36, 0, -30 },
  { 8433, 23, 30, 25, 0, -30 },
  { 8520, 22, 31, 24, 1, -30 },
  { 8606, 27, 43, 25, -3, -30 },
  { 8752, 24, 43, 25, 1, -30 },
  { 8881, 20, 30, 17, 0, -30 },
  { 8956, 20, 31, 19, 0, -30 },
  { 9034, 16, 37, 16, 2, -36 },
  { 9108, 24, 30, 24, 1, -29 },
  { 9198, 21, 29, 22, 3, -29 },
  { 9275, 33, 29, 33, 3, -29 },
  { 9395, 27, 29, 22, -3, -29 },
  { 9493, 29, 42, 22, -4, -29 },
  { 9646, 22, 29, 18, -2, -29 },
  { 9726, 21, 48, 18, 1, -39 },
  { 9852, 6, 53, 20, 7, -41 },
  { 9892, 21, 48, 18, -3, -39 },
  { 10018, 22, 9, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC54PT7B_H_
