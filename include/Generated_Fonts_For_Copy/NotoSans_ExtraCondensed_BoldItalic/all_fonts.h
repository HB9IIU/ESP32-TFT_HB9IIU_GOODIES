#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_BoldItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_BoldItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_BoldItalic72pt7b.h"
