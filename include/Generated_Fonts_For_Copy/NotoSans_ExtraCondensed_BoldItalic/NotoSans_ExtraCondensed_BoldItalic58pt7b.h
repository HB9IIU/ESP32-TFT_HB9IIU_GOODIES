#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x8F, 0xF7, 0xF8, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F,
  0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xF6, 0x7C, 0x03, 0xF9, 0x86, 0x01, 0xFC, 0xE0, 0x00,
  0x7F, 0x38, 0x00, 0x1F, 0xCC, 0x00, 0x07, 0xFB, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1D, 0xFE,
  0x00, 0x06, 0x7F, 0x80, 0x01, 0x9F, 0xE1, 0x00, 0x67, 0xF0, 0x60, 0x19,
  0xFC, 0x1C, 0x0E, 0x7F, 0x07, 0xC3, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0xFC, 0x01, 0xF9, 0xF0,
  0x0F, 0x80, 0x1F, 0x1F, 0x81, 0xF8, 0x03, 0xF1, 0xF8, 0x1F, 0x00, 0x3E,
  0x1F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x07, 0xE0,
  0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0xF8, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x0F, 0x83, 0xE3, 0xF0, 0x00, 0xF8,
  0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xE7, 0xE1, 0xFC, 0xF8, 0x7C, 0x7C, 0x3F,
  0xEF, 0x8F, 0xCF, 0xC7, 0xFE, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F,
  0x9F, 0xFF, 0x7F, 0xF1, 0xF1, 0xF1, 0xF7, 0xFE, 0x3F, 0x3E, 0x1F, 0x3F,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7E, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xC1,
  0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x1F, 0x8F, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0x87,
  0xC0, 0x0F, 0x80, 0xF8, 0xFC, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0x3F, 0x00,
  0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xC0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x0F, 0xE0,
  0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xE7, 0xF0, 0xFF,
  0x3F, 0x9F, 0xC3, 0xF8, 0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xF8, 0x7F, 0x07,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x80, 0xFF,
  0xE0, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xF0, 0x3F, 0xFE, 0x3F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE7, 0xF9, 0xFE,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x10, 0x7E, 0x01, 0xE3, 0xF0, 0x0F, 0x9F, 0x81, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xEF, 0xE0, 0xFE, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0x0F, 0xE0, 0x30, 0x3C,
  0x00, 0x81, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x00, 0x0E, 0x1F, 0x9F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF,
  0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF3, 0xF9, 0xFC, 0x7C, 0xFE, 0x0E,
  0x3F, 0x83, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xE0, 0xFF, 0x00, 0xF8, 0x1F, 0xE0, 0x0E, 0x03,
  0xFC, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0x81, 0xFF, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x7F, 0x83, 0x00, 0x1F, 0xF0, 0x7C,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0xFE, 0x00, 0x0F, 0x9F, 0xC0, 0x01, 0xF7, 0xF8, 0x00, 0x7C, 0xFE,
  0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xE3, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xC3, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0x81, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xE3, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x80, 0x0F, 0xF8,
  0x30, 0x07, 0xFC, 0x0F, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0x00, 0x1F, 0xCF,
  0xF0, 0x07, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xC1, 0xFF, 0x07, 0xF0,
  0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x01,
  0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xE0, 0xFF, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xF3,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x3F, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFE, 0x03,
  0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x10, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x3F, 0xE0, 0xC0, 0x7F, 0x04, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xFC, 0x1F, 0x07, 0xE0, 0x7F,
  0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x1F, 0x0F, 0x83, 0xFF, 0xF0, 0xF0, 0xF8,
  0x3F, 0x3F, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F,
  0x1F, 0x0F, 0x83, 0xE1, 0xF3, 0xE1, 0xF8, 0x7E, 0x1F, 0x3E, 0x1F, 0x07,
  0xC1, 0xF3, 0xE1, 0xF0, 0x7C, 0x1E, 0x7C, 0x3E, 0x07, 0xC1, 0xE7, 0xC3,
  0xE0, 0xFC, 0x3E, 0x7C, 0x3E, 0x0F, 0x83, 0xE7, 0xC3, 0xE0, 0xF8, 0x3C,
  0x7C, 0x3E, 0x0F, 0x87, 0xC7, 0x87, 0xE1, 0xF8, 0x7C, 0xF8, 0x7E, 0x1F,
  0x0F, 0x8F, 0x87, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x7F, 0x9F, 0x0F, 0x83,
  0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0x81, 0xFE, 0x7F, 0xC0,
  0xF8, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0x7E, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF1,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x81, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF8, 0x18, 0x03, 0xFE, 0x01, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0x80,
  0x3F, 0xF1, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0x01, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0xC3, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3C, 0x03, 0xFE, 0x00, 0x20, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0xF8, 0x7F, 0x81, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0x87,
  0xF8, 0x3F, 0xFE, 0x3F, 0xE0, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xDF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xF7, 0xF0,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x1F, 0xDF, 0x81, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0xFE, 0xFE,
  0x01, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0, 0x3F,
  0x9F, 0x87, 0xE7, 0xF0, 0x0F, 0xE7, 0xE1, 0xF9, 0xFC, 0x03, 0xF9, 0xF8,
  0xFE, 0xFF, 0x00, 0xFE, 0x7E, 0x3F, 0x3F, 0x80, 0x3F, 0x1F, 0x9F, 0xCF,
  0xE0, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0x07, 0xF1, 0xF9, 0xF8, 0xFE, 0x01,
  0xFC, 0x7E, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0x1F, 0x87,
  0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0xF0,
  0x7F, 0x00, 0xFE, 0x1F, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xE0, 0x1F, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8,
  0x1F, 0xC0, 0x3F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x81, 0xFC, 0x03, 0xF7,
  0xE0, 0x7F, 0x00, 0xFD, 0xF8, 0x1F, 0x80, 0x7F, 0x7E, 0x0F, 0xE0, 0x1F,
  0xDF, 0xC3, 0xF8, 0x07, 0xF7, 0xF0, 0xFE, 0x01, 0xFD, 0xFC, 0x3F, 0x80,
  0x7E, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x9F, 0xC0, 0x3F, 0x07, 0xE7,
  0xE0, 0x1F, 0xC1, 0xFB, 0xF8, 0x07, 0xF0, 0x7E, 0xFE, 0x01, 0xFC, 0x1F,
  0xBF, 0x80, 0x7F, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xF0, 0x0F, 0xE0,
  0x3F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0x80, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x1F, 0xF0,
  0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xF9, 0xFE, 0x00,
  0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x9F, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE7, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F, 0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0xF8, 0x03, 0xFE, 0x01, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x40, 0x03, 0xFC, 0x06, 0x00, 0x7F, 0xC0, 0x78, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE,
  0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0x8F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE1, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0x01, 0xFC,
  0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFF,
  0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xEF, 0xC7, 0xF8, 0x07,
  0xF1, 0xFB, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x3F, 0x3F, 0x80, 0x1F, 0x8F, 0xCF, 0xCF, 0xE0, 0x0F, 0xE7, 0xE3, 0xF7,
  0xF8, 0x03, 0xF9, 0xF8, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x3F, 0x7F, 0x00,
  0x3F, 0xBF, 0x0F, 0xBF, 0xC0, 0x0F, 0xEF, 0xC3, 0xEF, 0xE0, 0x03, 0xFF,
  0xE0, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0,
  0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x3F, 0xE7, 0xF0, 0x1F, 0xFD, 0xFC, 0x0F, 0xFF, 0x7F,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFD, 0xFC,
  0x03, 0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xBF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0x7F, 0xF8, 0x0F, 0xCF, 0xFC, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x87, 0x03, 0xFC, 0x08,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0x03, 0xFE,
  0x1C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0xCF, 0xE0,
  0x07, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x87, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xDF, 0x80, 0x0F, 0xFC, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0xC3, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x81, 0xFE, 0x0F, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xE1, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFF,
  0x9F, 0xC0, 0x0F, 0xFE, 0xFE, 0x00, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xC3, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE1, 0xFF,
  0x00, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x41, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x40, 0x03, 0xFC, 0x03,
  0x80, 0x3F, 0xE0, 0x1F, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xDF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F,
  0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x0F, 0xCF, 0xF8,
  0x7F, 0xC0, 0x3F, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFE,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFF, 0x00, 0xFC, 0xFF, 0xC0, 0x7C, 0xFF,
  0xF0, 0x7E, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF9, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF9,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF1, 0xFF, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFD, 0xFF, 0xE0, 0x0F, 0xEF, 0xFE, 0x00, 0x7F, 0x3F, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0xC0, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xE3,
  0xF0, 0x1F, 0xFD, 0xFC, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0x1F, 0xF8, 0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFD, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0xC0, 0x02, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x80, 0xFD, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x07, 0x07,
  0xF8, 0x08, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x80, 0x3F,
  0xC3, 0x81, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x10, 0x00, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xF0, 0x1F, 0xFD, 0xF8, 0x03,
  0xFE, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF7, 0xE0,
  0x3F, 0xC0, 0xFE, 0x7E, 0x07, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0xC1, 0xFC,
  0x7E, 0x07, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0xC1, 0xFC, 0x7E, 0x0F, 0xFC,
  0x3F, 0x87, 0xE1, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x07, 0xE1,
  0xFF, 0xC7, 0xF0, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xE3, 0xEF, 0xCF, 0xE0,
  0xFE, 0x7E, 0xF8, 0xFE, 0x0F, 0xE7, 0xEF, 0x8F, 0xC0, 0xFE, 0x7C, 0xF9,
  0xFC, 0x0F, 0xEF, 0xCF, 0x9F, 0xC0, 0xFE, 0xFC, 0xF9, 0xF8, 0x0F, 0xEF,
  0x8F, 0xBF, 0x80, 0xFF, 0xF9, 0xFB, 0xF0, 0x0F, 0xFF, 0x1F, 0xBF, 0x00,
  0xFD, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x13, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 17, 42, 15, 0, -41 },
  { 91, 20, 15, 23, 6, -41 },
  { 129, 29, 41, 28, 0, -41 },
  { 278, 26, 47, 25, 0, -44 },
  { 431, 36, 43, 41, 3, -42 },
  { 625, 30, 43, 30, 0, -42 },
  { 787, 10, 15, 14, 6, -41 },
  { 806, 19, 51, 16, 1, -42 },
  { 928, 20, 51, 16, -5, -42 },
  { 1056, 21, 25, 24, 5, -45 },
  { 1122, 24, 27, 27, 2, -34 },
  { 1203, 13, 16, 14, -3, -8 },
  { 1229, 15, 7, 17, 1, -19 },
  { 1243, 9, 10, 14, 0, -9 },
  { 1255, 30, 42, 22, -3, -42 },
  { 1413, 24, 43, 25, 1, -42 },
  { 1542, 18, 41, 25, 6, -41 },
  { 1635, 27, 42, 25, -2, -42 },
  { 1777, 27, 43, 25, -1, -42 },
  { 1923, 27, 42, 25, -1, -42 },
  { 2065, 26, 42, 25, 0, -41 },
  { 2202, 26, 43, 25, 1, -42 },
  { 2342, 27, 41, 25, 1, -41 },
  { 2481, 26, 43, 25, 0, -42 },
  { 2621, 25, 43, 25, 0, -42 },
  { 2756, 14, 33, 14, 0, -32 },
  { 2814, 17, 40, 14, -3, -32 },
  { 2899, 24, 28, 27, 2, -35 },
  { 2983, 24, 17, 27, 2, -29 },
  { 3034, 24, 28, 27, 2, -35 },
  { 3118, 21, 43, 19, 1, -42 },
  { 3231, 36, 47, 38, 1, -42 },
  { 3443, 28, 42, 27, -4, -42 },
  { 3590, 28, 41, 28, 0, -41 },
  { 3734, 27, 43, 25, 2, -42 },
  { 3880, 29, 41, 30, 0, -41 },
  { 4029, 26, 41, 23, 0, -41 },
  { 4163, 26, 41, 22, 0, -41 },
  { 4297, 30, 43, 31, 2, -42 },
  { 4459, 33, 41, 31, 0, -41 },
  { 4629, 26, 41, 18, -3, -41 },
  { 4763, 25, 53, 14, -9, -41 },
  { 4929, 32, 41, 27, 0, -41 },
  { 5093, 19, 41, 22, 0, -41 },
  { 5191, 42, 41, 40, 0, -41 },
  { 5407, 34, 41, 33, 0, -41 },
  { 5582, 29, 43, 32, 2, -42 },
  { 5738, 29, 41, 27, 0, -41 },
  { 5887, 29, 52, 32, 2, -42 },
  { 6076, 27, 41, 27, 0, -41 },
  { 6215, 28, 43, 24, -1, -42 },
  { 6366, 23, 41, 23, 4, -41 },
  { 6484, 30, 42, 30, 2, -41 },
  { 6642, 27, 41, 27, 5, -41 },
  { 6781, 42, 41, 41, 4, -41 },
  { 6997, 33, 41, 25, -3, -41 },
  { 7167, 25, 41, 25, 5, -41 },
  { 7296, 28, 41, 23, -2, -41 },
  { 7440, 23, 51, 16, -2, -42 },
  { 7587, 12, 42, 22, 6, -42 },
  { 7650, 23, 51, 16, -4, -42 },
  { 7797, 25, 24, 25, 0, -41 },
  { 7872, 20, 4, 19, -6, 5 },
  { 7882, 11, 9, 17, 8, -44 },
  { 7895, 26, 33, 27, 1, -32 },
  { 8003, 26, 45, 27, 0, -44 },
  { 8150, 22, 33, 21, 1, -32 },
  { 8241, 29, 45, 27, 1, -44 },
  { 8405, 23, 33, 24, 1, -32 },
  { 8500, 30, 58, 16, -7, -44 },
  { 8718, 29, 46, 27, -2, -32 },
  { 8885, 25, 44, 27, 0, -44 },
  { 9023, 16, 44, 13, 0, -44 },
  { 9111, 23, 58, 13, -7, -44 },
  { 9278, 28, 44, 25, 0, -44 },
  { 9432, 16, 44, 13, 0, -44 },
  { 9520, 38, 32, 39, 0, -32 },
  { 9672, 25, 32, 27, 0, -32 },
  { 9772, 24, 33, 26, 1, -32 },
  { 9871, 29, 46, 27, -3, -32 },
  { 10038, 26, 46, 27, 1, -32 },
  { 10188, 22, 32, 19, 0, -32 },
  { 10276, 22, 33, 21, 0, -32 },
  { 10367, 17, 39, 17, 2, -38 },
  { 10450, 26, 33, 26, 1, -32 },
  { 10558, 23, 32, 23, 3, -32 },
  { 10650, 36, 32, 36, 3, -32 },
  { 10794, 29, 32, 23, -3, -32 },
  { 10910, 30, 46, 23, -4, -32 },
  { 11083, 24, 32, 20, -2, -32 },
  { 11179, 23, 50, 20, 1, -41 },
  { 11323, 7, 58, 22, 7, -45 },
  { 11374, 22, 50, 20, -3, -41 },
  { 11512, 24, 9, 27, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC58PT7B_H_
