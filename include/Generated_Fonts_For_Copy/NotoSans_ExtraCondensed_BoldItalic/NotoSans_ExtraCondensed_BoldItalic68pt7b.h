#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC,
  0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF6, 0xFE, 0x00,
  0x7F, 0x9C, 0x38, 0x01, 0xFF, 0x38, 0x30, 0x03, 0xFC, 0x70, 0x00, 0x07,
  0xF8, 0xC0, 0x00, 0x0F, 0xF1, 0x80, 0x00, 0x1F, 0xF7, 0x00, 0x00, 0x3F,
  0xEE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0E, 0xFF, 0x80, 0x00, 0x1D, 0xFF, 0x80, 0x00, 0x39, 0xFF,
  0x00, 0x00, 0x63, 0xFC, 0x04, 0x00, 0xC7, 0xF8, 0x08, 0x03, 0x8F, 0xF0,
  0x3C, 0x07, 0x3F, 0xE0, 0x7E, 0x0E, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x03,
  0xF0, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x3F, 0x81, 0xE0, 0xFC, 0x3F, 0x8F, 0xC1, 0xFE, 0x3F, 0x0F, 0xC7, 0xF1,
  0xFF, 0xCF, 0xC7, 0xF1, 0xF8, 0xFF, 0xFB, 0xF1, 0xF8, 0xFE, 0x3F, 0xFE,
  0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xCF, 0xE7, 0xFF, 0xFF,
  0x8F, 0xE3, 0xF0, 0xFD, 0xFF, 0xE3, 0xF1, 0xFC, 0x3F, 0x3F, 0xE1, 0xFC,
  0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE7, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xE3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x07, 0xF0, 0x01, 0xC1, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0x83, 0x9F, 0xFF, 0xE7, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x3F, 0xF7, 0xF0, 0x0F, 0xF9,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x0F, 0xF8, 0x07, 0x83, 0xFC, 0x00,
  0xC0, 0x7C, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0x8F, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F,
  0xF3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07,
  0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x87, 0xFC, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFD, 0xFE, 0x7F, 0xDF, 0xF3,
  0xFC, 0xFF, 0x0F, 0xC7, 0xF8, 0x3C, 0x3F, 0xC1, 0xC3, 0xFE, 0x04, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x1F, 0x80,
  0xFF, 0xC0, 0x07, 0x80, 0x7F, 0xE0, 0x03, 0x80, 0x1F, 0xF0, 0x00, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x40, 0x00, 0x7F, 0xE0, 0xE0, 0x03, 0xFF, 0x81, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x7F, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x03, 0xF7, 0xF8, 0x00,
  0x0F, 0xDF, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x7E, 0x7F, 0x80, 0x01,
  0xF8, 0xFF, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x0F, 0xC7, 0xFC, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x07, 0xE0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0xFF,
  0xC0, 0xE0, 0x07, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0E, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xCF, 0xFC, 0x03, 0xFE, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xC7,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x0F, 0xFC, 0x07, 0xF8,
  0x7F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x04, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80,
  0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xE0,
  0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0x87,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x00,
  0x1F, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x06,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0x07,
  0x01, 0xFF, 0x04, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x03, 0xFF, 0x03, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0xFC,
  0x1F, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0x7F, 0xFF, 0xC3, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0x83,
  0xE3, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x3F, 0x07, 0xE7, 0xE1, 0xF8,
  0x1F, 0x81, 0xF1, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0x8F, 0xC3, 0xF0, 0x3F, 0x03, 0xE3,
  0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x3F, 0x07, 0xF0, 0x7C, 0x3E, 0x0F,
  0xC1, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xFF, 0x0F, 0x83, 0xE0, 0xFE, 0x3F,
  0xC7, 0xE0, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x7F, 0xF8,
  0x0F, 0x81, 0xFF, 0xCF, 0xFC, 0x03, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFC,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x38, 0x01, 0xFF, 0xC0, 0x10, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x02, 0x00, 0x7F, 0xF0, 0x0C, 0x00,
  0x7F, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x9F, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x10, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x30, 0x01, 0xFF,
  0xC0, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xC0,
  0x7F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0x03, 0xFD, 0xFC,
  0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xDF,
  0xC0, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xF0, 0x7F, 0xBF, 0xE0, 0x07, 0xF9,
  0xFC, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x0F, 0xF3, 0xFC, 0x00, 0x7F,
  0x9F, 0xC3, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF1, 0xFC, 0x7F, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x1F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xCF, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFD, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x7F, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0xFF,
  0x00, 0x3F, 0xE1, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFF, 0x81,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xF8,
  0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFD, 0xFE, 0x07, 0xF8,
  0x01, 0xFD, 0xFE, 0x07, 0xF8, 0x03, 0xFD, 0xFE, 0x0F, 0xF8, 0x03, 0xFD,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xBF, 0xC0,
  0x0F, 0xF0, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0,
  0x3F, 0xBF, 0xC0, 0x1F, 0xE0, 0x3F, 0xBF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xC0, 0x38, 0x01,
  0xFF, 0x80, 0x10, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x60, 0x00, 0xFF, 0x80, 0x70, 0x01, 0xFF, 0x80, 0x7C,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xF0,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xF0,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xF0,
  0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xF0,
  0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xF7, 0xF0,
  0xFF, 0x80, 0xFF, 0x87, 0xF7, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF7, 0xF1,
  0xFF, 0x00, 0xFF, 0x0F, 0xE7, 0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xE7, 0xF1,
  0xFE, 0x00, 0xFF, 0x1F, 0xC7, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xC7, 0xE3,
  0xFC, 0x00, 0xFF, 0x3F, 0xCF, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0x8F, 0xE7,
  0xFC, 0x00, 0xFF, 0x3F, 0x8F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x0F, 0xEF,
  0xF8, 0x00, 0xFF, 0x7F, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE,
  0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x10, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC,
  0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF,
  0xC7, 0xF8, 0x07, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0x8F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0xFF, 0x3F, 0xF8, 0x01, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0xFC, 0x01,
  0xFC, 0x7F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFE, 0x06, 0x03, 0xFF, 0x00, 0x80, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x10, 0x1F, 0xF0,
  0x08, 0x07, 0xFE, 0x0E, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x3F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF3, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x0F,
  0xFF, 0xBF, 0x80, 0x01, 0xFF, 0xCF, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x98, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0C, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0xFF, 0xE3, 0xFC, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0x87, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x80, 0x01,
  0xFF, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE1, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xF8, 0x01,
  0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC7, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x07,
  0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0xC3, 0xFE, 0x07, 0xFC,
  0x01, 0xFC, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0x3F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0x00, 0x7F, 0x3F, 0xFC, 0x01, 0xF9, 0xFF,
  0xF8, 0x07, 0xEF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0x80,
  0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xCF, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0xF0, 0x00,
  0x7F, 0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x7F, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0x80, 0x03,
  0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0xE7, 0xF0,
  0x03, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF,
  0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x9F, 0xF0, 0x1F, 0xDF, 0xF0, 0x1F, 0xEF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFC, 0xFC, 0x0F, 0xF8, 0x0E, 0x07, 0xFC, 0x02,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x08, 0x00, 0xFF, 0x84,
  0x00, 0xFF, 0xC3, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x78, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xCF,
  0xE0, 0x0F, 0xFE, 0x3F, 0x80, 0x1F, 0xF0, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F,
  0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xFC, 0x0F,
  0xF3, 0xFC, 0x0F, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xFF, 0x83, 0xFC, 0x7F, 0x87, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xF8, 0xFF,
  0x07, 0xF8, 0xFD, 0xFC, 0x7F, 0x83, 0xFC, 0xFE, 0xFE, 0x3F, 0x81, 0xFE,
  0x7F, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0x3F, 0x9F, 0xE0, 0x7F, 0xBF, 0x9F,
  0xDF, 0xE0, 0x3F, 0xDF, 0xCF, 0xCF, 0xF0, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0,
  0x0F, 0xEF, 0xE3, 0xF7, 0xF8, 0x07, 0xF7, 0xE1, 0xFB, 0xFC, 0x03, 0xFB,
  0xF0, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x04, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x11, 0xFF, 0x00, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEC, 0x00, 0x7F, 0xFC, 0x80,
  0x01, 0xFF, 0x88, 0x00, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 20, 50, 17, 0, -49 },
  { 126, 24, 18, 27, 6, -49 },
  { 180, 34, 49, 33, 0, -49 },
  { 389, 31, 56, 29, 0, -52 },
  { 606, 42, 50, 48, 4, -49 },
  { 869, 35, 50, 35, 0, -49 },
  { 1088, 11, 18, 17, 7, -49 },
  { 1113, 23, 60, 18, 1, -49 },
  { 1286, 22, 61, 19, -5, -50 },
  { 1454, 26, 28, 28, 5, -52 },
  { 1545, 27, 32, 32, 3, -40 },
  { 1653, 15, 18, 16, -4, -9 },
  { 1687, 18, 8, 20, 1, -22 },
  { 1705, 11, 11, 16, 0, -10 },
  { 1721, 35, 49, 25, -4, -49 },
  { 1936, 28, 50, 29, 1, -49 },
  { 2111, 21, 49, 30, 7, -49 },
  { 2240, 33, 49, 29, -3, -49 },
  { 2443, 31, 50, 29, -1, -49 },
  { 2637, 31, 49, 30, -1, -49 },
  { 2827, 30, 50, 29, 0, -49 },
  { 3015, 29, 50, 29, 2, -49 },
  { 3197, 31, 48, 29, 2, -48 },
  { 3383, 30, 50, 29, 0, -49 },
  { 3571, 29, 50, 29, 0, -49 },
  { 3753, 16, 39, 16, 0, -38 },
  { 3831, 20, 47, 16, -4, -38 },
  { 3949, 27, 33, 32, 3, -41 },
  { 4061, 28, 20, 32, 3, -34 },
  { 4131, 28, 33, 32, 3, -41 },
  { 4247, 24, 50, 23, 2, -49 },
  { 4397, 42, 54, 44, 2, -49 },
  { 4681, 32, 49, 32, -4, -49 },
  { 4877, 33, 49, 32, 0, -49 },
  { 5080, 32, 50, 30, 2, -49 },
  { 5280, 34, 49, 35, 0, -49 },
  { 5489, 30, 49, 27, 0, -49 },
  { 5673, 30, 49, 26, 0, -49 },
  { 5857, 36, 50, 36, 2, -49 },
  { 6082, 38, 49, 36, 0, -49 },
  { 6315, 30, 49, 22, -3, -49 },
  { 6499, 29, 63, 17, -10, -49 },
  { 6728, 38, 49, 31, 0, -49 },
  { 6961, 22, 49, 26, 0, -49 },
  { 7096, 50, 49, 47, 0, -49 },
  { 7403, 40, 49, 38, 0, -49 },
  { 7648, 35, 50, 37, 2, -49 },
  { 7867, 34, 49, 31, 0, -49 },
  { 8076, 35, 61, 37, 2, -49 },
  { 8343, 32, 49, 31, 0, -49 },
  { 8539, 32, 50, 28, -1, -49 },
  { 8739, 27, 49, 27, 5, -49 },
  { 8905, 36, 50, 35, 2, -49 },
  { 9130, 31, 49, 32, 6, -49 },
  { 9320, 48, 49, 48, 5, -49 },
  { 9614, 39, 49, 30, -4, -49 },
  { 9853, 29, 49, 29, 6, -49 },
  { 10031, 34, 49, 26, -3, -49 },
  { 10240, 27, 60, 19, -3, -49 },
  { 10443, 14, 49, 26, 7, -49 },
  { 10529, 27, 60, 19, -5, -49 },
  { 10732, 30, 30, 30, 0, -49 },
  { 10845, 23, 4, 22, -6, 6 },
  { 10857, 12, 11, 20, 10, -52 },
  { 10874, 31, 39, 31, 1, -38 },
  { 11026, 31, 53, 31, -1, -52 },
  { 11232, 26, 39, 25, 1, -38 },
  { 11359, 34, 53, 31, 1, -52 },
  { 11585, 27, 39, 29, 1, -38 },
  { 11717, 35, 68, 19, -8, -52 },
  { 12015, 34, 54, 31, -2, -38 },
  { 12245, 31, 52, 31, -1, -52 },
  { 12447, 20, 52, 16, -1, -52 },
  { 12577, 28, 68, 16, -9, -52 },
  { 12815, 32, 52, 29, 0, -52 },
  { 13023, 20, 52, 15, -1, -52 },
  { 13153, 44, 38, 46, 0, -38 },
  { 13362, 30, 38, 31, 0, -38 },
  { 13505, 28, 39, 30, 1, -38 },
  { 13642, 34, 54, 31, -4, -38 },
  { 13872, 31, 54, 31, 1, -38 },
  { 14082, 25, 38, 22, 0, -38 },
  { 14201, 25, 39, 24, 0, -38 },
  { 14323, 20, 46, 20, 2, -45 },
  { 14438, 30, 38, 31, 1, -37 },
  { 14581, 27, 37, 27, 4, -37 },
  { 14706, 41, 37, 42, 4, -37 },
  { 14896, 34, 37, 28, -3, -37 },
  { 15054, 36, 53, 27, -5, -37 },
  { 15293, 28, 37, 23, -3, -37 },
  { 15423, 27, 60, 23, 1, -49 },
  { 15626, 8, 67, 25, 8, -52 },
  { 15693, 26, 60, 23, -4, -49 },
  { 15888, 28, 12, 32, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC68PT7B_H_
