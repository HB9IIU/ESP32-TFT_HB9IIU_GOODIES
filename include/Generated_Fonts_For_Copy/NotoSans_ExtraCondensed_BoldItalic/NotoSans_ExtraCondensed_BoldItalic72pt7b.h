#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF,
  0xCF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x67, 0xE0, 0x03, 0xFE, 0x70, 0xF0, 0x01,
  0xFE, 0x38, 0x10, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0x7F, 0x8E, 0x00, 0x00,
  0x7F, 0xC6, 0x00, 0x00, 0x3F, 0xE7, 0x00, 0x00, 0x0F, 0xFB, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x77, 0xFE, 0x00, 0x00, 0x3B,
  0xFF, 0x00, 0x00, 0x1C, 0xFF, 0x80, 0x00, 0x0C, 0x7F, 0xC0, 0x40, 0x0E,
  0x3F, 0xE0, 0x20, 0x07, 0x1F, 0xF0, 0x1C, 0x03, 0x9F, 0xF8, 0x1F, 0x01,
  0xCF, 0xF8, 0x0F, 0xF0, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x80, 0x60, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F,
  0xC3, 0xF0, 0x7F, 0x1F, 0xC3, 0xFF, 0x9F, 0x87, 0xF1, 0xFC, 0x3F, 0xFC,
  0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0xF7, 0xF3, 0xF8, 0xFE, 0x3F, 0xFF, 0xBF,
  0xFF, 0xC7, 0xE1, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xF7, 0xFF,
  0xC7, 0xF1, 0xFC, 0x3F, 0xBF, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0xFF, 0xC3,
  0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xF0, 0x3F, 0xEF, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xE7, 0xF8,
  0x3F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0xC0, 0x3F, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x9F, 0xF8, 0x07,
  0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x40, 0x3F, 0x80, 0x0E, 0x07, 0xF0, 0x01, 0xE1, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0xCF, 0xFF, 0xF0, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xEF, 0xF0, 0x1F, 0xF9, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFE, 0x01, 0xF0, 0x7F, 0xC0, 0x1C,
  0x07, 0xE0, 0x01, 0x80, 0xF0, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0x83,
  0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF1,
  0xFC, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F,
  0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0x1F, 0xFB, 0xFE, 0x1F, 0xE7, 0xFC, 0x3F,
  0x8F, 0xF8, 0x3E, 0x1F, 0xE0, 0x38, 0x7F, 0xC0, 0x20, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x0F, 0xF0,
  0x3F, 0xF0, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x0C,
  0x00, 0x7F, 0xC0, 0x02, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x87,
  0xFF, 0x80, 0x0E, 0x01, 0xFF, 0xC0, 0x06, 0x00, 0x7F, 0xE0, 0x02, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x40, 0x00, 0x3F, 0xF0, 0x30, 0x00, 0x3F, 0xF8, 0x1E, 0x00, 0x7F,
  0xF8, 0x0F, 0xFB, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x03, 0xF9,
  0xFF, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x01, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x7F, 0xC0, 0x00, 0xFC, 0x3F, 0xE0, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0xFE,
  0x0F, 0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x01, 0xFF, 0xC0, 0xC0, 0x03,
  0xFF, 0x80, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x01,
  0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x01, 0xFF,
  0xC3, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xF8, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x0F, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0x80, 0xFF, 0x83, 0x00, 0x7F, 0xC1, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x06, 0x00,
  0x3F, 0x03, 0xF8, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFC, 0x3F,
  0x07, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x3F, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC3, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x83, 0xF8,
  0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xF0, 0x3F,
  0x03, 0xF3, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x7E, 0x0F, 0xE0, 0x7F, 0x07,
  0xE7, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE7,
  0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xCF, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x83, 0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0x7F, 0xC7,
  0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0xF7, 0xFF, 0xC0,
  0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x00, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFC, 0x00,
  0xFF, 0xF0, 0x0E, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x80, 0x1F, 0xFE, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x20, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0x20,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x43, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0xFE, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF,
  0xE0, 0x3F, 0xDF, 0xF0, 0x03, 0xFC, 0xFE, 0x03, 0xF9, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFE, 0x07, 0xF3, 0xFE, 0x00,
  0x7F, 0xCF, 0xE0, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x0F, 0xF3, 0xFE,
  0x00, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x1F, 0xE7,
  0xFC, 0x00, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x3F,
  0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF3, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x1F,
  0xE0, 0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF7,
  0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xDF, 0xE0,
  0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xE7, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0x9F, 0xE0, 0x03, 0xFE, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x1F, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0x80, 0x0F, 0xFE, 0x00,
  0xC0, 0x07, 0xFF, 0x00, 0x10, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x40, 0x00, 0x7F, 0xE0, 0x1C, 0x00, 0x3F, 0xF8,
  0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x81,
  0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F,
  0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xBF, 0xC3, 0xFE, 0x00,
  0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xBF, 0xC7, 0xFC,
  0x00, 0x7F, 0x87, 0xF3, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x3F, 0x87,
  0xFC, 0x00, 0x7F, 0x8F, 0xF3, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFE, 0x3F,
  0x8F, 0xF8, 0x00, 0x7F, 0x9F, 0xE3, 0xF9, 0xFF, 0x00, 0x07, 0xF9, 0xFC,
  0x3F, 0x9F, 0xF0, 0x00, 0x7F, 0xBF, 0xC3, 0xF9, 0xFF, 0x00, 0x0F, 0xFB,
  0xFC, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0xBF, 0x83, 0xFB, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF3, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xFE, 0x3F, 0xC0, 0x1F,
  0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xEF, 0xF0, 0x03, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xF3, 0xFC, 0x00, 0x7F,
  0xF1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F,
  0xCF, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF, 0xF0, 0x07, 0xFB,
  0xFF, 0xF0, 0x03, 0xF8, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0x01, 0xFF, 0x80,
  0x40, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x04, 0x07,
  0xFE, 0x03, 0x80, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0xE7, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF1, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x40, 0xFF, 0xC0, 0x1C, 0x0F, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x40, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xE0,
  0x00, 0xFF, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFD, 0xFF,
  0x00, 0x03, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x70,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x7F, 0x8F, 0xFC, 0x00,
  0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x10, 0x7F, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x7F, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x3F, 0xFC, 0x3F,
  0xFC, 0x00, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x3F, 0xE0, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xE0, 0x1F,
  0xCF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF,
  0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF9, 0xFE, 0x00, 0xFF, 0x8F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xE3, 0xFF,
  0xC0, 0x01, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xEF, 0xFF, 0xE0, 0x01, 0xFD,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0xF0, 0x00, 0xFF, 0xBF,
  0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xC0, 0x0F, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F,
  0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xF7, 0xFC, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x01, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF3, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x07, 0x01, 0xFF, 0x80, 0x20, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x20, 0x03, 0xFF, 0x07, 0x00, 0xFF, 0xE0, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x82, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xCF, 0xE0, 0x07,
  0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0xE0,
  0x3F, 0xE7, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xCF, 0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0x8F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8,
  0x7F, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xEF, 0xC3, 0xFE, 0x0F, 0xF8, 0xFE, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xC3, 0xFC, 0x0F, 0xF1, 0xFD, 0xFC, 0x7F,
  0xC0, 0xFF, 0x1F, 0xDF, 0xC7, 0xF8, 0x0F, 0xF3, 0xF9, 0xFC, 0x7F, 0x80,
  0xFF, 0x3F, 0x9F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF9, 0xFC, 0xFF, 0x00, 0xFF,
  0x7F, 0x1F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF1, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE1, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFB, 0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 21, 52, 18, 0, -51 },
  { 138, 25, 18, 28, 7, -51 },
  { 195, 36, 51, 34, 0, -51 },
  { 425, 33, 59, 31, 0, -55 },
  { 669, 45, 53, 51, 4, -52 },
  { 968, 37, 53, 37, 0, -52 },
  { 1214, 12, 18, 18, 7, -51 },
  { 1241, 24, 63, 19, 1, -52 },
  { 1430, 25, 63, 20, -6, -52 },
  { 1627, 27, 30, 30, 6, -55 },
  { 1729, 29, 35, 33, 3, -43 },
  { 1856, 16, 20, 17, -4, -10 },
  { 1896, 19, 9, 21, 1, -24 },
  { 1918, 11, 12, 17, 0, -11 },
  { 1935, 37, 53, 27, -4, -52 },
  { 2181, 30, 53, 31, 1, -52 },
  { 2380, 23, 51, 31, 7, -51 },
  { 2527, 34, 52, 31, -3, -52 },
  { 2748, 33, 53, 31, -1, -52 },
  { 2967, 33, 52, 31, -1, -52 },
  { 3182, 32, 52, 31, 0, -51 },
  { 3390, 31, 53, 31, 2, -52 },
  { 3596, 33, 51, 31, 2, -51 },
  { 3807, 32, 53, 31, 0, -52 },
  { 4019, 31, 53, 31, 0, -52 },
  { 4225, 17, 41, 17, 0, -40 },
  { 4313, 21, 50, 17, -4, -40 },
  { 4445, 29, 34, 33, 3, -43 },
  { 4569, 29, 21, 33, 3, -36 },
  { 4646, 30, 34, 33, 3, -43 },
  { 4774, 25, 53, 24, 2, -52 },
  { 4940, 44, 58, 47, 2, -52 },
  { 5259, 33, 52, 34, -4, -52 },
  { 5474, 35, 51, 34, 0, -51 },
  { 5698, 33, 53, 32, 3, -52 },
  { 5917, 37, 51, 37, 0, -51 },
  { 6153, 32, 51, 29, 0, -51 },
  { 6357, 32, 51, 28, 0, -51 },
  { 6561, 37, 53, 38, 3, -52 },
  { 6807, 41, 51, 38, 0, -51 },
  { 7069, 31, 51, 23, -3, -51 },
  { 7267, 31, 66, 18, -11, -51 },
  { 7523, 40, 51, 33, 0, -51 },
  { 7778, 23, 51, 28, 0, -51 },
  { 7925, 52, 51, 50, 0, -51 },
  { 8257, 43, 51, 40, 0, -51 },
  { 8532, 36, 53, 39, 3, -52 },
  { 8771, 36, 51, 33, 0, -51 },
  { 9001, 36, 64, 39, 3, -52 },
  { 9289, 34, 51, 33, 0, -51 },
  { 9506, 34, 53, 30, -1, -52 },
  { 9732, 29, 51, 29, 5, -51 },
  { 9917, 38, 52, 37, 2, -51 },
  { 10164, 34, 51, 33, 6, -51 },
  { 10381, 52, 51, 50, 5, -51 },
  { 10713, 41, 51, 32, -4, -51 },
  { 10975, 31, 51, 31, 6, -51 },
  { 11173, 36, 51, 28, -3, -51 },
  { 11403, 29, 63, 20, -3, -52 },
  { 11632, 15, 53, 27, 7, -52 },
  { 11732, 28, 63, 20, -5, -52 },
  { 11953, 31, 30, 31, 0, -51 },
  { 12070, 25, 5, 23, -7, 6 },
  { 12086, 14, 11, 21, 10, -55 },
  { 12106, 33, 41, 33, 1, -40 },
  { 12276, 33, 56, 33, -1, -55 },
  { 12507, 27, 41, 26, 2, -40 },
  { 12646, 36, 56, 33, 1, -55 },
  { 12898, 28, 41, 30, 2, -40 },
  { 13042, 36, 72, 20, -8, -55 },
  { 13366, 36, 57, 33, -2, -40 },
  { 13623, 32, 55, 33, -1, -55 },
  { 13843, 21, 55, 16, -1, -55 },
  { 13988, 29, 72, 16, -9, -55 },
  { 14249, 35, 55, 31, -1, -55 },
  { 14490, 21, 55, 16, -1, -55 },
  { 14635, 48, 40, 48, -1, -40 },
  { 14875, 31, 40, 33, 0, -40 },
  { 15030, 29, 41, 32, 2, -40 },
  { 15179, 36, 57, 33, -4, -40 },
  { 15436, 33, 57, 33, 1, -40 },
  { 15672, 28, 40, 23, -1, -40 },
  { 15812, 27, 41, 26, 0, -40 },
  { 15951, 21, 49, 21, 2, -48 },
  { 16080, 31, 40, 33, 2, -39 },
  { 16235, 29, 39, 29, 4, -39 },
  { 16377, 44, 39, 44, 4, -39 },
  { 16592, 36, 39, 29, -4, -39 },
  { 16768, 38, 56, 29, -5, -39 },
  { 17034, 30, 39, 24, -3, -39 },
  { 17181, 28, 62, 24, 1, -51 },
  { 17398, 8, 71, 27, 9, -55 },
  { 17469, 27, 62, 24, -4, -51 },
  { 17679, 30, 12, 33, 3, -31 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC72PT7B_H_
