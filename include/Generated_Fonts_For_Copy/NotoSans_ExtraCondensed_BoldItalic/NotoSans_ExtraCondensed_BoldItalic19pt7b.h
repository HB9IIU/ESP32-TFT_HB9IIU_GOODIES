#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xCE, 0x63, 0x00, 0xCE, 0x70, 0x6F, 0xBC,
  0xF3, 0xD8, 0x0C, 0x83, 0x60, 0xD8, 0x24, 0x3F, 0xDF, 0xE1, 0x20, 0xD8,
  0xFF, 0x3F, 0xC6, 0xC1, 0xB0, 0x4C, 0x36, 0x00, 0x04, 0x07, 0xCF, 0xC6,
  0xA3, 0x41, 0xC0, 0xF0, 0x3C, 0x0E, 0x0B, 0x25, 0x9F, 0xCF, 0xC0, 0x80,
  0x80, 0x30, 0x47, 0x8C, 0x68, 0x8C, 0x98, 0xDB, 0x0D, 0xB0, 0xDE, 0xFF,
  0x7B, 0x6D, 0xB0, 0xD3, 0x19, 0x31, 0x36, 0x31, 0x66, 0x1C, 0x06, 0x07,
  0xC1, 0xB0, 0xEC, 0x3B, 0x07, 0x81, 0xC0, 0xF7, 0x6D, 0xBB, 0xEC, 0x73,
  0x1C, 0xFF, 0x1E, 0xE0, 0x7F, 0xEC, 0x0E, 0x18, 0x61, 0xC3, 0x06, 0x1C,
  0x30, 0x60, 0xC3, 0x87, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0x18, 0x70, 0xC3,
  0x0C, 0x30, 0xC7, 0x18, 0x61, 0x8E, 0x30, 0xC6, 0x18, 0xC0, 0x10, 0x1C,
  0x58, 0xFE, 0x3F, 0x3C, 0x6C, 0x2E, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x37, 0x66, 0xEC, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x00, 0x0E, 0x1F, 0x3F, 0x33, 0x73, 0x73, 0x63, 0x67,
  0x67, 0xE6, 0xEE, 0xEC, 0x7C, 0x78, 0x0C, 0x73, 0xBE, 0xDA, 0xE3, 0x8C,
  0x30, 0xC7, 0x1C, 0x61, 0x80, 0x07, 0x0F, 0xC6, 0xE2, 0x30, 0x18, 0x1C,
  0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x27, 0xE7, 0xF0, 0x0E, 0x3F, 0x37,
  0x03, 0x03, 0x07, 0x1C, 0x3C, 0x0E, 0x06, 0x06, 0x8E, 0xFC, 0xF8, 0x03,
  0x07, 0x07, 0x0F, 0x1F, 0x16, 0x36, 0x66, 0x4E, 0xFF, 0xFF, 0x0C, 0x0C,
  0x1C, 0x1F, 0x1F, 0x3F, 0x30, 0x30, 0x3C, 0x7E, 0x3E, 0x06, 0x06, 0x0E,
  0x8E, 0xFC, 0xF8, 0x03, 0x87, 0xC7, 0x27, 0x03, 0x03, 0xF1, 0xF8, 0xEE,
  0x67, 0x73, 0xB9, 0x8D, 0xC7, 0xC3, 0xE0, 0x3F, 0x9F, 0xCF, 0xE0, 0x60,
  0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x00, 0x0E,
  0x0F, 0x8C, 0xC6, 0x73, 0x31, 0xF8, 0x78, 0x78, 0x7E, 0x73, 0x31, 0x98,
  0xCF, 0xE3, 0xE0, 0x0E, 0x1F, 0x3F, 0x73, 0x73, 0x63, 0x67, 0x7F, 0x3E,
  0x06, 0x0E, 0x1C, 0xFC, 0xF0, 0x11, 0xCC, 0x40, 0x00, 0x00, 0x67, 0x38,
  0x08, 0x71, 0x84, 0x00, 0x00, 0x00, 0x31, 0xC6, 0x18, 0xE3, 0x00, 0x03,
  0x0F, 0x3C, 0xF0, 0xE0, 0x78, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xE0, 0x7C, 0x1F, 0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0x1C,
  0x7C, 0x98, 0x30, 0x61, 0x86, 0x18, 0x30, 0xC0, 0x03, 0x06, 0x1C, 0x00,
  0x03, 0xC0, 0xFE, 0x1C, 0x31, 0x03, 0x33, 0xD2, 0x69, 0x6D, 0x94, 0x9B,
  0x49, 0xB5, 0xB2, 0xCF, 0xEC, 0xDC, 0x40, 0x06, 0x10, 0x3F, 0x00, 0x80,
  0x03, 0x83, 0xC1, 0xE1, 0xB0, 0xD8, 0xEC, 0x6E, 0x37, 0x3F, 0x9F, 0xDF,
  0xEC, 0x7E, 0x3F, 0x1C, 0x1E, 0x0F, 0xCE, 0xE7, 0x33, 0x19, 0x9C, 0xFC,
  0xFC, 0x63, 0x31, 0x98, 0xDC, 0xEF, 0xE7, 0xE0, 0x0E, 0x0F, 0xCE, 0xCE,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x1C, 0x8F, 0xC3, 0xE0,
  0x1C, 0x07, 0xE3, 0xF8, 0xE7, 0x31, 0xCC, 0x73, 0x1D, 0xC6, 0x73, 0x98,
  0xE6, 0x73, 0xBC, 0xFE, 0x3E, 0x00, 0x1F, 0x8F, 0x8F, 0xC7, 0x03, 0x01,
  0x80, 0xF8, 0xFC, 0x70, 0x30, 0x18, 0x1C, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F,
  0x3F, 0x38, 0x30, 0x30, 0x3E, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0x07, 0x07, 0xF3, 0xD9, 0xC0, 0x70, 0x38, 0x0E, 0x7B, 0xBC, 0xCF, 0x31,
  0xCC, 0x73, 0x9C, 0xFE, 0x1F, 0x80, 0x18, 0xE3, 0x1C, 0xE3, 0x1C, 0x63,
  0x1C, 0x63, 0x8F, 0xE3, 0xFC, 0x73, 0x8C, 0x71, 0x8E, 0x71, 0x8E, 0x31,
  0xCE, 0x00, 0x1F, 0x1F, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x38, 0x78, 0xFC, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0xF8, 0xF0, 0x18, 0xE3,
  0x38, 0xE6, 0x1D, 0x83, 0x70, 0x6C, 0x0F, 0x03, 0xE0, 0x7E, 0x0D, 0xC1,
  0x98, 0x73, 0x0E, 0x61, 0x8E, 0x00, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x1C,
  0x71, 0x86, 0x38, 0xFF, 0xF0, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0x8F, 0x1E,
  0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x9F, 0x6C, 0x6D, 0xB1, 0xBC, 0xC6, 0xF7,
  0x3B, 0xD8, 0xEE, 0x63, 0x39, 0x80, 0x1C, 0x63, 0x8C, 0xF1, 0x9E, 0x73,
  0xCC, 0x79, 0x8F, 0xB3, 0xB6, 0x67, 0xCC, 0xF1, 0x9E, 0x73, 0xCE, 0x79,
  0x86, 0x00, 0x0E, 0x0F, 0xCE, 0xEE, 0x36, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3,
  0xE1, 0xB1, 0xDD, 0xCF, 0xE3, 0xE0, 0x1E, 0x0F, 0xCF, 0xE7, 0x33, 0x19,
  0x8C, 0xCE, 0xFE, 0x7E, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x0E, 0x0F,
  0xCE, 0xEE, 0x36, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xB1, 0xDD, 0xCF,
  0xE3, 0xE0, 0x70, 0x38, 0x1E, 0x00, 0x1C, 0x0F, 0x8E, 0xE7, 0x73, 0x39,
  0x9C, 0xDC, 0xFC, 0x7C, 0x37, 0x1B, 0x9C, 0xCE, 0x66, 0x38, 0x0E, 0x0F,
  0xCF, 0xC6, 0x03, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x91, 0xCF,
  0xC7, 0xC0, 0x7F, 0x7F, 0xFF, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0x31, 0xCC, 0x67, 0x19, 0xCE, 0x63, 0x98, 0xCE,
  0x33, 0x9C, 0xE7, 0x31, 0xCC, 0x63, 0x38, 0xFC, 0x1E, 0x00, 0xC3, 0xC7,
  0xC7, 0xC6, 0xCE, 0xCC, 0xDC, 0xD8, 0xD8, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0,
  0x63, 0x0D, 0x8C, 0x76, 0x71, 0x99, 0xCE, 0x67, 0x31, 0xBC, 0xC6, 0xF7,
  0x3B, 0xD8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0x8E,
  0x00, 0x18, 0xE3, 0x98, 0x76, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0xD8, 0x3B, 0x86, 0x71, 0xCE, 0x00, 0xC7, 0xC6, 0xCE,
  0xCC, 0xDC, 0xF8, 0xF0, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0x1F,
  0xC7, 0xE1, 0xF8, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x7E, 0x3F, 0x80, 0x0F, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x78, 0xF0, 0xCC, 0xCC,
  0xE6, 0x66, 0x66, 0x66, 0x73, 0x1E, 0x3C, 0x18, 0x60, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x78, 0xF0, 0x04, 0x0E, 0x0E, 0x1E,
  0x3E, 0x37, 0x63, 0x63, 0xC3, 0xFE, 0xDD, 0x80, 0x08, 0x1F, 0xCF, 0xEE,
  0x66, 0x33, 0x3B, 0x9D, 0xCC, 0xEE, 0x3F, 0x1D, 0x80, 0x18, 0x18, 0x38,
  0x32, 0x3F, 0x3F, 0x73, 0x73, 0x63, 0x63, 0x67, 0xE6, 0xFE, 0xDC, 0x04,
  0x1F, 0x3E, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE4, 0x7C, 0x7C, 0x01, 0xC0,
  0x60, 0x18, 0x26, 0x3F, 0x8F, 0xC7, 0x31, 0x8C, 0x63, 0x39, 0xCE, 0x63,
  0x98, 0x7E, 0x1D, 0x80, 0x04, 0x1E, 0x33, 0x73, 0x66, 0x7E, 0xF0, 0xE0,
  0xE0, 0x7C, 0x7C, 0x01, 0x03, 0xC1, 0xE0, 0xC0, 0xE0, 0xF8, 0x7C, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x78, 0x38,
  0x18, 0x00, 0x04, 0x07, 0xB1, 0xFC, 0xE6, 0x31, 0x8C, 0xE7, 0x39, 0xCC,
  0x77, 0x1F, 0xC3, 0xF0, 0x1C, 0x06, 0x3B, 0x8F, 0xC0, 0xC0, 0x18, 0x18,
  0x38, 0x32, 0x3F, 0x3F, 0x73, 0x73, 0x67, 0x67, 0x66, 0xE6, 0xE6, 0xCE,
  0x19, 0xC0, 0x03, 0x19, 0xCE, 0x63, 0x19, 0xCE, 0x60, 0x06, 0x1C, 0x00,
  0x00, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0xF1,
  0xC3, 0x00, 0x18, 0x0C, 0x0E, 0x06, 0x13, 0x31, 0xB9, 0xF8, 0xD8, 0x7C,
  0x3E, 0x1B, 0x1D, 0x8C, 0xE6, 0x70, 0x18, 0xCE, 0x73, 0x19, 0xCE, 0x63,
  0x19, 0xCE, 0x60, 0x02, 0x23, 0xFF, 0x3F, 0xF7, 0x33, 0x73, 0x36, 0x73,
  0x66, 0x76, 0x66, 0xE6, 0x6C, 0xE6, 0xCE, 0xE0, 0x02, 0x3F, 0x3F, 0x73,
  0x73, 0x67, 0x67, 0x66, 0xE6, 0xE6, 0xCE, 0x0C, 0x1E, 0x3F, 0x73, 0x63,
  0x63, 0xE7, 0xE7, 0xE6, 0x7E, 0x7C, 0x01, 0x0F, 0xC7, 0xE7, 0x33, 0x99,
  0x8C, 0xC6, 0x67, 0x73, 0x3F, 0x9B, 0x8C, 0x06, 0x07, 0x03, 0x01, 0x80,
  0x08, 0x0E, 0xCF, 0xCE, 0x66, 0x33, 0x1B, 0x9D, 0xCC, 0xE6, 0x7F, 0x1F,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x02, 0x7C, 0xFB, 0x87, 0x0C, 0x18,
  0x30, 0xE1, 0xC3, 0x00, 0x08, 0x7D, 0xD3, 0x87, 0x07, 0x07, 0x0E, 0x9D,
  0xF3, 0xE0, 0x31, 0x8D, 0xFF, 0xB3, 0x9C, 0xC6, 0x31, 0xCE, 0x00, 0x33,
  0x99, 0x9C, 0xCC, 0x66, 0x73, 0x31, 0x99, 0xDC, 0xFE, 0x3B, 0x00, 0xC7,
  0xCE, 0xCC, 0xCC, 0xD8, 0xD8, 0xF0, 0xF0, 0xF0, 0xE0, 0xCE, 0x7C, 0xE6,
  0xCE, 0xCD, 0xEC, 0xDE, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x70,
  0x3B, 0xC6, 0xC1, 0xF0, 0x78, 0x1C, 0x07, 0x03, 0xE0, 0xD8, 0x66, 0x39,
  0x80, 0x39, 0xCE, 0xE3, 0xB0, 0xEC, 0x3E, 0x0F, 0x81, 0x60, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0xF0, 0x38, 0x08, 0x00, 0x3F, 0x3F, 0x0E, 0x0C,
  0x1C, 0x18, 0x30, 0x70, 0x7C, 0xFC, 0x03, 0x0F, 0x0E, 0x1C, 0x18, 0x18,
  0x18, 0x78, 0xE0, 0xF0, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x38, 0x70, 0x60, 0xC1, 0x87, 0x0E, 0x0E,
  0x3C, 0xE1, 0xC3, 0x06, 0x1C, 0x78, 0xE0, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 8, 2, -14 },
  { 14, 10, 14, 9, 0, -14 },
  { 32, 9, 15, 8, 0, -14 },
  { 49, 12, 14, 13, 1, -14 },
  { 70, 10, 14, 10, 0, -14 },
  { 88, 3, 5, 5, 2, -14 },
  { 90, 7, 17, 5, 0, -14 },
  { 105, 6, 17, 5, -1, -14 },
  { 118, 8, 8, 8, 1, -15 },
  { 126, 8, 9, 9, 1, -11 },
  { 135, 4, 6, 5, -1, -3 },
  { 138, 5, 2, 5, 0, -6 },
  { 140, 3, 3, 5, 0, -3 },
  { 142, 10, 14, 7, -1, -14 },
  { 160, 8, 14, 8, 0, -14 },
  { 174, 6, 14, 8, 2, -14 },
  { 185, 9, 14, 8, -1, -14 },
  { 201, 8, 14, 8, 0, -14 },
  { 215, 8, 14, 8, 0, -14 },
  { 229, 8, 14, 8, 0, -14 },
  { 243, 9, 14, 8, 0, -14 },
  { 259, 9, 14, 8, 0, -14 },
  { 275, 9, 14, 8, 0, -14 },
  { 291, 8, 14, 8, 0, -14 },
  { 305, 5, 11, 5, 0, -11 },
  { 312, 6, 14, 5, -1, -11 },
  { 323, 8, 9, 9, 1, -11 },
  { 332, 8, 6, 9, 1, -10 },
  { 338, 8, 9, 9, 1, -11 },
  { 347, 7, 14, 6, 0, -14 },
  { 360, 12, 16, 12, 0, -14 },
  { 384, 9, 14, 9, -1, -14 },
  { 400, 9, 14, 9, 0, -14 },
  { 416, 9, 14, 8, 1, -14 },
  { 432, 10, 14, 10, 0, -14 },
  { 450, 9, 14, 8, 0, -14 },
  { 466, 8, 14, 7, 0, -14 },
  { 480, 10, 14, 10, 1, -14 },
  { 498, 11, 14, 10, 0, -14 },
  { 518, 8, 14, 6, -1, -14 },
  { 532, 8, 18, 5, -3, -14 },
  { 550, 11, 14, 9, 0, -14 },
  { 570, 6, 14, 7, 0, -14 },
  { 581, 14, 14, 13, 0, -14 },
  { 606, 11, 14, 11, 0, -14 },
  { 626, 9, 14, 10, 1, -14 },
  { 642, 9, 14, 9, 0, -14 },
  { 658, 9, 17, 10, 1, -14 },
  { 678, 9, 14, 9, 0, -14 },
  { 694, 9, 14, 8, 0, -14 },
  { 710, 8, 14, 8, 1, -14 },
  { 724, 10, 14, 10, 1, -14 },
  { 742, 8, 14, 9, 2, -14 },
  { 756, 14, 14, 13, 1, -14 },
  { 781, 11, 14, 8, -1, -14 },
  { 801, 8, 14, 8, 2, -14 },
  { 815, 10, 14, 7, -1, -14 },
  { 833, 8, 17, 5, -1, -14 },
  { 850, 4, 14, 7, 2, -14 },
  { 857, 7, 17, 5, -1, -14 },
  { 872, 8, 9, 8, 0, -14 },
  { 881, 7, 1, 6, -2, 2 },
  { 882, 3, 3, 6, 3, -15 },
  { 884, 9, 11, 9, 0, -11 },
  { 897, 8, 14, 9, 0, -14 },
  { 911, 8, 11, 7, 0, -11 },
  { 922, 10, 14, 9, 0, -14 },
  { 940, 8, 11, 8, 0, -11 },
  { 951, 9, 20, 5, -2, -15 },
  { 974, 10, 16, 9, -1, -11 },
  { 994, 8, 14, 9, 0, -14 },
  { 1008, 5, 14, 4, 0, -14 },
  { 1017, 7, 19, 4, -2, -14 },
  { 1034, 9, 14, 8, 0, -14 },
  { 1050, 5, 14, 4, 0, -14 },
  { 1059, 12, 11, 13, 0, -11 },
  { 1076, 8, 11, 9, 0, -11 },
  { 1087, 8, 11, 8, 0, -11 },
  { 1098, 9, 16, 9, -1, -11 },
  { 1116, 9, 16, 9, 0, -11 },
  { 1134, 7, 11, 6, 0, -11 },
  { 1144, 7, 11, 7, 0, -11 },
  { 1154, 5, 13, 6, 1, -13 },
  { 1163, 9, 10, 9, 0, -10 },
  { 1175, 8, 10, 8, 1, -10 },
  { 1185, 12, 10, 12, 1, -10 },
  { 1200, 10, 10, 8, -1, -10 },
  { 1213, 10, 15, 8, -1, -10 },
  { 1232, 8, 10, 6, -1, -10 },
  { 1242, 8, 17, 6, 0, -14 },
  { 1259, 2, 19, 7, 2, -15 },
  { 1264, 7, 17, 6, -1, -14 },
  { 1279, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC19PT7B_H_
