#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x1E, 0x1F, 0x0F,
  0x87, 0x80, 0x79, 0xEF, 0x79, 0xCF, 0x39, 0xEF, 0x3D, 0xE7, 0x38, 0xE7,
  0x1C, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x8C, 0x03, 0x9C, 0x03, 0x9C, 0x03,
  0x18, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x1C, 0x60, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x39, 0xC0, 0x39,
  0xC0, 0x71, 0x80, 0x73, 0x80, 0x73, 0x80, 0xE3, 0x00, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFB, 0x87, 0xA4, 0x1C,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xBC, 0x02, 0xF2, 0x0B, 0xC6, 0x6F, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x01,
  0xE0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0x07, 0x87, 0xE0, 0xE1,
  0xDC, 0x38, 0x39, 0x87, 0x0E, 0x31, 0xC1, 0xCE, 0x38, 0x39, 0xCE, 0x07,
  0x39, 0xC0, 0xC7, 0x71, 0x19, 0xCE, 0xFB, 0xBB, 0xBF, 0xFE, 0xE7, 0x7F,
  0x9D, 0xCE, 0x07, 0x39, 0xC0, 0xE6, 0x38, 0x39, 0xC7, 0x07, 0x38, 0xC1,
  0xC7, 0x38, 0x38, 0xE7, 0x0E, 0x1D, 0xC1, 0xC1, 0xF8, 0x70, 0x3E, 0x00,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x1F, 0xCF,
  0x3F, 0xDE, 0x7B, 0xDE, 0x71, 0xFC, 0xF1, 0xFC, 0xF1, 0xF8, 0xF0, 0xF0,
  0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x7C, 0x7B, 0xDE, 0xE7, 0x7B,
  0xDC, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x03, 0x80, 0x07, 0x00, 0x78, 0x07, 0x06, 0x70, 0x7F, 0x7F, 0xFF, 0x3F,
  0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x7B, 0xC3, 0x1E, 0x11, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x3C, 0xF1,
  0xE3, 0x8F, 0x1E, 0x78, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x33, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0xFF,
  0x1F, 0xF1, 0xEF, 0x3C, 0x73, 0xC7, 0x78, 0x77, 0x8F, 0x78, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEE, 0x1E, 0xE3, 0xCE, 0x3C,
  0xF7, 0x8F, 0xF8, 0xFF, 0x07, 0xE0, 0x03, 0xC1, 0xF0, 0xF8, 0x7E, 0x7F,
  0xBF, 0xEF, 0x79, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x79, 0xF0, 0x43, 0xE0, 0x87, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0x1F, 0x08,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x03,
  0xF8, 0x13, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF2, 0x07, 0x8C,
  0x7E, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x01, 0xFC, 0x0E, 0xF0, 0x73,
  0xC1, 0xCE, 0x0E, 0x78, 0x71, 0xE1, 0xC7, 0x8F, 0xFF, 0xBF, 0xFC, 0xFF,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x06, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xE2, 0x07, 0x8E, 0x7E, 0x3F, 0xF0, 0xFF, 0x83, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x7B, 0xC3, 0xFF, 0x3F, 0xF9, 0xF3, 0xCF, 0x1F, 0x78, 0xF3,
  0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3D, 0xF1, 0xFF, 0x87, 0xF8, 0x1F,
  0x80, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x1F, 0xF0, 0x3F, 0x80, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xE7, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC3, 0xFE,
  0x3C, 0xF1, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0xCF,
  0x3E, 0x7F, 0xF3, 0xFF, 0x0F, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x21, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x3E, 0x7C, 0xF0, 0x03, 0x81,
  0xF0, 0x78, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x0F, 0x00, 0x60, 0x00, 0x1F, 0xC7, 0xF8, 0xFF, 0x90, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x00, 0x00, 0x00, 0x04, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xE1, 0xE0, 0x0E, 0x38,
  0x61, 0xCE, 0x3F, 0xB9, 0x8F, 0xE7, 0x73, 0x9C, 0xEE, 0x73, 0x9D, 0x9C,
  0x73, 0xF3, 0x8C, 0x6E, 0x73, 0x8D, 0xCC, 0x73, 0xB1, 0x8E, 0x66, 0x33,
  0xDC, 0xC7, 0xFF, 0x18, 0xF3, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x20, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xFF,
  0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x79, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x7C, 0x3F, 0xF0, 0xFF, 0x81, 0xFF,
  0x83, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1,
  0xE7, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFC, 0xC1, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF3, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1E,
  0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x78,
  0x78, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x10, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x86,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x02,
  0x78, 0xFC, 0xF8, 0xFC, 0xF8, 0xFC, 0xF1, 0x3C, 0xF0, 0x7C, 0xF0, 0x78,
  0xF8, 0x78, 0xF8, 0x78, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x00, 0x0F, 0xF8, 0x7F, 0xC1, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x20, 0x00, 0x0F, 0x8F, 0x87, 0x87, 0x83, 0xC7, 0x81,
  0xE7, 0xC0, 0xF3, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xE0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0xC0, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1D, 0xC7, 0xF8, 0x3B, 0x8E,
  0xF0, 0xF7, 0x3F, 0xC1, 0xEE, 0x77, 0x83, 0xDC, 0xEF, 0x07, 0x3B, 0x9E,
  0x0E, 0x77, 0x38, 0x3C, 0xFC, 0xF0, 0x79, 0xF9, 0xE0, 0xF3, 0xF3, 0xC1,
  0xC7, 0xC7, 0x87, 0x8F, 0x8E, 0x0F, 0x1E, 0x3C, 0x1E, 0x3C, 0x78, 0x00,
  0x0F, 0x81, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3F, 0x0F, 0x0F, 0xC3, 0x87,
  0xF1, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1D, 0xC7, 0x87, 0x79, 0xC3, 0xDE,
  0xF0, 0xF3, 0xBC, 0x3C, 0xEF, 0x0E, 0x3B, 0xC3, 0x8F, 0xE1, 0xE3, 0xF8,
  0x78, 0xFE, 0x1E, 0x1F, 0x87, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C,
  0x1F, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E, 0x1E, 0x1F,
  0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78,
  0xF8, 0xF8, 0xFD, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7B, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0xF3, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0x7C, 0xF8, 0xF8, 0xFD, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x79, 0xF0, 0xF3, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F,
  0x1E, 0x1E, 0x3C, 0x38, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xBC,
  0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x1F, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x7E, 0xE0,
  0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x81, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFB,
  0xFF, 0x9F, 0xFD, 0xFF, 0xE0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xFB, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC,
  0x3E, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3B, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x78, 0x38, 0x3D,
  0xC1, 0xE0, 0xF7, 0x07, 0x87, 0x9C, 0x3E, 0x1E, 0x70, 0xF8, 0x79, 0xC3,
  0xE3, 0xC7, 0x1F, 0x8F, 0x1C, 0x7E, 0x38, 0x73, 0xF9, 0xE3, 0xCE, 0xE7,
  0x8F, 0x3B, 0xBC, 0x3D, 0xEE, 0xF0, 0xF7, 0x3B, 0x83, 0xDC, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0xE1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x0F, 0x78,
  0x07, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x00,
  0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x3C, 0x79, 0xE1, 0xDE, 0x0E,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0xF3,
  0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8F, 0x3C,
  0xF3, 0xC7, 0x1C, 0x70, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xC0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x39, 0xC3, 0xCE, 0x1C, 0x71,
  0xE3, 0xDE, 0x1E, 0xE0, 0x7F, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xF9, 0xE3,
  0xCF, 0x1C, 0x0F, 0x3C, 0x7E, 0xE3, 0xFF, 0x8F, 0x3E, 0x78, 0xF9, 0xE3,
  0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3,
  0xE3, 0xCF, 0x8F, 0xFC, 0x3F, 0x70, 0x79, 0xC0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xBC, 0x1F, 0xF8,
  0x7F, 0xE1, 0xE7, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x1E,
  0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x1E, 0x3C, 0xF9, 0xF3, 0xFF, 0x8F, 0xFC,
  0x39, 0xE0, 0x07, 0xE3, 0xFC, 0xFF, 0x1F, 0x27, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE2, 0x3F, 0xC3, 0xF8,
  0x7E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x07, 0x9C, 0x1F, 0xF8, 0x7F, 0xF0, 0xF3, 0xE3, 0xC7,
  0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1F, 0xF8, 0x3F, 0xF0, 0x3C, 0xE0, 0x07,
  0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF1, 0xEF, 0xFC, 0xFF,
  0x8F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x08, 0xFF, 0x87, 0xF8, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x03, 0xEF, 0x07, 0xEE, 0x0F, 0xFE, 0x0F, 0x3E, 0x1E,
  0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x1E,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0xC3, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x00, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0xBC, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0xCF, 0x9E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0x02, 0x03, 0x83,
  0xE1, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x00, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x7E,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x1F, 0x1E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xEF, 0x03, 0x8E, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0x1C, 0xF1, 0xE1, 0xDF, 0xBF, 0x1F, 0xFF, 0xF1, 0xF7,
  0xCF, 0x3E, 0x7C, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x8E, 0x38,
  0x70, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xE1, 0xC7,
  0x0E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xC0, 0x1C, 0xF0,
  0xEF, 0xC7, 0xFE, 0x3E, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38,
  0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x7B, 0xC3, 0x9E, 0x3C,
  0xF1, 0xE0, 0x0F, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF,
  0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x3C, 0x07, 0x7E, 0x07, 0xFE, 0x07, 0x9F,
  0x0F, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0,
  0x3D, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x0F, 0xBC, 0x7E, 0xE3, 0xFF, 0x8F, 0x3E, 0x78,
  0xF9, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C,
  0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0xFC, 0x3F, 0xF0, 0x7B, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1C, 0xF1,
  0xDE, 0x1F, 0xE1, 0xFE, 0x3F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xC4, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xCC, 0x78, 0xFF, 0x8F, 0xF0,
  0xFE, 0x00, 0x0E, 0x07, 0x07, 0x87, 0xF7, 0xFB, 0xFC, 0xF0, 0x78, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7E, 0x3F, 0x0F,
  0x80, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x79, 0xE3,
  0xCE, 0x1E, 0x70, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xE3,
  0xFF, 0x1F, 0xB8, 0x79, 0xC0, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x1C, 0xF3,
  0xCF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x0E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0xF1, 0xE1, 0xFE, 0x3C, 0x7B,
  0xCF, 0x8F, 0x71, 0xF1, 0xCE, 0x7E, 0x79, 0xCF, 0xCE, 0x39, 0xFB, 0xC7,
  0x77, 0x78, 0xEE, 0xEE, 0x1D, 0xDF, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x07, 0x1E, 0x07, 0xBC, 0x07, 0xBC, 0x07, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38,
  0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x87, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x38,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xF0, 0x00, 0x00, 0x0B, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0,
  0x20,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 11, 8, 12, 3, -22 },
  { 37, 16, 22, 15, 0, -22 },
  { 81, 14, 26, 13, 0, -24 },
  { 127, 19, 22, 22, 2, -22 },
  { 180, 16, 22, 16, 0, -22 },
  { 224, 5, 8, 8, 3, -22 },
  { 229, 11, 27, 8, 0, -22 },
  { 267, 10, 28, 8, -2, -23 },
  { 302, 12, 13, 13, 2, -24 },
  { 322, 13, 14, 14, 1, -18 },
  { 345, 7, 8, 7, -2, -4 },
  { 352, 9, 4, 9, 0, -10 },
  { 357, 5, 5, 7, 0, -5 },
  { 361, 16, 22, 12, -2, -22 },
  { 405, 12, 22, 13, 1, -22 },
  { 438, 10, 22, 13, 3, -22 },
  { 466, 15, 22, 13, -1, -22 },
  { 508, 14, 22, 13, 0, -22 },
  { 547, 14, 22, 13, 0, -22 },
  { 586, 14, 22, 13, 0, -22 },
  { 625, 13, 22, 13, 1, -22 },
  { 661, 14, 22, 13, 1, -22 },
  { 700, 14, 22, 13, 0, -22 },
  { 739, 13, 22, 13, 0, -22 },
  { 775, 7, 17, 8, 0, -17 },
  { 790, 10, 21, 8, -2, -17 },
  { 817, 13, 14, 14, 1, -18 },
  { 840, 13, 10, 14, 1, -16 },
  { 857, 13, 14, 14, 1, -18 },
  { 880, 11, 22, 10, 1, -22 },
  { 911, 19, 24, 20, 1, -22 },
  { 968, 15, 22, 15, -2, -22 },
  { 1010, 15, 22, 15, 0, -22 },
  { 1052, 15, 22, 14, 1, -22 },
  { 1094, 16, 22, 16, 0, -22 },
  { 1138, 14, 22, 12, 0, -22 },
  { 1177, 14, 22, 12, 0, -22 },
  { 1216, 16, 22, 16, 1, -22 },
  { 1260, 18, 22, 16, 0, -22 },
  { 1310, 13, 22, 10, -1, -22 },
  { 1346, 14, 29, 8, -5, -22 },
  { 1397, 17, 22, 14, 0, -22 },
  { 1444, 10, 22, 12, 0, -22 },
  { 1472, 23, 22, 22, 0, -22 },
  { 1536, 18, 22, 17, 0, -22 },
  { 1586, 16, 22, 17, 1, -22 },
  { 1630, 15, 22, 14, 0, -22 },
  { 1672, 16, 27, 17, 1, -22 },
  { 1726, 15, 22, 14, 0, -22 },
  { 1768, 15, 22, 13, -1, -22 },
  { 1810, 13, 22, 12, 2, -22 },
  { 1846, 16, 22, 16, 1, -22 },
  { 1890, 14, 22, 14, 3, -22 },
  { 1929, 22, 22, 22, 2, -22 },
  { 1990, 18, 22, 14, -2, -22 },
  { 2040, 13, 22, 13, 3, -22 },
  { 2076, 15, 22, 12, -1, -22 },
  { 2118, 12, 27, 9, -1, -22 },
  { 2159, 6, 22, 12, 3, -22 },
  { 2176, 12, 27, 9, -2, -22 },
  { 2217, 13, 13, 13, 0, -22 },
  { 2239, 11, 2, 10, -3, 3 },
  { 2242, 6, 5, 9, 4, -24 },
  { 2246, 14, 17, 14, 1, -17 },
  { 2276, 14, 24, 14, 0, -24 },
  { 2318, 11, 17, 11, 1, -17 },
  { 2342, 15, 24, 14, 1, -24 },
  { 2387, 12, 17, 13, 1, -17 },
  { 2413, 16, 31, 9, -4, -24 },
  { 2475, 16, 24, 14, -1, -17 },
  { 2523, 14, 24, 14, 0, -24 },
  { 2565, 9, 24, 7, 0, -24 },
  { 2592, 13, 31, 7, -4, -24 },
  { 2643, 15, 24, 13, 0, -24 },
  { 2688, 9, 24, 7, 0, -24 },
  { 2715, 20, 17, 21, 0, -17 },
  { 2758, 13, 17, 14, 0, -17 },
  { 2786, 12, 17, 14, 1, -17 },
  { 2812, 16, 24, 14, -2, -17 },
  { 2860, 14, 24, 14, 1, -17 },
  { 2902, 12, 17, 10, 0, -17 },
  { 2928, 12, 17, 11, 0, -17 },
  { 2954, 9, 20, 9, 1, -20 },
  { 2977, 13, 17, 14, 1, -17 },
  { 3005, 12, 17, 12, 2, -17 },
  { 3031, 19, 17, 19, 2, -17 },
  { 3072, 16, 17, 13, -2, -17 },
  { 3106, 16, 24, 12, -2, -17 },
  { 3154, 13, 17, 11, -1, -17 },
  { 3182, 13, 27, 10, 0, -22 },
  { 3226, 3, 31, 12, 4, -24 },
  { 3238, 12, 27, 10, -2, -22 },
  { 3279, 13, 6, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC31PT7B_H_
