#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x7B, 0xDE, 0xE7, 0x39,
  0xCE, 0x73, 0x19, 0xCE, 0x70, 0x03, 0xB8, 0x19, 0x81, 0xCC, 0x0E, 0xE0,
  0x67, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x0C, 0xC0, 0xE6, 0x06, 0x71, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF0, 0xCC, 0x0E, 0x60, 0x67, 0x03, 0x30, 0x39, 0x80,
  0x00, 0x80, 0x08, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xD6, 0x3B, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x5C, 0x85, 0xCC, 0x7C,
  0xFF, 0x8F, 0xF8, 0x7E, 0x00, 0x80, 0x08, 0x01, 0x00, 0x0C, 0x0E, 0x0F,
  0x06, 0x0F, 0xC7, 0x0E, 0xE3, 0x06, 0x73, 0x83, 0x3B, 0x81, 0x99, 0x81,
  0xCD, 0xC0, 0xEE, 0xCF, 0x7E, 0xEF, 0x9F, 0x6E, 0xE6, 0x76, 0x70, 0x33,
  0x38, 0x3B, 0x98, 0x19, 0xCC, 0x1C, 0xEE, 0x0C, 0x76, 0x0C, 0x3F, 0x0E,
  0x0F, 0x00, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70,
  0x77, 0x01, 0xF8, 0x0F, 0x80, 0xF9, 0xCF, 0xCE, 0xEF, 0xF7, 0x3F, 0x71,
  0xF3, 0x8F, 0x9C, 0x78, 0xFF, 0xE7, 0xFF, 0x1F, 0x3C, 0x7F, 0xEE, 0xEE,
  0xC0, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x03, 0x83, 0x83, 0x80, 0x0E, 0x03, 0x84, 0xE1, 0xF2, 0xFF, 0xCF,
  0xF3, 0xE1, 0xF8, 0xF7, 0x09, 0xE0, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x3B, 0xDC, 0xEE, 0x73, 0x00, 0x7E, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0xFC, 0x3F, 0x8F, 0x71,
  0xCE, 0x71, 0xCE, 0x39, 0xC7, 0x78, 0xEE, 0x3D, 0xC7, 0xB8, 0xE7, 0x1D,
  0xE7, 0xBC, 0xE3, 0xBC, 0x7F, 0x0F, 0xE0, 0xF8, 0x00, 0x03, 0x83, 0xC3,
  0xC3, 0xE3, 0xF7, 0xB9, 0xBC, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x00, 0x03, 0xC0, 0x7F, 0x1F, 0xF0,
  0xEF, 0x08, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xCF, 0xFC, 0xFF, 0x80,
  0x07, 0xC1, 0xFE, 0x1F, 0xE1, 0x9F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C,
  0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC8, 0x78,
  0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xDC, 0x19, 0xC3, 0xBC, 0x33, 0x86, 0x38, 0xFF,
  0xEF, 0xFC, 0xFF, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xF0, 0x3F, 0x83,
  0xFC, 0x23, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC8, 0x78, 0xFF, 0x8F,
  0xF0, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0xB8, 0xFF, 0x9F, 0xF3, 0xCF, 0x71, 0xCE, 0x39, 0xC7, 0x39, 0xE7,
  0x3C, 0xFF, 0x1F, 0xC1, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFE,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0xFE, 0x1F, 0xE1, 0xCF, 0x3C, 0xF3, 0xCE, 0x3C, 0xE1, 0xFC, 0x1F,
  0x81, 0xF0, 0x3F, 0x87, 0xBC, 0xF1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF,
  0x87, 0xF8, 0x3E, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0x71,
  0xCE, 0x3B, 0xCF, 0x79, 0xEF, 0xFC, 0xFF, 0x9F, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x3C, 0xFF, 0x1F, 0xC3, 0xF0, 0x00, 0x1C, 0xF3, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x3C, 0xF3, 0x80, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC7, 0x8E, 0x1C, 0x70, 0xE1, 0x80, 0x00, 0x20,
  0x0C, 0x07, 0x83, 0xF1, 0xF9, 0xF8, 0x3C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x3F, 0x1F, 0x8F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x0E, 0x3F, 0x9F,
  0xEC, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F,
  0x1E, 0x1C, 0x06, 0x18, 0x06, 0x31, 0xE7, 0x73, 0xF3, 0x67, 0x73, 0x66,
  0x67, 0xEE, 0x66, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF,
  0x78, 0xCE, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x40, 0x7F, 0xC0, 0x1F,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xD8, 0x0E,
  0xC0, 0xE6, 0x07, 0x78, 0x7B, 0xC3, 0x9E, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC,
  0xF1, 0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0xFC, 0x1E, 0x0F, 0x00, 0x7F, 0x07,
  0xFC, 0x38, 0xF1, 0xC7, 0x8E, 0x38, 0x71, 0xC7, 0x9E, 0x3F, 0xE1, 0xFC,
  0x0F, 0xF8, 0xF1, 0xC7, 0x8E, 0x38, 0x71, 0xC7, 0x8E, 0x3C, 0xFF, 0xC7,
  0xFC, 0x3F, 0xC0, 0x03, 0xE0, 0x7F, 0x1F, 0xE1, 0xE6, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x08, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x07,
  0xFC, 0x3F, 0xF1, 0xC7, 0x8E, 0x3C, 0x70, 0xE7, 0x8F, 0x3C, 0x79, 0xC3,
  0xCE, 0x1E, 0xF0, 0xE7, 0x8F, 0x3C, 0x79, 0xC7, 0x8E, 0x7C, 0xFF, 0xC7,
  0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x43, 0xF8, 0x3F,
  0x87, 0xF8, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x3E, 0x63, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x9F, 0xBC, 0xFD, 0xE7, 0xEF, 0x0E, 0x78, 0x73,
  0xC7, 0x9E, 0x3C, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x0E, 0x1E, 0x1C, 0x38,
  0x78, 0x70, 0xF0, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x1C, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xC3, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x3C,
  0x38, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0x87, 0x80, 0x0F, 0xE1, 0xFC, 0x7F,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x1F, 0xE3, 0xF8, 0x00, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0x60, 0x00, 0x0E, 0x1C,
  0x38, 0xF1, 0xE7, 0x87, 0x1C, 0x1C, 0xF0, 0x77, 0x81, 0xDC, 0x0F, 0xF0,
  0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7B, 0x81, 0xCE, 0x07, 0x3C,
  0x1C, 0xF0, 0xF1, 0xC3, 0xC7, 0x0E, 0x1E, 0x00, 0x0E, 0x0E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0xFF, 0xFF, 0xFF, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0x71, 0xD8, 0xFC, 0x3B, 0x1F,
  0x87, 0x67, 0x70, 0xEC, 0xEE, 0x1D, 0xFB, 0xC7, 0x3F, 0x70, 0xE7, 0xCE,
  0x1C, 0xF9, 0xC3, 0x9E, 0x38, 0xF3, 0xCF, 0x1C, 0x79, 0xC3, 0x8E, 0x38,
  0x00, 0x0F, 0x0E, 0x1E, 0x1C, 0x7C, 0x38, 0xF8, 0x71, 0xF1, 0xE3, 0xE3,
  0x87, 0xE7, 0x1D, 0xCE, 0x3B, 0x9C, 0x77, 0x78, 0xEE, 0xE1, 0xCD, 0xC7,
  0x1F, 0x8E, 0x3F, 0x1C, 0x7C, 0x38, 0xF8, 0xF1, 0xF1, 0xC1, 0xE3, 0x83,
  0xC0, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x3C, 0xF3, 0xC7, 0x9C, 0x3D, 0xE1,
  0xEE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE0, 0xEF, 0x0F, 0x78, 0x7B,
  0xC7, 0x9E, 0x3C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x87,
  0xFC, 0x3D, 0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0xF1, 0xFF,
  0x8F, 0xF8, 0xFF, 0x87, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x3C, 0xF3, 0xC7, 0x9C,
  0x3D, 0xE1, 0xEE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE0, 0xEF, 0x0F,
  0x78, 0x7B, 0xC7, 0x9E, 0x3C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C,
  0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0xFE, 0x3F, 0xC3, 0xF8, 0x7B,
  0x87, 0x38, 0x73, 0x87, 0x3C, 0xF3, 0xCF, 0x1C, 0xE1, 0xC0, 0x01, 0xE0,
  0x3F, 0xC3, 0xFC, 0x1E, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x0C, 0x78,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x1C, 0x38, 0xE1, 0xCF, 0x1E, 0x78, 0xF3,
  0x87, 0x9C, 0x39, 0xE1, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x39, 0xE1,
  0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x1E, 0x78, 0xFF, 0x83, 0xFC, 0x1F, 0x80,
  0xF0, 0x7F, 0x0F, 0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x38,
  0xF3, 0x8F, 0x70, 0xF7, 0x0F, 0xF0, 0x6E, 0x06, 0xE0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x00, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x1E, 0x3F,
  0x87, 0x8E, 0xE3, 0xE3, 0xB8, 0xF9, 0xCE, 0x3E, 0x73, 0x9F, 0xBC, 0xE7,
  0xCE, 0x3B, 0xB3, 0x8E, 0xED, 0xE3, 0xB3, 0x70, 0xFC, 0xDC, 0x3F, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x00,
  0x07, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x39, 0xE0, 0x7B, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFE,
  0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x70, 0x38, 0xE0, 0xF1, 0xC3, 0xC3, 0xC0,
  0xF0, 0xFE, 0x3D, 0xC7, 0x39, 0xE7, 0x38, 0xEF, 0x1D, 0xC3, 0xF8, 0x7E,
  0x0F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x21, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0x07, 0xC1,
  0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3F, 0x0F, 0xC0, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x73, 0x9C, 0xE7, 0x39,
  0xC6, 0x39, 0xCE, 0x07, 0xC1, 0xF0, 0xFC, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x3F, 0x0F, 0xC0, 0x01, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0xFC, 0x1F, 0x87, 0x71, 0xCE, 0x38, 0xEE, 0x1D, 0x83, 0xF0,
  0x70, 0xFF, 0xFF, 0xF7, 0x9C, 0x70, 0x0F, 0x71, 0xFF, 0x3F, 0xF3, 0x8E,
  0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF3, 0xC7, 0xFC,
  0x7F, 0xC7, 0xB8, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0E,
  0x71, 0xE7, 0x1C, 0x71, 0xCF, 0xF8, 0xFF, 0x8E, 0xF0, 0x1F, 0x9F, 0xDF,
  0x4E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x9F, 0xCF, 0xE3,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x3D,
  0xC3, 0xFE, 0x3D, 0xF1, 0xC7, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xF1,
  0xC7, 0x1E, 0x38, 0xF3, 0xC3, 0xFE, 0x1F, 0xE0, 0x7B, 0x00, 0x1F, 0x8F,
  0xE7, 0x9D, 0xC7, 0xF3, 0xBB, 0xEF, 0xF3, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0xCC, 0xFF, 0x1F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x00, 0x07,
  0xB8, 0x7F, 0xC7, 0xFE, 0x38, 0xE3, 0xC7, 0x1E, 0x38, 0xE3, 0xC7, 0x1E,
  0x38, 0xE3, 0xC7, 0x1E, 0x78, 0x7F, 0xC3, 0xFE, 0x1E, 0xE0, 0x07, 0x00,
  0x78, 0x83, 0xC7, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0xF9, 0xFF, 0x3F, 0xE7, 0x9C, 0xE3, 0x9C,
  0x77, 0x9E, 0xE3, 0xDC, 0x73, 0x8E, 0x71, 0xDE, 0x7B, 0x8E, 0x71, 0xC0,
  0x06, 0x1C, 0x78, 0x60, 0x00, 0x07, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F,
  0x1C, 0x38, 0x71, 0xE3, 0x87, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC3, 0xE0,
  0xF8, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0xF3, 0xCE, 0x39, 0xC3, 0xBC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0x78, 0x73, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0x0E, 0x1C, 0x38,
  0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71,
  0xE3, 0x87, 0x00, 0x1B, 0xEF, 0x1F, 0xFF, 0xCF, 0xFD, 0xE7, 0x9C, 0x73,
  0x8E, 0x79, 0xCF, 0x39, 0xE7, 0x1C, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE7,
  0x9C, 0xF3, 0x9E, 0x71, 0xCE, 0x38, 0xE7, 0x1C, 0x70, 0x1B, 0xE7, 0xFC,
  0xFF, 0x9E, 0x73, 0x8E, 0x71, 0xDE, 0x3B, 0x8F, 0x71, 0xCE, 0x39, 0xC7,
  0x79, 0xEE, 0x39, 0xC7, 0x00, 0x1F, 0x8F, 0xE7, 0xBD, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xEE, 0x7B, 0xFC, 0xFF, 0x1F, 0x00, 0x0D,
  0xF0, 0xEF, 0x87, 0xDC, 0x3C, 0xF1, 0xC7, 0x8E, 0x38, 0xF1, 0xC7, 0x0E,
  0x38, 0xF1, 0xC7, 0x0E, 0x78, 0xFF, 0xC7, 0xFC, 0x3B, 0xC1, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0x71, 0xFF, 0x3D,
  0xF3, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF3,
  0xC7, 0xFC, 0x7F, 0x87, 0xB8, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x1B, 0xCE, 0xE3, 0xF8, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x1F, 0xCF, 0xE3, 0x99,
  0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xC8, 0xF3, 0xFC, 0xFE,
  0x3F, 0x00, 0x1C, 0x38, 0x63, 0xFF, 0xE7, 0x1C, 0x38, 0x70, 0xE3, 0xC7,
  0x0E, 0x1C, 0x3E, 0x7C, 0xF8, 0x38, 0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1C,
  0xE3, 0xBC, 0xF7, 0x1C, 0xE3, 0x9C, 0x73, 0x9E, 0x7F, 0x8F, 0xB1, 0xEE,
  0x00, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xE7, 0x3B, 0x8E, 0xE3, 0xF0, 0xFC,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x73, 0xC7, 0x73, 0xC7, 0x73,
  0xCE, 0x77, 0xCE, 0x77, 0xDC, 0x6F, 0xDC, 0x6F, 0xDC, 0xED, 0xF8, 0xFD,
  0xF8, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1C,
  0x78, 0xE7, 0x87, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0xF7, 0x07, 0x38, 0x71, 0xE0, 0x0E, 0x3C,
  0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xE3, 0xF8,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x3F, 0x8F, 0xF1, 0xFE, 0x00, 0x00, 0x60, 0x78, 0x1F, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x80, 0x70,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04,
  0x01, 0xE0, 0xF8, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x7C, 0x07, 0x07, 0xC3, 0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0xFC, 0x3E, 0x0F, 0x00, 0x7C, 0x3F, 0xFF, 0x7F, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 10, 7, 10, 2, -19 },
  { 29, 13, 19, 12, 0, -19 },
  { 60, 12, 22, 11, 0, -20 },
  { 93, 17, 19, 18, 1, -19 },
  { 134, 13, 19, 13, 0, -19 },
  { 165, 4, 7, 6, 3, -19 },
  { 169, 9, 23, 7, 0, -19 },
  { 195, 9, 23, 7, -2, -19 },
  { 221, 10, 11, 11, 2, -20 },
  { 235, 11, 12, 12, 1, -15 },
  { 252, 5, 7, 6, -1, -3 },
  { 257, 7, 4, 7, 0, -9 },
  { 261, 4, 4, 6, 0, -4 },
  { 263, 13, 19, 10, -1, -19 },
  { 294, 11, 19, 11, 0, -19 },
  { 321, 9, 19, 11, 2, -19 },
  { 343, 12, 19, 11, -1, -19 },
  { 372, 12, 19, 11, 0, -19 },
  { 401, 12, 19, 11, 0, -19 },
  { 430, 12, 19, 11, 0, -19 },
  { 459, 11, 19, 11, 1, -19 },
  { 486, 12, 19, 11, 1, -19 },
  { 515, 12, 19, 11, 0, -19 },
  { 544, 11, 19, 11, 0, -19 },
  { 571, 6, 14, 6, 0, -14 },
  { 582, 7, 18, 6, -1, -14 },
  { 598, 11, 13, 12, 1, -16 },
  { 616, 11, 8, 12, 1, -13 },
  { 627, 11, 13, 12, 1, -16 },
  { 645, 9, 19, 9, 1, -19 },
  { 667, 16, 21, 17, 1, -19 },
  { 709, 13, 19, 12, -2, -19 },
  { 740, 13, 19, 12, 0, -19 },
  { 771, 12, 19, 11, 1, -19 },
  { 800, 13, 19, 13, 0, -19 },
  { 831, 12, 19, 10, 0, -19 },
  { 860, 12, 19, 10, 0, -19 },
  { 889, 13, 19, 14, 1, -19 },
  { 920, 15, 19, 14, 0, -19 },
  { 956, 11, 19, 8, -1, -19 },
  { 983, 11, 25, 6, -4, -19 },
  { 1018, 14, 19, 12, 0, -19 },
  { 1052, 8, 19, 10, 0, -19 },
  { 1071, 19, 19, 18, 0, -19 },
  { 1117, 15, 19, 15, 0, -19 },
  { 1153, 13, 19, 14, 1, -19 },
  { 1184, 13, 19, 12, 0, -19 },
  { 1215, 13, 23, 14, 1, -19 },
  { 1253, 12, 19, 12, 0, -19 },
  { 1282, 13, 19, 11, -1, -19 },
  { 1313, 10, 19, 10, 2, -19 },
  { 1337, 13, 19, 13, 1, -19 },
  { 1368, 12, 19, 12, 2, -19 },
  { 1397, 18, 19, 18, 2, -19 },
  { 1440, 15, 19, 11, -2, -19 },
  { 1476, 11, 19, 11, 2, -19 },
  { 1503, 13, 19, 10, -1, -19 },
  { 1534, 10, 23, 7, -1, -19 },
  { 1563, 5, 19, 10, 3, -19 },
  { 1575, 10, 23, 7, -2, -19 },
  { 1604, 11, 12, 11, 0, -19 },
  { 1621, 8, 2, 8, -2, 2 },
  { 1623, 5, 4, 8, 4, -20 },
  { 1626, 12, 14, 12, 0, -14 },
  { 1647, 12, 20, 12, 0, -20 },
  { 1677, 9, 14, 10, 1, -14 },
  { 1693, 13, 20, 12, 0, -20 },
  { 1726, 10, 14, 11, 1, -14 },
  { 1744, 13, 26, 7, -3, -20 },
  { 1787, 13, 20, 12, -1, -14 },
  { 1820, 11, 20, 12, 0, -20 },
  { 1848, 7, 20, 6, 0, -20 },
  { 1866, 10, 26, 6, -3, -20 },
  { 1899, 12, 20, 11, 0, -20 },
  { 1929, 7, 20, 6, 0, -20 },
  { 1947, 17, 14, 17, 0, -14 },
  { 1977, 11, 14, 12, 0, -14 },
  { 1997, 10, 14, 12, 1, -14 },
  { 2015, 13, 20, 12, -1, -14 },
  { 2048, 12, 20, 12, 0, -14 },
  { 2078, 10, 14, 8, 0, -14 },
  { 2096, 10, 14, 9, 0, -14 },
  { 2114, 7, 17, 8, 1, -17 },
  { 2129, 11, 14, 12, 1, -14 },
  { 2149, 10, 14, 10, 2, -14 },
  { 2167, 16, 14, 16, 1, -14 },
  { 2195, 13, 14, 11, -1, -14 },
  { 2218, 14, 20, 10, -2, -14 },
  { 2253, 11, 14, 9, -1, -14 },
  { 2273, 11, 23, 9, 0, -19 },
  { 2305, 3, 26, 10, 3, -20 },
  { 2315, 10, 23, 9, -2, -19 },
  { 2344, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC26PT7B_H_
